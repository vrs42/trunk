# EAGLE board tc08 (EAGLE 4.11), part 3 of 10
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
DB_03\  (via drill 0.61) (continued)
  Top 0.254: v329.73,52.31 318.04,52.31 316.52,53.84 D06.H1 | v330.74,41.14 332.27,39.61 v387.64,39.61 | v387.64,70.6 390.69,73.65 390.69,95.49 392.21,97.02 392.21,107.18 v391.2,107.18 | v390.18,201.66 390.18,219.95 324.14,219.95 v323.12,220.97 | v320.58,257.04 316.52,257.04 A06.H1 | v375.96,171.18 374.43,172.71 372.4,172.71 372.4,174.23 370.37,176.26 368.34,176.26 367.32,177.28 B02.L1
  Route15 0.254: v375.96,171.18 379,168.14 380.53,168.14 381.04,167.63 381.04,166.1 384.08,163.06 384.08,157.47 v391.7,149.85
  Bottom 0.254: v329.73,52.31 331.25,50.79 331.25,41.64 v330.74,41.14 | v387.64,39.61 388.15,40.12 388.15,51.8 386.62,53.33 386.62,69.58 v387.64,70.6 | v391.2,107.18 391.7,107.68 391.7,123.94 390.69,124.96 390.69,144.77 391.7,145.78 v391.7,149.85 390.69,150.86 390.69,152.39 389.67,153.4 389.67,179.31 390.69,180.33 390.69,185.41 389.16,186.93 389.16,199.63 389.67,200.14 389.67,201.16 v390.18,201.66 | v323.12,220.97 323.63,221.48 323.63,240.78 320.58,243.83 v320.58,257.04
DB_04\  (via drill 0.61)
  Top 0.254: v311.95,145.78 311.95,142.23 313.47,142.23 314.49,143.24 314.49,145.28 315.5,145.28 316.52,146.29 v325.16,146.29 | v327.19,143.75 327.7,144.26 364.78,144.26 v365.29,143.75 | v321.6,254.5 320.58,254.5 319.57,255.51 318.55,255.51 318.04,255 314.49,255 313.47,253.99 A06.J1 | v332.27,253.48 333.28,252.46 345.48,252.46 347,250.94 349.03,250.94 349.54,251.45 349.54,252.46 v350.05,252.46 | v359.19,218.43 361.73,215.89 365.8,215.89 v367.83,213.86
  Route2 0.254: v310.42,85.33 310.42,88.89 313.47,91.94 313.47,93.46 314.49,94.48 314.49,97.52 v313.47,98.54 | v321.6,254.5 325.66,250.43 327.7,252.46 331.25,252.46 v332.27,253.48
  Route15 0.254: v350.05,252.46 351.57,252.46 353.6,250.43 353.6,249.92 354.62,248.91 355.13,248.91 355.64,248.4 v355.64,244.84 | v367.83,213.86 365.29,211.32 366.3,210.3 366.3,205.73 368.34,203.7 368.34,198.62 373.42,193.54 373.42,192.52 374.43,191.5 374.43,189.47 v373.92,188.96 | v372.91,167.12 369.35,163.56 367.32,165.6 B02.R1
  Bottom 0.254: v310.42,85.33 310.42,85.84 312.46,85.84 312.96,85.33 312.96,73.65 311.44,72.12 311.44,52.31 312.46,51.3 D06.J1 | v313.47,98.54 311.44,100.57 311.44,145.28 v311.95,145.78 | v325.16,146.29 327.19,144.26 v327.19,143.75 | v365.29,143.75 365.29,163.56 366.3,164.58 B02.R1 | v355.64,244.84 355.64,243.83 361.22,238.24 361.22,237.22 360.72,236.72 358.68,236.72 358.68,233.67 359.19,233.16 v359.19,218.43 | v373.92,188.96 374.43,188.46 374.43,187.44 374.94,186.93 374.94,178.3 374.43,177.79 374.43,176.77 371.89,174.23 371.89,168.14 v372.91,167.12
DB_05\  (via drill 0.61)
  Top 0.254: v316.01,44.69 313.47,44.69 D06.L1 | v318.55,47.23 320.58,49.26 326.68,49.26 327.7,50.28 333.28,50.28 334.3,49.26 335.82,49.26 v337.86,51.3 | v376.46,126.48 378.5,128.51 380.53,128.51 381.54,127.5 382.56,127.5 384.59,129.53 384.59,138.67 382.56,138.67 380.02,141.21 v380.02,141.72 | v375.96,159.5 375.45,160.01 371.89,160.01 370.37,158.48 v370.37,157.47 | v308.39,247.89 312.46,247.89 A06.L1 | v307.38,268.21 310.93,268.21 311.44,268.72 315,268.72 315.5,268.21 316.52,268.21 317.03,268.72 321.09,268.72 321.6,268.21 323.12,268.21 323.63,268.72 327.7,268.72 328.2,268.21 v330.74,268.21 | v330.74,245.35 336.84,245.35 337.35,245.86 345.48,245.86 345.98,245.35 349.54,245.35 350.05,245.86 352.08,245.86 355.13,242.81 361.22,242.81 362.24,241.8 v364.78,241.8 | v379,205.22 379,204.71 377.99,203.7 377.99,199.12 372.91,194.04 371.89,194.04 371.38,193.54 371.38,192.01 375.96,192.01 v376.97,191 | v380.02,167.12 385.61,161.53 391.7,161.53 392.21,161.02 392.21,152.39 385.1,152.39 384.08,151.37 383.07,151.37 382.56,150.86 381.54,150.86 381.04,151.37 381.04,153.4 v382.05,153.4
  Route2 0.254: v318.55,47.23 v316.01,44.69 | v337.86,51.3 345.98,59.42 345.98,64 350.05,68.06 351.57,68.06 352.08,68.57 352.08,70.09 353.6,71.62 354.11,71.62 355.64,73.14 355.64,73.65 359.7,77.71 359.7,80.76 362.24,83.3 362.24,84.82 364.27,86.86 364.27,88.38 366.3,90.41 367.32,90.41 368.34,91.43 368.34,93.46 377.99,103.11 377.99,117.84 375.96,119.88 v376.46,120.38
  Route15 0.254: v376.46,120.38 376.46,121.4 379,123.94 v376.46,126.48 | v382.05,153.4 v375.96,159.5 | v365.29,237.73 365.29,233.67 365.8,233.16 365.8,231.64 368.34,229.1 368.34,223 369.35,221.98 369.35,216.4 379,206.74 v379,205.22 | v381.04,186.93 v376.97,191
  Bottom 0.254: v380.02,141.72 380.53,142.23 380.53,146.8 382.56,148.83 382.56,150.86 383.07,151.37 383.07,152.39 v382.05,153.4 | v370.37,157.47 370.37,161.53 B02.S1 | v308.39,247.89 307.88,248.4 307.88,248.91 307.38,249.42 307.38,252.97 307.88,253.48 307.88,267.7 v307.38,268.21 | v330.74,268.21 331.25,267.7 331.25,258.05 330.74,257.54 v330.74,245.35 | v364.78,241.8 365.29,241.29 v365.29,237.73 | v381.04,186.93 381.04,173.72 381.54,173.22 381.54,169.15 380.02,167.63 v380.02,167.12
DB_06\  (via drill 0.61)
  Top 0.254: v314.49,14.72 280.96,14.72 280.45,15.23 265.72,15.23 265.21,14.72 238.29,14.72 234.73,11.16 v234.73,10.66 | v231.68,10.66 230.67,9.64 204.25,9.64 203.24,10.66 191.04,10.66 190.03,9.64 131.1,9.64 v130.59,10.15 | v130.59,138.16 130.59,144.26 144.82,144.26 145.32,143.75 146.34,143.75 147.36,144.77 v151.42,144.77 | v158.02,289.04 159.55,289.04 160.56,288.02 214.92,288.02 216.44,289.55 216.44,295.64 239.3,295.64 241.34,293.61 250.99,293.61 252,292.6 255.56,292.6 256.58,293.61 264.7,293.61 266.23,292.09 281.98,292.09 283.5,293.61 293.66,293.61 294.17,294.12 306.36,294.12 306.87,294.63 v308.39,294.63 | v382.56,217.41 385.61,214.36 386.62,214.36 386.62,188.96 383.58,185.92 369.35,185.92 368.84,186.42 364.78,186.42 364.27,186.93 B02.H2 | v374.43,238.24 373.42,239.26 370.88,239.26 370.37,239.76 v316.01,239.76
  Bottom 0.254: v314.49,14.72 314.49,31.48 317.54,34.53 317.54,35.55 317.03,36.06 317.03,39.61 316.01,40.63 D06.M1 | v231.68,10.66 v234.73,10.66 | v130.59,138.16 v130.59,10.15 | v151.42,144.77 154.47,147.82 154.47,153.91 155.48,154.93 155.48,187.95 152.94,190.49 152.94,192.52 152.44,193.03 152.44,194.55 155.48,197.6 155.48,219.95 154.47,220.97 154.47,222.49 157.01,225.03 157.01,226.05 158.53,227.57 158.53,287.01 158.02,287.52 v158.02,289.04 | v308.39,294.63 314.49,294.63 314.49,248.91 315.5,247.89 315.5,244.84 A06.M1 316.01,243.83 v316.01,239.76 | v382.56,217.41 382.56,222.49 377.48,227.57 377.48,235.19 375.96,236.72 374.43,236.72 v374.43,238.24
DB_07\  (via drill 0.61)
  Top 0.254: v360.21,181.85 359.7,182.36 341.92,182.36 338.87,179.31 v315,179.31
  Bottom 0.254: 314.49,179.31 314.49,208.27 317.03,210.81 317.03,218.94 316.52,219.44 316.52,224.02 317.54,225.03 317.54,233.16 316.01,234.68 316.01,237.73 A06.P1 | 314.49,179.31 314.49,91.43 316.01,89.9 316.01,76.7 314.49,75.17 314.49,40.63 315,40.12 315,36.06 315.5,35.55 D06.P1 | v360.21,181.85 360.21,183.38 B02.J2 | v315,179.31 314.49,179.31
DB_08\  (via drill 0.61)
  Top 0.254: v316.52,16.24 333.79,16.24 334.81,15.23 v357.67,15.23 | v383.07,184.9 384.08,183.88 387.13,183.88 | 387.13,183.88 388.15,183.88 388.66,183.38 388.66,181.85 384.08,181.85 383.58,182.36 368.84,182.36 v367.32,180.84 | v364.78,167.12 364.27,166.61 362.75,166.61 360.72,168.64 360.72,170.68 B02.N2 | v318.55,231.64 316.52,231.64 A06.S1 | v322.62,282.44 367.32,282.44 367.83,282.94 v391.7,282.94 | v391.7,231.13 391.7,227.06 382.05,227.06 380.02,225.03 v378.5,225.03 | v381.54,218.94 382.05,218.43 383.58,218.43 387.13,214.87 387.13,183.88
  Route2 0.254: v382.05,140.7 382.56,140.7 384.08,142.23 384.08,144.77 389.16,149.85 389.16,184.39 v382.56,191
  Route15 0.254: v379,47.23 v376.46,44.69 | v381.04,54.34 388.15,61.46 387.13,62.47 387.13,64.5 386.62,65.01 386.62,72.63 388.15,74.16 388.15,94.98 387.64,95.49 387.64,108.19 382.05,113.78 382.05,115.81 381.04,116.83 381.04,117.84 384.59,121.4 385.61,121.4 388.15,123.94 388.15,133.08 382.05,139.18 v382.05,140.7
  Bottom 0.254: v316.52,16.24 317.54,17.26 317.54,26.4 316.01,27.93 D06.S1 | v357.67,15.23 371.89,15.23 371.89,26.91 374.94,29.96 374.94,43.17 v376.46,44.69 | v379,47.23 381.54,49.77 381.54,52.82 381.04,53.33 v381.04,54.34 | v382.56,191 384.08,189.47 384.08,185.92 v383.07,184.9 | v367.32,180.84 364.78,178.3 v364.78,167.12 | v318.55,231.64 318.04,232.14 318.04,233.67 317.54,234.18 317.54,235.7 318.04,236.21 318.04,240.27 317.54,240.78 317.54,242.81 318.04,243.32 318.04,246.37 317.54,246.88 317.54,248.91 318.04,249.42 318.04,252.97 317.54,253.48 317.54,255.51 318.04,256.02 318.04,259.07 317.54,259.58 317.54,277.36 v322.62,282.44 | v391.7,282.94 391.2,282.44 391.2,233.67 390.69,233.16 390.69,232.14 v391.7,231.13 | v378.5,225.03 380.02,223.51 380.53,223.51 381.54,222.49 v381.54,218.94
DB_09\  (via drill 0.61)
  Top 0.254: v282.99,61.96 280.45,59.42 275.88,59.42 275.37,58.92 v272.32,58.92 | v249.97,215.38 252.51,217.92 v265.21,217.92 | v282.48,242.3 283.5,241.29 285.02,241.29 286.55,239.76 290.1,239.76 v293.66,243.32 | v348.02,193.03 347.51,192.52 345.48,192.52 344.97,192.01 343.95,192.01 v341.41,194.55 | v314.49,247.38 314.49,249.42 301.79,249.42 v299.76,251.45
  Route2 0.254: v232.7,123.94 232.7,124.45 235.75,127.5 236.26,127.5 v237.27,128.51 | v237.27,139.69 237.27,141.72 237.78,142.23 237.78,145.78 238.8,146.8 238.8,147.31 241.84,150.36 241.84,151.88 244.38,154.42 244.38,158.99 249.97,164.58 250.48,164.58 250.99,165.09 250.99,167.63 254.04,170.68 v254.04,173.72 | v265.21,217.92 265.21,218.94 269.78,223.51 270.8,223.51 273.34,226.05 273.34,226.56 279.44,232.65 280.45,232.65 v281.47,231.64 | v293.66,243.32 293.66,245.35 v299.76,251.45 301.28,252.97 301.28,257.54 v305.85,262.12 | v341.41,194.55 342.94,196.08 342.94,199.12 337.86,204.2 337.35,203.7 v336.84,203.7
  Route15 0.254: v305.85,60.44 303.82,58.41 303.31,58.92 289.6,58.92 285.02,63.49 284.01,63.49 282.99,62.47 v282.99,61.96 | v256.58,74.66 v272.32,58.92 | v256.07,83.3 256.07,84.32 254.54,85.84 254.54,88.89 247.94,95.49 247.94,96 244.89,99.05 244.89,105.14 243.88,106.16 243.88,107.68 231.68,119.88 231.68,122.92 v232.7,123.94 | v255.05,177.28 255.05,178.8 254.04,179.82 254.04,186.93 252,188.96 251.5,188.96 247.94,192.52 247.94,197.09 241.84,203.19 241.84,204.71 241.34,205.22 241.34,208.78 244.38,211.82 244.89,211.32 245.91,211.32 v249.97,215.38 | v363.26,170.17 363.26,172.71 362.24,173.72 362.24,181.34 360.72,182.87 359.19,182.87 358.18,183.88 358.18,184.39 357.67,184.9 356.65,184.9 351.57,189.98 351.06,189.98 v348.02,193.03 | v334.81,210.81 330.24,215.38 329.22,215.38 324.14,220.46 324.14,221.98 322.11,224.02 321.09,224.02 v316.01,229.1
  Bottom 0.254: v305.85,60.44 305.85,62.98 D06.D2 | v256.58,74.66 255.56,75.68 255.56,82.79 v256.07,83.3 | v237.27,128.51 237.78,129.02 237.78,139.18 v237.27,139.69 | v254.04,173.72 254.04,174.74 255.05,175.76 v255.05,177.28 | v281.47,231.64 282.48,232.65 v282.48,242.3 | v305.85,262.12 305.85,266.18 A06.D2 | v363.26,170.17 363.26,168.64 B02.P2 | v336.84,203.7 334.81,205.73 v334.81,210.81 | v316.01,229.1 314.49,230.62 314.49,235.7 313.98,236.21 313.98,240.27 314.49,240.78 v314.49,247.38
DB_10\  (via drill 0.61)
  Top 0.254: v294.17,2.02 293.66,1.51 114.84,1.51 v114.34,2.02 | v86.4,134.61 86.9,135.12 102.65,135.12 108.75,141.21 118.4,141.21 121.45,144.26 v129.58,144.26 | v128.05,153.91 140.24,153.91 141.26,152.9 v142.28,152.9 | v144.82,161.53 146.85,163.56 149.9,163.56 v150.4,163.06 | v163.1,168.14 164.63,169.66 170.22,169.66 171.74,168.14 v173.26,168.14 | v245.4,212.33 252.51,212.33 v253.02,211.82 | v381.54,192.01 380.53,193.03 380.53,195.57 v381.04,195.57 | v391.7,232.65 391.7,278.37 v377.48,278.37 | v372.91,284.47 371.89,285.48 v332.78,285.48 | v333.28,266.69 332.78,267.2 327.19,267.2 326.17,268.21 324.14,268.21 323.63,267.7 320.08,267.7 319.57,268.21 317.54,268.21 317.03,267.7 313.98,267.7 313.47,268.21 311.95,268.21 v309.92,266.18
  Route2 0.254: v300.77,53.84 300.77,54.34 303.31,56.88 303.82,56.88 306.87,59.93 308.9,59.93 D06.E2 | v154.47,165.6 157.52,162.55 v163.1,168.14 | v173.26,168.14 176.82,164.58 178.34,166.1 186.98,166.1 188.5,164.58 202.22,178.3 203.24,178.3 218.98,194.04 218.98,195.57 222.03,198.62 222.03,200.14 229.65,207.76 231.68,207.76 236.26,212.33 240.83,212.33 242.35,210.81 243.88,210.81 v245.4,212.33 | v262.67,204.2 264.2,205.73 265.72,205.73 267.75,207.76 268.77,207.76 273.85,212.84 273.85,215.89 275.37,217.41 275.37,218.94 283.5,227.06 288.07,227.06 304.84,243.83 304.84,248.91 v309.41,253.48 | v379.51,186.93 377.99,185.41 377.99,180.33 368.34,170.68 368.34,164.07 361.73,157.47 363.26,155.94 B02.U2 | v381.04,207.25 381.04,208.27 381.54,208.78 381.54,214.87 383.58,216.9 383.58,222.49 390.69,229.6 390.69,231.64 v391.7,232.65
  Route15 0.254: v144.31,154.93 v142.28,152.9 | v253.02,211.82 254.04,211.82 261.15,204.71 262.16,204.71 v262.67,204.2
  Bottom 0.254: v300.77,53.84 298.74,51.8 298.74,6.59 v294.17,2.02 | v114.34,2.02 103.67,12.69 85.89,12.69 85.89,134.1 v86.4,134.61 | v129.58,144.26 128.05,145.78 v128.05,153.91 | v144.31,154.93 144.31,156.45 143.29,157.47 143.29,160.01 v144.82,161.53 | v150.4,163.06 153.45,163.06 154.47,164.07 v154.47,165.6 | v309.41,253.48 309.41,255 309.92,255.51 310.93,255.51 310.93,259.07 309.41,260.59 309.41,263.13 A06.E2 309.92,264.15 v309.92,266.18 | v379.51,186.93 381.54,188.96 v381.54,192.01 | v381.04,207.25 v381.04,195.57 | v377.48,278.37 372.91,282.94 v372.91,284.47 | v332.78,285.48 333.28,284.98 333.28,269.23 333.79,268.72 333.79,267.2 v333.28,266.69
DB_11\  (via drill 0.61)
  Top 0.254: v309.92,51.3 307.88,49.26 307.88,46.72 308.39,46.22 v312.46,46.22 | v329.73,36.56 v313.98,36.56 | v330.74,15.23 333.28,12.69 v371.89,12.69 | v381.04,47.23 379.51,48.76 377.48,48.76 376.97,49.26 v373.92,49.26 | v312.46,257.54 309.92,257.54 A06.H2 | v323.12,283.96 325.66,286.5 344.46,286.5 344.97,285.99 v380.53,285.99 | v388.15,239.26 388.15,234.68 388.66,234.18 388.66,232.65 384.08,232.65 383.58,233.16 375.45,233.16 374.94,232.65 374.94,231.13 v373.42,231.13
  Route2 0.254: v372.4,225.54 374.43,223.51 374.43,220.46 373.42,219.44 373.42,210.81 372.4,209.79 372.4,207.76 382.05,198.11 v382.05,196.58 | v383.07,179.31 375.96,172.2 375.45,172.2 374.94,171.69 374.94,170.68 371.89,167.63 371.89,161.53 364.27,153.91 361.73,153.91 360.72,152.9 B02.V2
  Route15 0.254: v373.92,59.93 374.94,60.95 374.94,61.46 379,65.52 379.51,65.52 383.07,69.08 380.53,71.62 380.53,72.63 373.92,79.24 v373.92,87.36 | v373.92,123.43 373.92,125.46 375.96,127.5 374.94,128.51 374.94,135.62 368.34,142.23 368.34,144.26 360.72,151.88 B02.V2 | v321.09,266.18 v312.46,257.54 | v389.67,253.99 389.67,246.88 390.18,246.37 390.18,245.35 v388.15,243.32 | v383.58,192.01 383.58,189.47 384.59,188.46 384.59,180.84 v383.07,179.31
  Bottom 0.254: v309.92,51.3 309.92,53.33 D06.H2 | v312.46,46.22 313.98,46.22 313.98,39.1 314.49,38.6 314.49,37.07 v313.98,36.56 | v329.73,36.56 330.74,35.55 v330.74,15.23 | v371.89,12.69 377.99,18.78 377.99,33.52 381.04,36.56 v381.04,47.23 | v373.92,49.26 374.43,49.77 374.43,59.42 v373.92,59.93 | v373.92,87.36 374.43,87.87 374.43,103.11 373.42,104.13 373.42,105.65 374.43,106.67 374.43,115.3 373.92,115.81 373.92,118.86 374.43,119.37 374.43,122.92 v373.92,123.43 | v321.09,266.18 323.63,268.72 323.63,283.45 v323.12,283.96 | v380.53,285.99 390.18,285.99 390.18,254.5 v389.67,253.99 | v388.15,239.26 v388.15,243.32 | v373.42,231.13 371.89,229.6 371.89,226.05 v372.4,225.54 | v382.05,196.58 384.08,194.55 384.08,192.52 v383.58,192.01
DF  (via drill 0.61)
  Top 0.254: v181.9,18.28 181.39,17.77 171.74,17.77 171.74,19.29 v167.17,19.29 | v143.29,74.66 132.62,74.66 132.12,75.17 121.45,75.17 v113.32,83.3 | v109.26,98.03 104.18,103.11 32.55,103.11 v15.28,120.38 | v15.28,195.06 15.28,198.62 v17.31,198.62 | v3.08,235.19 3.08,252.46 13.75,252.46 23.4,262.12 42.71,262.12 | 42.71,262.12 44.74,262.12 45.76,263.13 A26.E1 | v252,237.73 255.05,237.73 A10.P2 | v229.65,241.29 228.13,242.81 226.1,242.81 225.08,241.8 v220.51,241.8 | v211.87,250.43 210.35,251.96 209.33,251.96 208.82,252.46 v203.74,252.46 | v195.62,266.69 195.11,267.2 193.58,267.2 192.57,268.21 184.95,268.21 183.93,267.2 180.88,267.2 179.87,268.21 174.79,268.21 174.28,268.72 169.71,268.72 168.18,267.2 166.15,267.2 164.12,265.16 162.6,265.16 162.09,265.67 158.53,265.67 158.02,265.16 150.4,265.16 147.36,268.21 143.8,268.21 142.78,267.2 139.74,267.2 138.72,268.21 v137.2,268.21 | v103.67,294.12 103.16,294.63 74.2,294.63 v73.7,294.12 | v55.92,270.75 55.41,271.26 51.85,271.26 42.71,262.12
  Route2 0.254: v196.12,23.86 199.68,23.86 207.3,31.48 211.87,26.91 221.52,26.91 224.57,29.96 225.59,29.96 226.1,30.47 234.73,30.47 235.24,30.98 236.76,30.98 237.27,31.48 239.3,31.48 D11.R2 | v138.72,48.25 135.16,51.8 142.78,59.42 142.78,60.44 v143.29,60.95 | v252,237.73 250.99,237.73 249.97,236.72 242.35,236.72 241.84,236.21 241.84,234.68 v241.34,234.18 | v195.62,266.69 v198.16,264.15
  Route15 0.254: v12.74,205.22 11.21,205.22 10.2,206.24 10.2,207.76 v4.61,213.35 | v241.34,234.18 240.32,233.16 239.81,233.67 235.24,233.67 v233.72,232.14 | v211.87,250.43 v220.51,241.8
  Bottom 0.254: v196.12,23.86 188.5,23.86 186.98,22.34 186.98,17.77 181.9,17.77 v181.9,18.28 | v167.17,19.29 165.14,17.26 145.83,17.26 145.83,20.82 142.78,23.86 142.78,29.96 140.24,32.5 140.24,34.02 139.74,34.53 139.74,46.22 138.72,47.23 v138.72,48.25 | v143.29,74.66 v143.29,60.95 | v113.32,83.3 112.81,83.81 112.81,89.9 110.78,91.94 110.78,96.51 v109.26,98.03 | v15.28,120.38 15.78,120.89 15.78,194.55 v15.28,195.06 | v17.31,198.62 16.8,199.12 16.8,201.16 v12.74,205.22 | v4.61,213.35 5.12,213.86 5.12,233.16 v3.08,235.19 | v233.72,232.14 232.19,233.67 232.19,238.75 v229.65,241.29 | v203.74,252.46 203.24,252.97 203.24,255.51 203.74,256.02 203.74,258.56 v198.16,264.15 | v137.2,268.21 136.69,268.72 136.69,276.85 117.38,296.15 103.67,296.15 v103.67,294.12 | v73.7,294.12 59.98,294.12 59.98,295.14 59.47,295.64 56.42,295.64 56.42,274.82 56.93,274.31 56.93,271.77 v55.92,270.75
DF\  (via drill 0.61)
  Top 0.254: v250.48,217.92 v246.42,217.92 | v256.07,211.32 257.08,210.3 259.62,210.3 262.16,212.84 v262.16,213.35 | v266.74,218.94 v262.67,218.94 | v276.9,221.98 278.42,223.51 288.58,223.51 289.09,223 v289.09,221.48 | v291.12,216.4 300.77,216.4 301.79,217.41 313.47,217.41 v315.5,215.38 | v239.3,35.55 241.84,35.55 242.35,35.04 D11.P2 | v226.1,41.14 225.59,40.63 222.54,40.63 221.52,39.61 220,39.61 v218.48,41.14 | v218.48,29.45 217.97,29.96 213.4,29.96 v212.38,28.94 | v193.58,20.31 193.08,20.82 132.12,20.82 122.46,30.47 52.87,30.47 v3.08,80.25 | v4.1,231.64 18.83,246.37 50.33,246.37 v53.38,249.42 | v53.38,290.06 53.88,289.55 58.96,289.55 59.98,288.53 65.06,288.53 65.57,288.02 99.6,288.02 100.11,288.53 110.27,288.53 112.81,291.07 115.86,291.07 116.37,290.56 138.21,290.56 140.24,292.6 161.07,292.6 161.58,292.09 162.6,292.09 163.61,291.07 205.78,291.07 v206.28,291.58 | v223.56,215.89 223.56,210.81 v227.11,210.81
  Route2 0.254: v233.72,186.93 235.24,188.46 235.24,189.47 242.86,197.09 v242.86,197.6
  Route15 0.254: v250.48,217.92 251.5,217.92 v253.02,216.4 | v266.74,218.94 271.82,218.94 275.88,223 v276.9,221.98 | v315.5,215.38 316.52,215.38 322.11,209.79 324.65,209.79 328.2,206.24 B05.A1 | v234.22,40.63 v239.3,35.55 | v232.19,205.73 232.7,205.73 235.75,202.68 237.78,202.68 v242.86,197.6
  Bottom 0.254: v233.72,186.93 233.72,184.39 B12.J1 | v242.86,197.6 244.89,199.63 244.89,204.2 246.42,205.73 v246.42,217.92 | v253.02,216.4 255.05,214.36 255.05,212.33 v256.07,211.32 | v262.16,213.35 263.18,214.36 263.18,218.43 v262.67,218.94 | v289.09,221.48 291.12,219.44 v291.12,216.4 | v234.22,40.63 232.19,40.63 232.19,34.53 231.18,33.52 226.1,33.52 226.1,37.07 225.59,37.58 225.59,40.63 v226.1,41.14 | v218.48,41.14 218.98,40.63 218.98,29.96 v218.48,29.45 | v212.38,28.94 212.89,28.44 212.89,17.26 213.9,16.24 213.9,14.72 212.89,13.7 212.89,12.18 202.73,2.02 193.58,2.02 v193.58,20.31 | v3.08,80.25 3.59,80.76 3.59,146.8 2.58,147.82 2.58,202.68 3.59,203.7 3.59,206.74 2.58,207.76 2.58,230.11 v4.1,231.64 | v53.38,249.42 53.88,249.92 53.88,278.88 53.38,279.39 v53.38,290.06 | v206.28,291.58 207.3,290.56 210.86,290.56 210.86,275.83 212.89,273.8 212.89,269.23 215.43,266.69 215.94,266.69 215.94,266.18 219.49,262.62 219.49,256.02 222.03,253.48 222.03,237.22 221.52,236.72 221.52,233.16 222.54,232.14 222.54,224.02 223.56,223 v223.56,215.89 | v227.11,210.81 228.64,209.28 228.64,205.22 229.14,204.71 231.68,204.71 231.68,205.22 v232.19,205.73
DTB_00  (via drill 0.61)
  Top 0.254: v264.7,109.72 270.8,109.72 273.85,112.76 v274.86,112.76 | v52.36,279.9 53.38,280.91 58.46,280.91 59.47,279.9 83.86,279.9 84.36,280.4 114.84,280.4 v115.35,280.91 | v116.88,147.31 117.38,147.82 169.2,147.82 170.72,146.29 173.26,146.29 174.28,147.31 233.72,147.31 235.24,145.78 241.84,145.78 242.86,144.77 256.58,144.77 257.08,144.26 v258.61,144.26 | v264.2,131.56 273.34,131.56 274.36,130.54 C09.E1
  Bottom 0.254: v264.7,109.72 263.69,108.7 263.69,65.01 264.7,64 D09.D2 | v274.86,112.76 275.37,113.27 275.37,115.81 275.88,116.32 275.88,120.38 273.34,122.92 273.34,125.46 274.36,126.48 274.36,129.53 C09.E1 | v52.36,279.9 52.36,276.85 A25.A2 | v115.35,280.91 115.35,202.17 116.88,200.65 v116.88,147.31 | C10.B1 258.61,140.2 v258.61,144.26 262.67,144.26 263.18,143.75 263.18,132.58 v264.2,131.56
DTB_00\  (via drill 0.61)
  Top 0.254: v291.12,235.7 294.68,239.26 295.69,239.26 296.2,239.76 v296.71,239.76 | v300.77,243.83 300.77,245.86 304.84,245.86 305.34,245.35 308.39,245.35 308.9,245.86 311.44,245.86 v313.47,243.83 | v328.2,229.1 333.28,229.1 334.3,230.11 335.82,230.11 337.86,228.08 v339.38,228.08 | v353.1,214.36 v358.68,214.36
  Route2 0.254: v248.96,196.08 248.96,197.09 257.08,205.22 257.08,206.74 268.26,217.92 269.28,217.92 269.78,218.43 271.31,218.43 275.88,223 278.42,223 v291.12,235.7 | v358.68,214.36 364.27,214.36 367.83,210.81 368.34,211.32 369.35,211.32 370.88,209.79 370.88,207.25 370.37,206.74 B02.A1
  Route15 0.254: v248.96,196.08 254.04,191 255.05,191 256.07,189.98 256.07,188.96 260.64,184.39 260.64,179.82 262.16,178.3 260.13,176.26 258.1,176.26 258.1,174.74 260.64,172.2 260.64,167.12 261.15,166.61 261.15,165.09 266.74,159.5 266.74,152.9 268.26,151.37 268.26,150.36 273.34,145.28 273.34,135.62 275.37,133.59 271.82,130.04 271.82,127.5 C09.F1 | v313.47,243.83 v328.2,229.1 | v339.38,228.08 v353.1,214.36
  Bottom 0.254: v296.71,239.76 297.72,239.76 298.23,239.26 301.28,239.26 301.28,243.32 v300.77,243.83
DTB_01  (via drill 0.61)
  Top 0.254: v274.36,49.26 273.85,49.26 273.34,48.76 269.28,48.76 268.77,48.25 D09.K2 | v277.91,280.4 277.4,279.9 235.75,279.9 235.24,280.4 199.68,280.4 199.17,279.9 172.25,279.9 171.74,280.4 145.32,280.4 144.82,280.91 143.8,280.91 142.28,279.39 126.02,279.39 125.51,278.88 85.89,278.88 85.38,278.37 49.31,278.37 49.31,273.8 A25.B2 | v278.42,127.5 277.4,126.48 274.86,126.48 v272.32,123.94 268.77,123.94 C09.H2 267.75,123.94 262.67,123.94 C10.H1
  Bottom 0.254: v274.36,49.26 275.88,50.79 275.88,60.44 276.9,61.46 276.9,94.98 276.39,95.49 276.39,107.18 273.34,110.22 273.34,121.91 272.32,122.92 v272.32,123.94 | v277.91,280.4 277.91,221.48 276.9,220.46 276.9,193.03 277.4,192.52 277.4,137.15 277.91,136.64 277.91,128 v278.42,127.5
DTB_01\  (via drill 0.61)
  Top 0.254: v268.26,121.4 266.23,121.4 265.72,120.89 C09.J2
  Route2 0.254: v268.26,121.4 271.82,124.96 273.34,124.96 273.85,125.46 274.86,125.46 277.91,128.51 280.96,128.51 282.99,130.54 282.99,131.56 293.15,141.72 293.15,143.24 298.74,148.83 300.26,148.83 301.79,150.36 301.79,155.94 308.9,163.06 312.46,163.06 316.52,158.99 319.06,161.53 319.57,161.53 320.08,162.04 320.08,163.56 321.09,164.58 322.62,164.58 327.7,169.66 329.73,169.66 332.78,172.71 332.78,177.79 v339.38,184.39 | v342.43,180.84 343.95,182.36 345.48,182.36 346.49,183.38 346.49,206.24 v347.51,207.25
  Route15 0.254: v339.38,184.39 339.38,183.88 v342.43,180.84 | v347.51,207.25 358.18,217.92 358.68,217.41 364.78,217.41 v365.29,217.92
  Bottom 0.254: v365.29,217.92 366.3,216.9 366.3,203.7 B02.B1
DTB_02  (via drill 0.61)
  Top 0.254: v62.01,268.21 53.88,268.21 52.87,269.23 A25.C2 | v63.03,147.82 63.54,148.32 240.32,148.32 243.37,145.28 v257.59,145.28 | v257.59,123.43 259.12,121.91 260.13,121.91 261.66,120.38 263.18,120.38 268.77,114.8 | 268.77,114.8 269.28,114.29 C09.L1 | 268.77,114.8 268.26,114.8 262.16,108.7 259.12,108.7 C10.N1
  Bottom 0.254: v62.01,268.21 62.01,255 61.5,254.5 61.5,150.86 62.01,150.36 62.01,149.34 63.03,148.32 v63.03,147.82 | v257.59,123.43 v257.59,145.28 | D09.R2 265.21,32.5 263.69,34.02 263.69,61.46 260.13,65.01 260.13,106.16 259.12,107.18 C10.N1
DTB_02\  (via drill 0.61)
  Top 0.254: v274.36,115.3 274.86,115.81 275.37,115.81 275.88,116.32 275.88,120.38 v274.36,120.38 | v255.56,149.85 255.56,151.88 v255.05,151.88 | v312.46,226.05 313.47,227.06 v320.08,227.06 | v334.3,233.16 356.14,233.16 v356.65,233.67 | v358.18,229.1 v354.11,225.03
  Route2 0.254: v255.05,151.88 252.51,154.42 252.51,156.45 254.04,157.98 254.04,164.07 260.13,170.17 260.13,176.26 263.18,179.31 263.18,185.92 266.23,188.96 267.75,188.96 269.28,190.49 269.28,192.01 275.88,198.62 275.88,200.65 282.99,207.76 285.02,207.76 293.66,216.4 300.77,216.4 301.79,217.41 303.82,217.41 v312.46,226.05 | v320.08,227.06 320.58,227.06 324.14,230.62 325.16,230.62 327.7,233.16 329.22,233.16 329.73,233.67 333.79,233.67 v334.3,233.16 | v355.64,210.3 355.64,204.2 359.7,200.14 360.72,200.14 361.73,199.12 361.73,196.58 363.26,195.06 364.27,195.06 367.32,192.01 366.3,191 B02.F1
  Route15 0.254: v274.36,120.38 271.31,123.43 271.31,124.96 270.29,125.97 270.29,131.56 258.61,143.24 258.1,143.24 256.58,144.77 256.58,148.83 v255.56,149.85 | v354.11,225.03 351.57,222.49 v355.64,218.43
  Bottom 0.254: v274.36,115.3 273.85,114.8 273.85,112.26 274.36,111.75 C09.M1 | v356.65,233.67 358.18,233.67 358.18,233.16 358.68,232.65 358.68,229.6 v358.18,229.1 | v355.64,218.43 356.14,217.92 356.14,210.81 v355.64,210.3
DTB_03  (via drill 0.61)
  Top 0.254: v59.47,146.29 72.17,146.29 73.19,147.31 114.34,147.31 115.86,145.78 118.91,145.78 119.92,146.8 166.66,146.8 168.18,145.28 172.25,145.28 172.76,144.77 197.65,144.77 198.66,145.78 209.84,145.78 210.86,144.77 v240.32,144.77 | v241.34,127.5 242.86,125.97 244.89,125.97 245.4,125.46 252,125.46 | 252,125.46 257.08,120.38 257.08,119.37 257.59,118.86 257.59,106.67 262.67,106.67 264.7,104.64 267.75,104.64 C09.P2 | v272.83,129.53 272.32,129.02 269.28,129.02 268.77,128.51 263.69,128.51 263.18,128 262.16,128 259.62,125.46 252,125.46
  Bottom 0.254: v59.47,146.29 59.47,149.85 59.98,150.36 59.98,226.56 54.39,232.14 54.39,238.24 50.84,241.8 50.84,261.1 50.33,261.61 50.33,265.67 49.82,266.18 A25.D2 | v240.32,144.77 240.83,144.26 240.83,140.7 241.34,140.2 241.34,138.16 240.32,137.15 240.32,135.12 241.34,134.1 v241.34,127.5 | v272.83,129.53 272.83,134.61 274.36,136.13 C09.C1
DTB_03\  (via drill 0.61)
  Top 0.254: v265.21,105.65 267.24,107.68 v267.75,107.68 | v360.72,129.02 361.22,128.51 v363.26,128.51 | v382.05,151.88 382.56,152.39 384.08,152.39 384.59,152.9 384.59,158.99 v382.05,158.99 | v378.5,173.22 373.92,173.22 372.91,174.23 372.91,176.26 372.4,176.26 371.38,177.28 371.38,179.31 371.89,179.31 v372.4,179.82
  Route2 0.254: v267.75,107.68 268.26,107.68 275.37,114.8 275.37,115.81 275.88,116.32 275.88,119.37 294.68,138.16 294.68,138.67 297.22,141.21 297.72,141.21 308.39,151.88 310.42,151.88 311.95,153.4 314.49,153.4 315,153.91 319.57,153.91 v322.11,151.37 | v363.26,128.51 364.78,128.51 375.45,139.18 376.46,139.18 376.97,139.69 376.97,141.21 377.99,142.23 377.99,144.77 379,145.78 379,148.83 v382.05,151.88
  Route15 0.254: v322.11,151.37 323.63,149.85 326.68,149.85 331.76,144.77 333.79,144.77 339.89,138.67 340.4,138.67 340.9,138.16 347,138.16 350.05,135.12 354.62,135.12 356.14,133.59 356.14,133.08 357.67,131.56 358.18,131.56 v360.72,129.02 | v382.05,158.99 v377.99,163.06 | v372.4,179.82 371.38,180.84 371.38,182.87 v370.37,183.88
  Bottom 0.254: v265.21,105.65 265.21,102.1 C09.R2 | v377.99,163.06 377.99,172.71 v378.5,173.22 | v370.37,183.88 370.37,186.93 B02.H1
DTB_04  (via drill 0.61)
  Top 0.254: v114.34,259.07 92.49,259.07 91.98,258.56 77.25,258.56 74.2,261.61 69.12,261.61 68.62,262.12 53.88,262.12 52.87,263.13 A25.E2 | v115.86,144.77 116.37,145.28 119.42,145.28 120.43,146.29 166.15,146.29 167.68,144.77 169.71,144.77 170.22,144.26 198.16,144.26 199.17,145.28 209.33,145.28 210.35,144.26 233.72,144.26 v234.22,143.75 | v236.76,119.88 237.27,119.37 256.07,119.37 257.08,118.35 257.08,106.16 258.1,106.16 264.2,100.06 267.24,100.06 267.75,100.57 270.29,100.57 271.82,99.05 274.36,99.05 C09.S1 | v256.58,132.07 262.16,132.07 263.69,130.54 267.75,130.54 C09.E2 | v256.58,153.4 256.07,153.91 236.76,153.91 v236.26,153.4
  Bottom 0.254: v114.34,259.07 114.84,258.56 114.84,201.66 116.37,200.14 116.37,148.32 115.86,147.82 v115.86,144.77 | v236.76,119.88 234.73,121.91 234.73,143.24 v234.22,143.75 236.26,145.78 v236.26,153.4 | v256.58,132.07 257.08,132.58 257.08,144.26 256.58,144.77 v256.58,153.4
DTB_04\  (via drill 0.61)
  Top 0.254: v284.01,45.2 284.01,44.18 285.53,42.66 291.12,42.66 292.14,41.64 292.14,40.12 291.63,40.12 v287.56,36.06 | v288.07,29.96 288.58,30.47 303.31,30.47 v303.82,30.98 | v305.85,28.94 307.88,26.91 v311.44,26.91 | v318.04,9.64 319.06,8.62 385.1,8.62 389.16,12.69 389.67,12.69 390.69,13.7 390.69,44.18 383.58,44.18 v383.07,44.69 | v388.66,59.93 391.7,62.98 v391.7,94.98
  Route2 0.254: v281.98,48.76 281.98,47.23 v284.01,45.2 | v305.85,28.94 v303.82,30.98 | v383.07,44.69 383.07,45.71 384.08,46.72 384.08,55.36 v388.66,59.93
  Route15 0.254: v273.85,88.38 273.85,76.19 275.88,74.16 275.88,65.52 284.01,57.39 284.01,56.38 v281.98,54.34 | v391.7,94.98 391.7,104.64 392.21,105.14 392.21,123.43 390.69,124.96 390.69,144.77 389.67,145.78 389.67,147.31 v383.58,153.4 | v382.05,163.56 379,163.56 375.96,166.61 375.45,166.61 371.89,170.17 371.89,172.71 370.37,174.23 B02.M1
  Bottom 0.254: v273.85,88.38 273.85,90.92 274.36,91.43 C09.U1 | v281.98,54.34 282.48,53.84 282.48,49.26 v281.98,48.76 | v287.56,36.06 288.58,35.04 288.58,30.47 v288.07,29.96 | v311.44,26.91 311.44,23.36 313.98,20.82 313.98,15.74 313.47,15.23 313.47,14.21 v318.04,9.64 | v383.58,153.4 384.08,153.91 384.08,162.55 383.07,163.56 v382.05,163.56
DTB_05  (via drill 0.61)
  Top 0.254: v61,261.1 60.49,261.61 50.84,261.61 49.82,260.59 A25.F2 | v61,281.93 61.5,281.42 78.27,281.42 78.78,281.93 112.81,281.93 113.83,282.94 140.75,282.94 141.26,283.45 147.36,283.45 147.86,282.94 174.28,282.94 174.79,282.44 196.63,282.44 197.14,282.94 220.51,282.94 221.52,283.96 v241.34,283.96 | v262.67,146.8 263.18,147.31 272.83,147.31 274.36,145.78 280.96,145.78 v281.47,145.28 | v283.5,120.38 281.98,121.91 272.32,121.91 271.82,121.4 C09.J1 271.31,119.88 271.31,116.83 271.82,116.32 272.83,116.32 272.83,113.27 272.32,112.76 267.75,112.76 v265.72,110.73 | v262.67,88.89 C09.V2
  Bottom 0.254: v61,281.93 v61,261.1 | v241.34,283.96 241.34,263.13 244.38,260.08 244.38,258.05 250.99,251.45 250.99,232.14 257.08,226.05 257.08,223.51 257.59,223 257.59,220.46 260.13,217.92 260.13,193.03 260.64,192.52 260.64,172.71 263.18,170.17 263.18,147.31 v262.67,146.8 | v281.47,145.28 282.48,144.26 282.48,132.07 282.99,131.56 282.99,120.89 v283.5,120.38 | v262.67,88.89 263.18,89.4 263.18,109.72 264.2,110.73 v265.72,110.73
DTB_05\  (via drill 0.61)
  Top 0.254: v296.71,107.68 298.23,109.21 312.46,109.21 314.49,111.24 314.49,111.75 315.5,112.76 319.57,112.76 322.11,115.3 v322.11,115.81 | v356.65,164.58 357.16,164.07 359.19,164.07 359.7,163.56 367.32,163.56 368.34,164.58 368.34,170.68 366.81,170.68 B02.N1
  Route2 0.254: v296.71,107.68 292.14,103.11 292.14,101.59 291.63,101.08 291.12,101.08 288.07,98.03 286.55,98.03 277.91,89.4 271.82,89.4 C09.V1 | v322.11,115.81 321.6,115.81 319.06,118.35 325.16,124.45 326.17,124.45 330.24,128.51 330.74,128.51 331.25,129.02 331.25,131.56 332.27,132.58 332.27,136.64 333.28,137.66 333.28,140.7 338.87,146.29 338.87,146.8 349.03,156.96 349.03,157.98 350.56,159.5 351.57,159.5 v356.65,164.58
DTB_06  (via drill 0.61)
  Top 0.254: 51.34,290.56 51.85,291.07 53.88,291.07 54.9,290.06 59.47,290.06 60.49,289.04 65.57,289.04 66.08,288.53 99.1,288.53 99.6,289.04 109.76,289.04 112.3,291.58 116.37,291.58 116.88,291.07 137.7,291.07 140.24,293.61 146.34,293.61 146.85,293.1 161.58,293.1 162.09,292.6 163.1,292.6 164.12,291.58 196.63,291.58 v197.14,292.09 | 51.34,290.56 v50.84,290.06 | v196.12,247.89 196.12,246.37 224.57,246.37 v225.08,246.88 | v225.08,243.32 229.14,243.32 v231.18,241.29 | v244.89,205.73 247.43,205.73 248.45,204.71 v259.12,204.71 | v264.2,193.03 265.72,191.5 267.75,191.5 v268.26,191 | v229.65,63.49 228.13,61.96 168.18,61.96 166.66,63.49 v165.64,63.49 | v153.45,58.41 140.75,58.41 140.24,58.92 56.42,58.92 v30.52,84.82 | v20.86,289.04 22.39,290.56 51.34,290.56
  Route2 0.254: v268.77,106.67 267.75,106.67 265.72,104.64 264.7,104.64 257.59,97.52 257.59,96.51 v240.83,79.74 | v165.64,63.49 163.61,65.52 160.06,61.96 159.55,61.96 159.04,61.46 157.52,61.46 154.98,58.92 153.96,58.92 v153.45,58.41
  Route15 0.254: v231.18,241.29 232.7,239.76 238.8,239.76 v240.83,237.73 | v259.12,204.71 259.62,204.71 v261.66,202.68 | v268.26,191 272.83,195.57 274.36,194.04 B09.E1 | v239.3,76.7 237.27,74.66 235.24,74.66 232.19,71.62 232.19,69.58 v230.16,69.58
  Bottom 0.254: v50.84,290.06 50.84,263.13 51.34,262.62 51.34,258.05 51.85,257.54 A25.H2 | v197.14,292.09 197.14,250.43 196.12,249.42 v196.12,247.89 | v225.08,246.88 v225.08,243.32 | v240.83,237.73 241.84,236.72 241.84,235.19 244.38,232.65 244.38,230.11 243.88,229.6 243.88,226.56 244.89,225.54 244.89,216.4 244.38,215.89 244.38,206.24 v244.89,205.73 | v261.66,202.68 263.69,200.65 263.69,193.54 v264.2,193.03 | v268.77,106.67 268.77,110.73 C09.M2 | v240.83,79.74 240.32,79.24 240.32,77.71 v239.3,76.7 | v230.16,69.58 228.64,68.06 228.64,65.01 229.65,64 v229.65,63.49 | v30.52,84.82 16.29,99.05 16.29,200.14 10.2,206.24 10.2,217.41 16.29,223.51 16.29,284.47 v20.86,289.04
DTB_06\  (via drill 0.61)
  Top 0.254: v291.12,212.33 292.14,213.35 315,213.35 v319.06,217.41 | v325.66,226.05 326.68,227.06 345.48,227.06 v347.51,225.03
  Route2 0.254: v271.82,193.03 273.34,194.55 275.37,194.55 289.6,208.78 289.6,211.32 290.61,212.33 v291.12,212.33 | v321.6,222.49 322.11,222.49 v325.66,226.05
  Route15 0.254: v347.51,225.03 v354.11,218.43 | v355.13,213.35 360.21,208.27 360.21,205.73 361.73,204.2 361.73,198.62 360.72,197.6 B02.D2
  Bottom 0.254: v271.82,193.03 271.82,190.49 B09.F1 | v319.06,217.41 320.58,218.94 320.58,220.46 321.6,221.48 v321.6,222.49 | v354.11,218.43 355.13,217.41 v355.13,213.35
DTB_07  (via drill 0.61)
  Top 0.254: v58.46,252.46 50.84,252.46 49.82,253.48 A25.J2 | v59.98,282.94 61.5,282.94 62.52,281.93 77.76,281.93 78.27,282.44 112.3,282.44 113.32,283.45 140.24,283.45 140.75,283.96 152.44,283.96 152.94,283.45 174.79,283.45 175.3,282.94 196.12,282.94 196.63,283.45 220,283.45 221.02,284.47 240.32,284.47 240.83,284.98 254.54,284.98 257.59,281.93 258.1,281.93 258.61,281.42 258.61,280.4 276.39,280.4 277.4,281.42 280.96,281.42 282.48,279.9 293.15,279.9 293.66,280.4 v386.12,280.4 | v388.15,150.36 384.08,150.36 383.58,149.85 330.24,149.85 326.17,153.91 312.46,153.91 309.92,151.37 309.92,149.85 304.84,149.85 303.31,151.37 301.79,151.37 300.77,150.36 284.52,150.36 283.5,151.37 282.48,151.37 280.96,149.85 267.75,149.85 265.72,151.88 B09.V2 | v286.04,105.14 285.02,106.16 276.39,106.16 275.37,105.14 C09.P1 | v287.56,86.35 288.07,86.86 294.68,86.86 295.18,86.35 322.11,86.35 322.62,86.86 345.48,86.86 345.98,86.35 355.64,86.35 356.14,85.84 368.84,85.84 369.35,85.33 373.92,85.33 379,90.41 v386.12,90.41
  Bottom 0.254: v58.46,252.46 58.96,252.97 58.96,255 59.98,256.02 59.98,266.69 60.49,267.2 60.49,280.91 59.98,281.42 v59.98,282.94 | v386.12,280.4 388.15,278.37 388.15,252.46 387.64,251.96 387.64,245.86 387.13,245.35 387.13,235.7 388.66,234.18 388.66,233.16 387.64,232.14 387.64,202.17 387.13,201.66 387.13,184.9 388.66,183.38 388.66,182.36 387.64,181.34 387.64,150.86 v388.15,150.36 388.15,147.31 387.13,146.29 387.13,140.2 387.64,139.69 387.64,104.13 386.62,103.11 386.62,90.92 v386.12,90.41 | v286.04,105.14 286.04,87.87 v287.56,86.35
DTB_07\  (via drill 0.61)
  Top 0.254: v304.33,211.82 305.34,212.84 v316.01,212.84 | v327.19,218.94 v336.33,218.94 | v347.51,212.33 v358.68,212.33
  Route2 0.254: v271.31,155.94 275.88,160.52 275.88,163.56 295.18,182.87 295.18,187.44 295.69,187.95 295.69,190.49 297.22,192.01 297.72,192.01 298.23,192.52 298.23,197.6 298.74,198.11 298.74,203.7 304.33,209.28 304.84,209.28 305.34,209.79 305.34,210.81 v304.33,211.82 | v316.01,212.84 317.03,212.84 322.11,217.92 323.12,217.92 323.63,218.43 326.68,218.43 v327.19,218.94 | v336.33,218.94 340.9,218.94 v347.51,212.33
  Route15 0.254: v358.68,212.33 358.68,210.81 360.72,208.78 360.72,206.24 362.24,204.71 362.24,195.06 363.26,194.04 B02.E2
  Bottom 0.254: v271.31,155.94 271.31,152.39 B09.V1
DTB_08  (via drill 0.61)
  Top 0.254: v236.76,77.71 v261.66,77.71 | v231.18,70.6 230.67,71.11 201.71,71.11 v201.2,70.6 | v253.02,143.75 252.51,144.26 247.43,144.26 245.91,142.74 244.89,142.74 244.38,143.24 244.38,144.26 v241.84,144.26 | v17.82,249.42 34.07,249.42 37.12,252.46 46.77,252.46 47.28,251.96 50.84,251.96 51.85,250.94 A25.K2 | v12.74,224.52 11.72,223.51 9.69,223.51 3.08,216.9 3.08,211.82 4.1,210.81 v11.21,210.81 | v11.21,206.74 3.59,199.12 3.59,131.56 v17.31,131.56 | v19.34,103.62 47.79,75.17 108.24,75.17 112.3,71.11 164.63,71.11 v165.14,70.6
  Route2 0.254: v234.73,72.63 233.21,72.63 v231.18,70.6 | v271.82,173.72 270.29,172.2 270.29,167.63 259.62,156.96 259.62,153.4 261.15,151.88 v253.02,143.75
  Route15 0.254: v262.16,86.35 263.69,87.87 263.69,89.4 v265.21,90.92 260.64,95.49 260.64,96.51 247.94,109.21 247.94,110.22 247.43,110.73 247.43,128 v242.35,133.08 | v17.82,249.42 17.82,249.92 v15.28,252.46 | v165.14,70.6 166.15,71.62 174.28,71.62 176.82,69.08 177.84,69.08 178.34,68.57 195.11,68.57 199.17,72.63 v201.2,70.6
  Bottom 0.254: v265.21,90.92 265.21,94.48 C09.T2 | v262.16,86.35 261.15,85.33 261.15,78.22 v261.66,77.71 | v236.76,77.71 235.75,76.7 235.75,74.66 234.73,73.65 v234.73,72.63 | v271.82,173.72 271.82,176.77 B09.L1 | v241.84,144.26 241.34,143.75 241.34,141.21 241.84,140.7 241.84,137.66 241.34,137.15 241.34,135.12 242.35,134.1 v242.35,133.08 | v15.28,252.46 12.74,252.46 v12.74,224.52 | v11.21,206.74 v11.21,210.81 | v17.31,131.56 19.34,129.53 v19.34,103.62
DTB_08\  (via drill 0.61)
  Top 0.254: v289.09,175.25 288.58,175.76 283.5,175.76 282.99,175.25 275.88,175.25 275.37,174.74 B09.M1 | v287.56,194.55 288.07,195.06 295.69,195.06 v297.22,196.58 | v304.33,210.3 305.34,211.32 v319.06,211.32 | v329.73,209.79 330.24,209.28 v336.84,209.28 | v348.02,199.12 348.52,198.62 354.62,198.62 355.64,197.6 355.64,195.06 v354.62,195.06
  Route2 0.254: v297.22,196.58 297.22,197.6 298.23,198.62 298.23,204.2 v304.33,210.3 | v319.06,211.32 321.6,211.32 326.17,206.74 328.2,208.78 328.71,208.78 v329.73,209.79
  Route15 0.254: v289.09,183.38 v289.09,175.25 | v339.89,207.25 v348.02,199.12 | v354.62,192.52 361.73,185.41 361.73,182.87 363.26,181.34 B02.K2
  Bottom 0.254: v289.09,183.38 288.58,183.88 288.58,193.54 v287.56,194.55 | v336.84,209.28 338.36,207.76 339.89,207.76 v339.89,207.25 | v354.62,195.06 v354.62,192.52
DTB_09  (via drill 0.61)
  Top 0.254: v47.79,282.44 48.3,281.93 59.47,281.93 60.49,280.91 79.28,280.91 79.79,281.42 113.32,281.42 114.34,282.44 141.26,282.44 141.77,282.94 146.85,282.94 147.36,282.44 173.77,282.44 174.28,281.93 197.14,281.93 197.65,282.44 221.02,282.44 222.03,283.45 233.21,283.45 236.26,280.4 257.08,280.4 v257.59,280.91 | v267.24,198.11 269.78,198.11 270.8,199.12 v272.32,199.12 274.36,199.12 B09.C1 | v272.32,169.66 269.78,169.66 268.77,168.64 B09.P2
  Bottom 0.254: v47.79,282.44 47.79,249.92 49.31,248.4 A25.L2 | v257.59,280.91 257.59,268.72 257.08,268.21 257.08,252.46 257.59,251.96 257.59,232.14 260.64,229.1 260.64,224.02 261.15,223.51 261.15,209.28 263.69,206.74 263.69,201.66 v267.24,198.11 | v272.32,169.66 272.83,170.17 272.83,198.62 v272.32,199.12
DTB_09\  (via drill 0.61)
  Top 0.254: v267.75,170.68 v264.7,167.63 | v293.66,214.36 294.17,213.86 312.96,213.86 v313.98,214.87 | v343.95,198.11 349.03,198.11 v350.56,196.58
  Route2 0.254: v267.75,170.68 267.75,171.18 272.83,176.26 272.83,181.34 276.9,185.41 276.9,189.47 285.02,197.6 285.02,198.11 292.14,205.22 292.14,208.78 292.64,209.28 292.64,213.35 v293.66,214.36
  Route15 0.254: v316.01,218.43 325.16,218.43 327.7,215.89 327.7,214.36 v343.95,198.11 | v350.56,188.96 351.57,188.96 355.64,184.9 355.64,183.88 356.65,182.87 357.67,182.87 v360.21,180.33
  Bottom 0.254: v264.7,167.63 264.7,165.09 B09.R2 | v313.98,214.87 314.49,215.38 314.49,216.9 v316.01,218.43 | v350.56,196.58 352.08,195.06 352.08,192.52 351.57,192.01 350.56,192.01 v350.56,188.96 | v360.21,180.33 360.21,178.3 B02.L2
DTB_10  (via drill 0.61)
  Top 0.254: v60.49,149.34 241.34,149.34 244.38,146.29 249.46,146.29 250.48,147.31 260.13,147.31 v260.64,146.8 | v260.64,156.45 260.64,157.98 264.7,157.98 B09.T2 265.72,157.98 266.74,156.96 273.85,156.96 v274.36,157.47
  Bottom 0.254: v60.49,149.34 60.49,233.16 53.38,240.27 53.38,243.32 52.87,243.83 A25.M2 | v260.64,146.8 v260.64,156.45 | v274.36,157.47 274.36,161.02 B09.S1
DTB_10\  (via drill 0.61)
  Top 0.254: v305.85,154.93 307.38,154.93 307.88,155.44 307.88,156.45 312.96,156.45 v313.47,155.94 | v328.71,158.99 329.22,159.5 333.28,159.5 333.79,160.01 337.86,160.01 v338.36,159.5 | v340.9,162.04 342.43,163.56 v343.95,163.56 | v344.97,166.61 345.48,167.12 349.54,167.12 350.05,166.61 356.14,166.61 357.67,165.09 B02.R2
  Route2 0.254: v297.72,164.58 295.69,162.55 295.69,162.04 294.17,160.52 291.63,163.06 280.96,163.06 280.45,162.55 280.45,162.04 274.86,156.45 274.86,155.94 B09.U1 | v313.47,155.94 315.5,157.98 316.52,157.98 318.55,160.01 321.6,160.01 325.66,155.94 v328.71,158.99 | v340.9,162.04 v338.36,159.5
  Route15 0.254: v297.72,164.58 299.25,163.06 300.26,163.06 300.77,162.55 300.77,160.01 v305.85,154.93
  Bottom 0.254: v343.95,163.56 344.97,164.58 v344.97,166.61
DTB_11  (via drill 0.61)
  Top 0.254: v49.82,244.34 51.85,246.37 169.71,246.37 v170.22,246.88 | v170.22,182.36 261.66,182.36 265.72,186.42 267.75,186.42 B09.H2 268.77,186.42 269.28,186.42 271.31,184.39 B09.J1
  Bottom 0.254: v49.82,244.34 49.82,241.8 A25.N2 | v170.22,246.88 169.71,246.37 169.71,182.87 v170.22,182.36
DTB_11\  (via drill 0.61)
  Top 0.254: v353.6,163.06 354.11,163.56 357.67,163.56 358.18,163.06 362.75,163.06 363.26,162.55 B02.S2 | v351.06,165.6 350.56,166.1 349.03,166.1 348.52,166.61 346.49,166.61 345.48,165.6 343.95,165.6 339.89,169.66 334.81,169.66 334.3,169.15 333.28,169.15 v329.73,172.71 | v269.28,184.9 268.77,184.39 265.72,184.39 B09.J2
  Route2 0.254: v351.06,165.6 v353.6,163.06 | v329.73,172.71 329.22,172.71 326.17,169.66 311.95,169.66 306.87,174.74 v303.82,171.69 | v275.37,191 v269.28,184.9
  Route15 0.254: v303.82,171.69 303.31,171.69 288.07,186.93 288.07,187.44 287.56,187.95 286.55,187.95 284.52,189.98 283.5,189.98 281.98,191.5 275.88,191.5 v275.37,191
DTF  (via drill 0.61)
  Top 0.254: v240.83,243.83 237.78,243.83 237.27,244.34 A12.M1 | v243.88,240.78 243.88,242.3 244.89,242.3 245.4,242.81 247.43,242.81 247.94,242.3 251.5,242.3 252,242.81 254.54,242.81 255.05,242.3 257.59,242.3 258.1,242.81 260.13,242.81 260.64,242.3 264.2,242.3 264.7,242.81 267.24,242.81 267.75,242.3 270.29,242.3 270.8,242.81 272.83,242.81 273.85,241.8 275.88,241.8 276.39,242.3 276.39,245.86 v272.32,245.86 | v284.52,254.5 287.06,254.5 A08.J1 | v52.87,149.85 53.38,150.36 61,150.36 61.5,149.85 117.38,149.85 v117.89,150.36 | v116.37,2.53 116.88,2.02 245.4,2.02 v245.91,2.53 | v214.41,230.11 209.84,230.11 v208.82,229.1 | v207.81,223 207.3,223.51 197.14,223.51 197.14,222.49 194.09,222.49 192.57,224.02 181.9,224.02 178.34,227.57 174.28,227.57 173.77,227.06 140.24,227.06 137.2,224.02 132.62,224.02 v130.08,226.56 | v107.22,295.14 106.72,295.64 v55.41,295.64
  Route2 0.254: v272.32,245.86 273.85,245.86 275.37,247.38 275.37,247.89 275.88,248.4 277.91,248.4 278.93,249.42 279.44,249.42 v284.52,254.5 | v214.41,230.11 214.92,230.11 224.57,239.76 227.62,239.76 228.64,240.78 228.64,241.8 229.65,242.81 230.67,242.81 231.68,243.83 236.26,243.83 A12.M1
  Route15 0.254: v130.08,226.56 130.08,228.08 127.04,231.13 v127.04,234.68
  Bottom 0.254: v243.88,240.78 v240.83,243.83 | 47.28,268.21 46.26,269.23 A26.C1 | 47.28,268.21 47.28,246.37 47.79,245.86 47.79,232.14 50.84,229.1 50.84,219.44 47.79,216.4 47.79,155.94 52.87,150.86 v52.87,149.85 | v117.89,150.36 117.89,145.28 115.35,142.74 115.35,3.54 v116.37,2.53 | v245.91,2.53 246.42,3.04 246.42,18.28 D11.V1 | v208.82,229.1 209.33,228.59 209.33,224.52 v207.81,223 | v127.04,234.68 127.04,238.75 128.56,240.27 128.56,242.3 130.08,243.83 130.08,245.86 127.54,248.4 127.54,249.92 123.99,253.48 123.99,283.45 112.3,295.14 v107.22,295.14 | v55.41,295.64 46.77,295.64 46.77,277.86 47.28,277.36 47.28,268.21
DTF\  (via drill 0.61)
  Top 0.254: v229.65,15.23 229.14,14.72 226.6,14.72 226.1,14.21 215.43,14.21 v214.92,14.72 | v190.54,18.78 189.01,20.31 136.69,20.31 v136.18,19.8 | v133.64,103.62 131.1,106.16 42.2,106.16 v27.47,120.89 | v21.88,291.58 27.47,297.17 204.25,297.17 v205.27,296.15 | v335.32,188.46 334.81,188.96 322.62,188.96 319.57,192.01 307.88,192.01 v306.87,193.03 | v245.4,215.38 244.89,215.89 v241.34,215.89
  Route2 0.254: v229.65,15.23 230.16,14.72 231.68,14.72 235.75,18.78 239.3,18.78 D11.V2 | v242.86,203.7 240.83,201.66 238.8,201.66 237.27,200.14 B12.C1
  Route15 0.254: v208.32,260.08 208.32,259.07 212.89,254.5 212.89,253.99 214.92,251.96 215.43,251.96 222.03,245.35 222.03,244.34 229.65,236.72 231.18,236.72 232.19,235.7 232.19,234.18 231.18,233.16 229.65,233.16 228.13,231.64 232.7,227.06 237.27,227.06 242.35,221.98 242.35,216.9 v241.34,215.89 | v306.87,193.03 305.85,193.03 303.31,195.57 302.8,195.57 302.3,196.08 302.3,197.6 295.18,204.71 295.18,205.22 294.68,205.73 293.15,205.73 291.63,207.25 286.55,207.25 283.5,210.3 267.24,210.3 263.18,214.36 259.12,214.36 256.58,216.9 254.04,216.9 252.51,218.43 251.5,218.43 250.99,218.94 248.96,218.94 v245.4,215.38
  Bottom 0.254: v214.92,14.72 213.4,13.2 213.4,11.67 203.24,1.51 190.54,1.51 v190.54,18.78 | v136.18,19.8 136.18,74.66 135.67,75.17 135.67,77.71 136.18,78.22 136.18,94.98 133.64,97.52 v133.64,103.62 | v27.47,120.89 21.88,126.48 v21.88,291.58 | v205.27,296.15 205.27,274.82 206.79,273.29 206.79,261.61 v208.32,260.08 | v241.34,215.89 240.83,215.38 240.83,205.73 v242.86,203.7 | v335.32,188.46 336.33,187.44 336.33,179.31 335.32,178.3 B04.L2
DTSF  (via drill 0.61)
  Top 0.254: v303.82,247.38 302.3,248.91 279.94,248.91 v279.44,248.4 | v266.74,247.89 266.74,248.91 262.67,248.91 v261.66,247.89 | v235.75,235.19 233.72,235.19 A12.R1
  Route2 0.254: v350.56,172.71 349.03,171.18 349.03,170.17 348.52,169.66 348.52,168.64 345.98,166.1 345.98,161.02 339.38,154.42 339.38,153.4 333.79,147.82 332.78,147.82 329.22,144.26 329.22,143.24 C05.A1 | v261.66,247.89 260.13,246.37 255.05,246.37 253.02,244.34 251.5,244.34 249.97,245.86 246.42,245.86 v235.75,235.19
  Route15 0.254: v350.56,172.71 349.54,173.72 349.54,178.3 339.89,187.95 339.89,189.47 333.79,195.57 333.79,198.11 327.7,204.2 326.68,204.2 323.12,207.76 319.57,207.76 312.96,214.36 312.96,215.89 v312.46,216.4 | v314.49,229.1 310.42,233.16 v306.87,233.16 | v307.88,243.83 307.38,243.83 v303.82,247.38 | v279.44,248.4 275.37,252.46 271.82,252.46 270.29,250.94 v268.77,252.46
  Bottom 0.254: v312.46,216.4 313.47,217.41 313.47,220.46 314.49,221.48 v314.49,229.1 | v306.87,233.16 307.88,233.16 v307.88,243.83 | v268.77,252.46 266.74,252.46 v266.74,247.89
EA_00\  (via drill 0.61)
  Top 0.254: v304.84,167.63 305.85,166.61 317.03,166.61 317.54,166.1 324.14,166.1 B05.R1
  Bottom 0.254: D06.V2 306.36,19.8 305.34,20.82 305.34,24.37 304.84,24.88 304.84,72.12 306.36,73.65 306.36,86.86 304.84,88.38 304.84,141.21 305.85,142.23 305.85,150.36 304.84,151.37 v304.84,167.63 304.84,203.7 306.36,205.22 306.36,221.48 A06.V2
EA_01\  (via drill 0.61)
  Top 0.254: v305.85,27.42 305.85,25.9 D06.T2 | v302.8,31.99 301.79,33.01 290.61,33.01 v290.1,32.5 | v276.39,47.74 279.44,50.79 279.44,52.31 280.45,53.33 v280.45,55.36 | v275.88,61.96 277.91,64 279.44,64 280.45,65.01 283.5,65.01 v284.01,64.5 | v315.5,152.9 316.01,153.4 322.11,153.4 v322.62,152.9
  Route2 0.254: v305.85,27.42 304.84,28.44 304.84,28.94 303.82,29.96 303.31,29.96 302.3,30.98 302.8,31.48 v302.8,31.99 | v292.14,73.14 292.14,74.66 293.15,75.68 293.15,77.2 297.72,81.78 297.72,84.32 301.28,87.87 301.28,91.43 301.79,91.94 301.79,92.95 303.31,94.48 v303.82,94.48 | v302.8,107.68 302.8,108.7 304.84,110.73 304.84,114.8 308.9,118.86 313.98,118.86 316.52,121.4 316.52,122.42 317.54,123.43 317.54,127.5 v323.12,133.08 | v322.62,152.9 323.63,152.9 327.7,156.96 v329.22,156.96
  Route15 0.254: v290.1,32.5 287.56,35.04 287.06,35.04 286.55,35.55 286.55,36.56 279.44,43.68 279.44,44.69 v276.39,47.74 | v280.45,55.36 279.44,56.38 279.44,58.41 v275.88,61.96 | v284.01,64.5 285.02,64.5 292.64,72.12 292.14,72.63 v292.14,73.14 | v303.82,94.48 303.82,95.49 301.79,97.52 301.79,106.67 v302.8,107.68 | v323.12,139.69 323.12,141.21 323.63,141.72 323.63,145.28 317.54,151.37 317.54,152.39 317.03,152.9 v315.5,152.9 | v303.31,202.68 314.49,191.5 314.49,190.49 317.54,187.44 317.54,186.42 v316.52,185.41 | v316.52,177.28 316.52,175.76 320.58,171.69 320.58,167.12 324.14,163.56 326.68,163.56 B05.S1
  Bottom 0.254: v323.12,133.08 323.63,133.59 323.63,139.18 v323.12,139.69 | v329.22,156.96 329.73,157.47 329.73,160.52 B05.S1 | v303.31,202.68 304.33,203.7 304.33,204.2 305.85,205.73 305.85,215.38 304.84,216.4 304.84,223 305.85,224.02 305.85,228.08 A06.T2 | v316.52,185.41 316.52,182.36 317.54,181.34 317.54,178.3 v316.52,177.28
EA_02\  (via drill 0.61)
  Top 0.254: v387.64,182.87 328.71,182.87 325.16,186.42 322.62,186.42 B05.H2 | v331.25,230.11 310.93,230.11 309.92,231.13 A06.S2
  Bottom 0.254: v387.64,182.87 387.13,182.36 387.13,147.31 386.62,146.8 386.62,139.69 387.13,139.18 387.13,104.64 385.1,102.6 385.1,2.02 316.52,2.02 310.93,7.61 310.93,23.36 310.42,23.86 310.42,27.42 309.92,27.93 D06.S2 | v331.25,230.11 331.76,229.6 331.76,205.22 323.63,197.09 323.63,188.96 322.62,187.95 322.62,187.44 B05.H2