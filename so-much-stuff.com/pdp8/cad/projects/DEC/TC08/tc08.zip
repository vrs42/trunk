# EAGLE board tc08 (EAGLE 4.11), part 9 of 10
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
T_GO\  (via drill 0.61) (continued)
  Bottom 0.254: v62.52,195.06 62.01,195.57 62.01,253.99 62.52,254.5 62.52,262.12 68.11,267.7 68.11,269.23 A24.C2
T_PWR_CLR\  (via drill 0.61)
  Top 0.254: v86.4,203.19 v82.33,207.25 | v70.14,245.35 70.65,245.86 83.35,245.86 v84.87,244.34
  Bottom 0.254: v86.4,203.19 85.89,202.68 85.89,195.06 82.33,191.5 82.33,182.36 81.32,181.34 B23.K2 | v82.33,207.25 81.32,208.27 81.32,223.51 82.33,224.52 82.33,232.65 83.86,234.18 A23.R1 84.36,235.7 84.36,238.75 85.38,239.76 85.38,243.83 v84.87,244.34 | v70.14,245.35 70.14,255 68.62,256.53 A24.H2
T_REV\  (via drill 0.61)
  Top 0.254: v69.12,189.47 74.2,184.39 77.25,184.39 B23.J2 | v66.08,249.42 82.84,249.42 83.86,248.4 A23.L1
  Bottom 0.254: v69.12,189.47 66.58,192.01 66.58,198.11 63.03,201.66 63.03,249.42 | 63.03,249.42 63.03,252.97 63.54,253.48 63.54,257.04 65.06,258.56 65.06,259.58 A24.F2 | 63.03,249.42 v66.08,249.42
T_SINGLE_UNIT\  (via drill 0.61)
  Top 0.254: v58.96,170.68 60.49,169.15 64.04,169.15 73.19,160.01 101.64,160.01 B21.T2 | v57.44,209.28 58.46,210.3 59.47,210.3 64.04,214.87 64.04,217.41 v65.06,217.41 | v66.58,231.13 v64.04,233.67
  Bottom 0.254: v58.96,170.68 57.44,172.2 v57.44,209.28 | v65.06,217.41 67.09,219.44 67.09,230.62 v66.58,231.13 | v64.04,233.67 63.54,234.18 63.54,237.73 67.09,241.29 67.09,247.89 67.6,248.4 67.6,250.43 A24.K2
T_STOP\
  Top 0.254: A24.D2 65.57,266.18 66.58,265.16 85.89,265.16 86.9,264.15 A23.E1
  Bottom 0.254: B23.E2 81.32,194.04 82.84,195.57 82.84,203.7 85.38,206.24 85.38,219.44 95.03,229.1 95.03,234.18 95.54,234.68 95.54,245.86 92.49,248.91 92.49,256.02 87.92,260.59 87.92,263.13 A23.E1
T_TRK  (via drill 0.61)
  Top 0.254: v146.34,198.62 174.79,198.62 178.85,194.55 188,194.55 188.5,194.04 B15.E2 | v183.42,101.08 185.46,101.08 C15.R2 | v190.54,31.99 190.54,30.47 203.24,30.47 204.76,28.94 207.81,28.94 D14.S1 | v145.83,207.25 145.32,207.76 128.05,207.76 v127.04,206.74 | v127.04,197.09 127.04,195.57 110.78,195.57 110.27,195.06 v104.18,195.06 | v113.32,19.29 114.84,17.77 121.96,17.77 122.46,17.26 133.64,17.26 134.66,16.24 136.18,16.24 137.2,15.23 184.44,15.23 185.46,16.24 197.65,16.24 198.66,17.26 201.2,17.26 205.78,21.83 207.81,21.83 D14.U1
  Bottom 0.254: 146.34,207.25 v146.34,198.62 | 146.34,207.25 146.34,218.94 146.85,219.44 146.85,224.52 147.36,225.03 A18.U2 | D14.U1 207.81,22.85 207.81,27.93 D14.S1 | v183.42,101.08 183.93,100.57 183.93,78.73 184.44,78.22 184.44,72.12 183.93,71.62 183.93,57.39 184.44,56.88 184.44,48.25 190.54,42.15 v190.54,31.99 | v145.83,207.25 146.34,207.25 | v127.04,197.09 v127.04,206.74 | v104.18,195.06 104.68,194.55 104.68,168.64 101.64,165.6 101.64,153.91 99.1,151.37 99.1,144.26 98.59,143.75 98.59,34.02 v113.32,19.29
T_TRK\  (via drill 0.61)
  Top 0.254: v155.48,221.48 154.98,220.97 145.32,220.97 144.82,221.48 A18.V2 | v155.99,194.04 158.02,192.01 193.58,192.01 194.6,193.03 B15.E1
  Bottom 0.254: v155.48,221.48 155.99,220.97 v155.99,194.04
T_WRITE_OK\  (via drill 0.61)
  Top 0.254: A24.L2 65.06,248.4 65.06,251.96 67.09,251.96 67.6,252.46 91.48,252.46 v93.51,254.5 95.54,252.46 97.57,252.46 98.08,252.97 102.14,252.97 v104.18,250.94 | v101.13,179.31 79.79,179.31 78.27,177.79 B23.L2
  Bottom 0.254: v93.51,254.5 93.51,256.53 A22.H2 | v101.13,179.31 101.64,179.82 101.64,209.28 102.14,209.79 102.14,217.41 102.65,217.92 102.65,218.43 105.19,220.97 105.19,236.21 104.68,236.72 104.68,250.43 v104.18,250.94
TIM  (via drill 0.61)
  Top 0.254: v68.62,223.51 68.11,224.02 60.49,224.02 59.47,225.03 A25.U1 | v94.02,218.94 v78.78,218.94 | v94.52,227.06 98.59,227.06 101.64,230.11 104.18,230.11 v106.21,228.08 | v118.91,224.52 119.42,224.02 122.97,224.02 123.48,224.52 123.48,226.56 128.05,226.56 v129.07,227.57 | v147.36,240.78 147.86,241.29 148.88,241.29 150.4,242.81 152.94,242.81 v154.98,240.78 | v160.06,241.8 160.56,242.3 162.6,242.3 163.1,242.81 165.64,242.81 166.66,241.8 v167.17,241.8 | v175.8,247.89 176.82,248.91 182.41,248.91 v182.92,248.4 | v224.06,285.48 v232.19,285.48 | v261.66,282.94 262.67,281.93 v273.34,281.93
  Route2 0.254: v129.07,227.57 129.07,228.08 134.15,233.16 139.23,233.16 146.85,240.78 v147.36,240.78 | v154.98,240.78 157.01,238.75 v160.06,241.8 | v167.17,241.8 169.71,241.8 v175.8,247.89 | v182.92,248.4 183.93,248.4 194.09,258.56 199.17,258.56 205.27,264.66 206.79,264.66 207.3,265.16 211.87,265.16 v220,273.29 | v232.19,285.48 234.73,282.94 235.24,283.45 239.3,283.45 240.83,284.98 255.56,284.98 256.07,285.48 259.12,285.48 v261.66,282.94 | v273.34,281.93 280.45,274.82 279.44,273.8 279.44,272.78 278.93,272.28 278.93,264.66 290.61,252.97 289.09,251.45 289.09,249.92 287.56,248.4 A08.L1
  Route15 0.254: v68.62,223.51 74.2,223.51 v78.78,218.94 | v106.21,228.08 107.73,228.08 108.75,227.06 110.78,227.06 112.81,229.1 114.34,229.1 v118.91,224.52
  Bottom 0.254: v94.02,218.94 93.51,219.44 93.51,223 95.03,224.52 95.03,226.56 v94.52,227.06 | v220,273.29 219.49,273.8 219.49,280.91 v224.06,285.48
TIM\  (via drill 0.61)
  Top 0.254: v339.89,174.23 338.87,173.22 v331.76,173.22 | v331.76,242.81 295.69,242.81 294.17,244.34 291.12,244.34 A08.M1 | v266.74,258.05 267.24,258.56 288.58,258.56 v289.09,258.05
  Bottom 0.254: v339.89,174.23 339.89,173.72 341.41,172.2 B04.N1 | v331.76,173.22 331.76,179.31 331.25,179.82 331.25,196.08 332.78,197.6 332.78,211.32 332.27,211.82 332.27,242.3 v331.76,242.81 | v266.74,258.05 266.74,253.48 266.23,252.97 266.23,249.42 265.21,248.4 A09.L2 | v289.09,258.05 289.09,247.38 290.1,246.37 290.1,244.84 A08.M1
TM_EN  (via drill 0.61)
  Top 0.254: C16.R2 173.77,101.59 174.79,100.57 178.34,100.57 178.85,100.06 v181.39,100.06 193.08,100.06 194.6,98.54 C15.S1 | v215.94,101.08 215.43,100.57 212.38,100.57 211.87,100.06 v200.7,100.06 | v180.38,125.46 137.2,125.46 v135.16,127.5 | v133.64,163.06 134.15,163.56 142.28,163.56 143.8,165.09 B18.R2
  Bottom 0.254: v181.39,100.06 181.39,110.22 181.9,110.73 C16.M1 182.41,111.75 181.39,112.76 181.39,124.45 v180.38,125.46 | v215.94,101.08 215.94,105.65 217.46,107.18 C13.N1 | v200.7,100.06 199.17,98.54 195.62,98.54 C15.S1 | B18.R2 144.31,165.6 142.78,167.12 142.78,203.7 143.8,204.71 143.8,220.46 143.29,220.97 143.29,233.16 144.31,234.18 A18.R2 | v135.16,127.5 133.64,129.02 v133.64,163.06
TM_EN\  (via drill 0.61)
  Top 0.254: v223.05,116.83 223.56,117.34 229.14,117.34 C12.K2 | v230.67,134.61 232.19,136.13 235.75,136.13 C12.C1 | B15.D2 186.47,196.08 191.55,196.08 B15.D1 | v205.27,78.22 204.76,78.73 188.5,78.73 188,78.22 186.98,78.22 v185.96,79.24
  Route15 0.254: v205.78,85.84 203.24,88.38 203.24,88.89 202.73,89.4 215.43,102.1 215.94,102.1 218.48,104.64 220,104.64 C13.P1
  Bottom 0.254: v223.05,116.83 223.56,116.32 223.56,107.68 221.02,105.14 C13.P1 | v230.67,134.61 231.18,134.1 231.18,118.35 230.67,117.84 C12.K2 | D15.K2 188.5,48.25 188.5,48.76 186.47,50.79 D15.J2 185.96,51.3 186.98,52.31 186.98,78.22 186.47,78.73 186.47,79.24 | 186.47,79.24 186.47,87.36 187.49,88.38 187.49,145.78 186.98,146.29 186.98,195.57 186.47,196.08 B15.D2 | v205.78,85.84 207.81,85.84 207.81,77.71 207.3,77.2 205.27,77.2 v205.27,78.22 | v185.96,79.24 186.47,79.24
TP00  (via drill 0.61)
  Top 0.254: v276.9,270.75 281.98,270.75 282.99,271.77 286.55,271.77 287.06,272.28 A08.B1 | v275.88,188.96 258.1,188.96 256.58,187.44 256.07,187.44 B10.H2 255.05,187.44 254.54,187.44 252.51,189.47 B10.F2 252,189.47 250.99,188.46 228.64,188.46 227.11,186.93 221.02,186.93 B13.H1 220,186.93 217.46,186.93 215.94,185.41 197.65,185.41 197.14,184.9 193.08,184.9 192.57,184.39 B15.J1 | A16.N2 173.26,241.8 175.3,243.83 175.8,243.83 A16.M2 | v190.54,238.75 190.54,236.72 178.85,236.72 177.84,237.73 176.82,237.73 A16.P2 | v193.08,131.05 194.09,131.05 194.6,130.54 C15.E1
  Bottom 0.254: B10.N1 258.61,171.69 257.59,172.71 257.59,181.34 256.07,182.87 256.07,186.42 B10.H2 | v276.9,270.75 277.4,270.24 277.4,224.02 274.86,221.48 274.86,218.94 275.88,217.92 275.88,192.01 276.39,191.5 276.39,189.47 v275.88,188.96 | A16.P2 175.8,238.75 175.8,243.83 A16.M2 | A15.L1 192.06,246.88 191.04,245.86 191.04,242.3 190.54,241.8 v190.54,238.75 190.54,219.44 192.06,217.92 192.06,205.22 190.54,203.7 190.54,185.41 B15.J1 192.57,183.38 192.57,180.84 194.09,179.31 194.09,145.28 193.58,144.77 193.58,131.56 v193.08,131.05 | B13.D2 211.87,196.58 215.94,196.58 215.94,200.65 217.46,202.17 B13.B1 217.97,202.17 222.54,202.17 222.54,191.5 221.02,189.98 221.02,187.44 B13.H1
TP00\  (via drill 0.61)
  Top 0.254: v211.36,109.72 152.94,109.72 151.42,108.19 CD18.AN1 150.4,108.19 147.36,108.19 145.83,109.72 107.73,109.72 v107.22,109.21 | v193.08,232.65 192.57,233.16 124.5,233.16 v123.99,232.65 | v120.43,218.94 112.81,211.32 112.81,208.78 v109.26,208.78
  Bottom 0.254: 195.11,251.45 192.57,253.99 A15.J1 192.06,254.5 192.06,259.58 A15.F1 | 195.11,251.45 195.11,256.53 A15.H1 194.6,257.54 194.6,263.13 A15.E1 | 195.11,251.45 A15.K1 194.6,250.43 193.58,249.42 193.58,237.73 193.08,237.22 193.08,236.21 193.58,235.7 193.58,233.16 v193.08,232.65 | v211.36,109.72 211.87,110.22 211.87,112.76 212.89,113.78 212.89,164.07 216.95,168.14 216.95,170.68 B13.N1 | v123.99,232.65 123.48,232.14 123.48,230.62 121.45,228.59 121.45,227.06 120.94,226.56 120.94,219.44 v120.43,218.94 | v109.26,208.78 108.24,207.76 108.24,165.09 107.22,164.07 107.22,163.06 107.73,162.55 107.73,109.72 v107.22,109.21
TP00_A  (via drill 0.61)
  Top 0.254: v233.72,131.05 231.18,131.05 230.67,130.54 C12.E2 | v252.51,146.29 v258.61,146.29 | v256.58,179.31 258.1,180.84 v259.62,180.84 | v259.62,186.93 261.66,186.93 B10.H1 | v201.2,230.11 196.63,230.11 195.62,231.13 A15.S1 | v203.24,226.05 203.74,226.56 206.79,226.56 207.3,227.06 v228.13,227.06 | v253.53,213.86 v238.8,213.86
  Route2 0.254: v233.72,131.05 234.22,131.05 235.24,132.07 236.26,132.07 248.45,144.26 250.48,144.26 v252.51,146.29
  Route15 0.254: v259.62,168.14 v257.08,170.68 | v238.8,213.86 v230.67,221.98 | v258.61,193.54 v256.07,196.08
  Bottom 0.254: v258.61,146.29 260.13,147.82 260.13,155.44 259.62,155.94 259.62,156.96 260.13,157.47 260.13,167.63 v259.62,168.14 | v257.08,170.68 257.08,178.8 v256.58,179.31 | v259.62,180.84 260.13,181.34 260.13,186.42 | 260.13,186.42 v259.62,186.93 | v201.2,230.11 203.24,228.08 v203.24,226.05 | v228.13,227.06 228.64,226.56 228.64,225.03 230.67,223 v230.67,221.98 | v253.53,213.86 254.04,213.35 254.04,199.12 256.07,197.09 v256.07,196.08 | v258.61,193.54 260.13,192.01 260.13,186.42
TP00_A\  (via drill 0.61)
  Top 0.254: v195.11,246.88 194.6,246.37 174.79,246.37 173.77,247.38 A16.L2 | A15.N1 192.57,241.8 194.6,243.83 195.11,243.83 A15.M1
  Bottom 0.254: A15.R1 192.06,235.7 192.06,240.78 A15.N1 | A15.P1 195.11,238.75 195.11,243.83 A15.M1 195.11,244.84 v195.11,246.88
TP0_XTLK_DY\  (via drill 0.61)
  Top 0.254: v229.65,234.18 230.16,233.67 238.29,233.67 239.3,234.68 A11.R2 | v228.64,256.53 227.11,258.05 222.03,258.05 221.52,258.56 197.14,258.56 196.63,259.07 187.49,259.07 186.47,260.08 A15.F2
  Bottom 0.254: 175.3,251.96 173.77,253.48 173.77,253.99 A16.J2 | 175.3,251.96 175.8,251.45 A16.K2 | 175.3,251.96 175.3,252.46 181.39,258.56 181.39,259.58 185.46,259.58 A15.F2 | v229.65,234.18 229.14,234.68 229.14,237.22 228.64,237.73 v228.64,256.53
TP01  (via drill 0.61)
  Top 0.254: 190.54,249.42 v190.54,247.38 | 190.54,249.42 222.03,249.42 226.1,253.48 226.6,253.48 A12.J2 | B16.N2 173.77,170.68 175.8,168.64 B16.P2 176.82,167.63 177.84,166.61 v188,166.61 | v188,58.92 154.47,58.92 154.47,57.9 153.96,57.39 151.42,57.39 CD18.BF1 | v228.64,122.42 237.78,122.42 239.3,120.89 C11.J2 | v225.59,138.16 224.57,139.18 218.98,139.18 217.97,138.16 210.35,138.16 209.33,139.18 206.28,139.18 205.27,138.16 197.65,138.16 196.63,139.18 192.57,139.18 C15.B1 | v171.74,249.42 190.54,249.42 | v176.31,195.57 v174.28,197.6
  Bottom 0.254: v190.54,247.38 190.54,243.83 190.03,243.32 190.03,239.76 189.01,238.75 A15.P2 | B16.P2 175.8,168.64 175.8,173.72 B16.M2 176.82,174.74 177.84,175.76 177.84,194.04 v176.31,195.57 | v188,58.92 187.49,59.42 187.49,77.71 188.5,78.73 188.5,89.4 190.54,91.43 190.54,138.16 191.55,139.18 C15.B1 191.55,140.2 191.55,142.74 187.49,146.8 187.49,166.1 v188,166.61 | v228.64,122.42 228.13,122.92 228.13,134.61 225.59,137.15 v225.59,138.16 | v171.74,249.42 171.74,244.84 170.72,243.83 170.72,207.76 174.28,204.2 v174.28,197.6
TP01\  (via drill 0.61)
  Top 0.254: v188,176.26 210.35,176.26 210.86,176.77 B13.L2 | A15.M2 188.5,243.83 188.5,241.8 185.96,241.8 A15.N2
  Bottom 0.254: A15.J2 185.46,253.48 185.46,248.4 A15.L2 185.46,246.88 185.46,241.8 A15.N2 185.96,240.78 185.96,237.22 187.49,235.7 187.49,176.77 v188,176.26 | A15.K2 188.5,250.43 188.5,244.84 A15.M2
TP01_A  (via drill 0.61)
  Top 0.254: v185.46,99.05 183.42,97.02 181.39,97.02 178.85,99.56 176.82,99.56 176.31,100.06 v135.67,100.06 | v139.74,223 140.75,224.02 180.88,224.02 181.9,223 185.46,223 A15.V2 | v215.94,171.69 215.43,172.2 212.38,172.2 211.87,172.71 206.28,172.71 v204.25,174.74 | v203.24,177.28 201.71,178.8 196.12,178.8 195.62,179.31 192.57,179.31 190.03,181.85 171.23,181.85 170.72,181.34 169.71,181.34 168.18,182.87 v135.67,182.87
  Route15 0.254: v188.5,107.68 187.49,106.67 187.49,105.14 v186.47,104.13 | v221.52,164.07 226.6,158.99 B12.T2
  Bottom 0.254: v188.5,107.68 188.5,110.73 C15.M2 | v186.47,104.13 186.98,103.62 186.98,100.57 v185.46,99.05 | v135.67,100.06 136.18,100.57 136.18,171.18 133.64,173.72 133.64,182.87 | 133.64,182.87 133.64,202.68 136.69,205.73 136.69,218.43 139.74,221.48 v139.74,223 | v221.52,164.07 222.03,164.58 222.03,169.15 221.52,169.66 218.98,169.66 218.98,171.69 217.97,172.71 215.94,172.71 v215.94,171.69 | v204.25,174.74 203.24,175.76 v203.24,177.28 | 133.64,182.87 v135.67,182.87
TP01_A\
  Top 0.254: A15.S2 188.5,231.13 186.47,229.1 185.96,229.1 A15.T2
  Bottom 0.254: A15.U2 188.5,226.05 188.5,231.13 A15.S2 | B16.L2 173.77,177.79 174.28,178.3 174.28,195.57 186.98,208.27 186.98,227.06 185.96,228.08 A15.T2 185.96,229.1 185.96,234.18 A15.R2
TP1_XTLK_DY\  (via drill 0.61)
  Top 0.254: B16.J2 173.26,184.39 175.3,186.42 175.8,186.42 B16.H2 | v206.79,254.5 208.32,252.97 209.84,252.97 210.35,252.46 v216.44,252.46 | v221.02,229.6 221.52,230.11 v231.18,230.11 | v193.58,214.87 194.09,214.36 v205.27,214.36
  Route2 0.254: v215.94,226.05 216.95,227.06 218.48,227.06 v221.02,229.6 | v171.74,195.57 170.22,197.09 170.72,197.6 170.72,198.11 171.23,198.62 172.76,198.62 175.3,201.16 179.87,201.16 v193.58,214.87
  Route15 0.254: v194.09,272.78 194.6,272.78 197.14,270.24 197.14,269.74 198.66,268.21 199.17,268.21 v200.19,267.2 | v234.22,225.54 235.75,224.02 237.78,224.02 239.3,222.49 A11.V2 | v205.27,214.36 205.27,215.89 207.3,217.92 207.3,220.97 210.86,224.52 211.36,224.52 214.41,227.57 v215.94,226.05
  Bottom 0.254: v194.09,272.78 192.57,272.78 A15.B1 | v200.19,267.2 206.79,260.59 v206.79,254.5 | v216.44,252.46 215.94,251.96 v215.94,226.05 | v231.18,230.11 231.68,229.6 231.68,228.08 v234.22,225.54 | v171.74,195.57 171.74,184.39 172.76,184.39 B16.J2
TS03\  (via drill 0.61)
  Top 0.254: D17.K2 160.06,48.25 158.02,50.28 157.52,50.28 D17.J2 | v310.42,80.25 309.92,80.76 304.84,80.76 303.31,79.24 v296.71,79.24 | v290.1,57.39 288.58,55.87 284.01,55.87 282.99,54.85 282.99,51.3 v284.01,51.3 | v264.7,48.25 264.2,48.76 263.18,48.76 262.67,49.26 240.32,49.26 237.27,46.22 235.75,46.22 v233.72,48.25 | v187.49,79.24 v208.82,79.24 | v174.28,60.95 173.77,61.46 167.68,61.46 167.17,61.96 v166.66,61.96
  Route2 0.254: v310.42,80.25 313.47,83.3 313.47,85.33 318.55,90.41 319.57,90.41 320.08,89.9 321.6,89.9 322.11,90.41 323.12,90.41 328.71,96 330.24,96 333.79,99.56 333.79,102.6 337.86,106.67 338.87,106.67 339.89,107.68 339.89,108.7 340.9,109.72 340.9,111.75 344.46,115.3 344.46,116.83 C04.K1 | v296.71,79.24 296.71,78.73 296.2,78.22 296.2,77.2 294.68,75.68 294.68,74.16 289.6,69.08 289.6,68.06 289.09,67.55 289.09,58.41 v290.1,57.39 | v284.01,51.3 282.48,51.3 275.88,57.9 273.34,55.36 271.82,55.36 v264.7,48.25 | v218.98,85.84 215.43,85.84 v208.82,79.24
  Route15 0.254: v233.72,48.25 232.19,49.77 232.19,51.8 231.68,52.31 229.14,52.31 228.64,52.82 226.1,52.82 v221.52,57.39 | v187.49,79.24 182.92,74.66 181.9,74.66 v177.33,70.09
  Bottom 0.254: D17.H2 160.06,53.33 160.06,48.25 D17.K2 161.07,47.23 164.63,47.23 165.14,47.74 165.14,48.25 166.66,49.77 166.66,51.8 165.14,53.33 165.14,57.9 164.12,58.92 164.12,61.96 v166.66,61.96 | v221.52,57.39 222.03,57.9 222.03,84.32 220.51,85.84 v218.98,85.84 | v177.33,70.09 174.28,67.04 v174.28,60.95
U+M_DY\  (via drill 0.61)
  Top 0.254: v218.98,92.44 218.48,92.95 216.44,92.95 215.43,93.97 206.28,93.97 205.78,93.46 | 205.78,93.46 204.25,91.94 v203.24,91.94 | v223.05,101.59 C12.R2 | v233.21,142.74 235.75,142.74 C12.A1 | v232.7,154.93 231.18,156.45 225.08,156.45 v224.57,155.94 | v224.57,165.09 220,165.09 217.97,163.06 205.78,163.06 202.73,160.01 201.2,160.01 199.68,161.53 197.65,161.53 196.12,163.06 185.46,163.06 184.95,162.55 183.93,162.55 183.42,163.06 v181.39,163.06 | v182.92,94.48 183.93,93.46 205.78,93.46
  Route2 0.254: v223.05,94.48 221.02,94.48 v218.98,92.44
  Bottom 0.254: 203.74,59.93 206.79,59.93 206.79,57.39 209.84,54.34 209.84,53.33 206.79,50.28 206.79,43.68 205.78,42.66 205.78,38.6 D14.N1 | 203.74,59.93 202.73,59.93 D14.E2 | v223.05,94.48 v223.05,101.59 | v203.24,91.94 203.24,85.33 203.74,84.82 203.74,59.93 | v233.21,142.74 232.19,143.75 232.19,154.42 v232.7,154.93 | v224.57,165.09 v224.57,155.94 | v181.39,163.06 180.88,162.55 180.88,143.24 177.84,140.2 177.84,119.37 180.88,116.32 180.88,101.08 180.38,100.57 180.38,97.02 v182.92,94.48
USR_00  (via drill 0.61)
  Top 0.254: v79.28,274.82 76.24,277.86 61,277.86 59.47,276.34 A25.A1 | v86.4,267.2 86.9,267.7 89.44,267.7 89.95,268.21 91.98,268.21 93,267.2 v94.02,267.2 | v112.3,241.29 113.32,240.27 117.89,240.27 118.4,239.76 120.43,239.76 121.45,240.78 122.97,240.78 125,242.81 127.04,242.81 128.56,241.29 v129.58,241.29 | v135.67,235.19 137.2,233.67 147.36,233.67 v147.86,234.18 | v153.45,235.19 154.47,236.21 166.66,236.21 v167.17,235.7 | v267.24,234.68 268.77,234.68 270.29,236.21 272.83,236.21 v273.34,235.7
  Route2 0.254: v307.88,205.73 307.88,202.17 304.33,198.62 304.33,196.08 303.31,195.06 303.31,194.04 B07.E1 | v147.86,234.18 149.39,234.18 150.91,232.65 v153.45,235.19 | v232.7,231.13 234.73,231.13 236.26,229.6 238.8,229.6 242.35,233.16 244.89,233.16 246.42,231.64 247.43,231.64 247.94,231.13 247.94,230.62 v249.46,229.1
  Route15 0.254: v307.88,205.73 307.38,205.73 303.31,209.79 303.31,211.82 293.66,221.48 A07.V2 293.15,221.98 291.63,221.98 290.1,223.51 289.09,223.51 288.58,224.02 283.5,224.02 275.88,231.64 275.88,232.65 273.34,235.19 v273.34,235.7 | v101.64,254.5 101.64,251.96 v112.3,241.29 | v135.67,235.19 v129.58,241.29 | v167.17,235.7 171.74,240.27 178.34,233.67 200.19,233.67 208.32,241.8 210.35,239.76 225.59,239.76 230.67,234.68 v231.18,234.68 | v249.46,229.1 250.99,229.1 253.02,231.13 255.05,229.1 257.08,229.1 259.62,231.64 261.15,230.11 262.67,230.11 v267.24,234.68
  Bottom 0.254: v79.28,274.82 86.4,267.7 v86.4,267.2 | v94.02,267.2 101.64,259.58 v101.64,254.5 | v231.18,234.68 231.68,234.18 231.68,232.14 v232.7,231.13
USR_00\  (via drill 0.61)
  Top 0.254: v313.47,188.46 311.95,188.46 311.44,188.96 301.79,188.96 300.77,189.98 B07.F1 | v313.98,209.28 314.49,208.78 323.12,208.78 323.63,208.27 324.14,208.27 324.65,208.78 335.82,208.78 336.33,208.27 355.13,208.27 356.65,206.74 B03.A1
  Bottom 0.254: v313.47,188.46 313.98,188.96 v313.98,209.28
USR_01  (via drill 0.61)
  Top 0.254: v62.01,276.85 59.98,274.82 56.93,274.82 55.92,273.8 A25.B1 | v69.12,293.1 75.22,293.1 75.73,293.61 v101.13,293.61 | v122.46,272.28 122.97,271.77 127.04,271.77 v128.05,272.78 | v144.31,258.05 144.82,258.56 157.01,258.56 v157.52,258.05 | v174.28,263.13 v169.71,263.13 | v248.96,247.38 250.48,248.91 253.53,248.91 v254.54,247.89
  Route2 0.254: v122.46,272.28 v101.13,293.61 | v128.05,272.78 134.66,266.18 135.67,266.18 136.18,265.67 136.18,264.66 143.29,257.54 143.8,258.05 v144.31,258.05 | v157.52,258.05 159.04,258.05 162.6,261.61 166.15,261.61 166.66,262.12 168.69,262.12 v169.71,263.13 | v224.06,240.78 224.57,240.78 229.65,245.86 231.18,245.86 232.7,244.34 233.72,244.34 236.26,246.88 236.26,247.38 236.76,247.89 237.78,247.89 242.35,252.46 243.88,252.46 v248.96,247.38
  Route15 0.254: v179.87,263.13 180.38,263.13 194.09,249.42 199.68,249.42 202.73,246.37 214.41,246.37 220,240.78 v224.06,240.78 | v254.54,247.89 258.61,243.83 259.62,243.83 260.64,244.84 260.64,245.35 265.72,250.43 267.75,248.4 267.75,247.38 268.77,246.37 270.29,246.37 274.86,241.8 277.91,241.8 292.64,227.06 294.68,227.06 296.2,225.54 A07.U2
  Bottom 0.254: B07.H2 296.2,187.44 295.69,187.95 295.69,191 295.18,191.5 295.18,207.76 296.71,209.28 296.71,225.03 A07.U2 | v62.01,276.85 66.08,280.91 66.08,292.6 66.58,293.1 v69.12,293.1 | v174.28,263.13 175.3,262.12 179.87,262.12 v179.87,263.13
USR_01\  (via drill 0.61)
  Top 0.254: v284.01,188.96 284.52,188.46 291.12,188.46 292.14,187.44 295.18,187.44 295.18,184.9 294.68,184.39 294.17,184.39 B07.J2 | v288.58,209.28 289.09,208.78 311.95,208.78 313.47,210.3 318.55,210.3 v319.06,209.79 | v322.62,202.68 323.63,201.66 341.92,201.66 342.94,202.68 345.98,202.68 347,201.66 352.59,201.66 353.6,202.68 B03.B1
  Bottom 0.254: v284.01,188.96 282.99,189.98 282.99,196.08 286.04,199.12 286.04,206.74 v288.58,209.28 | v319.06,209.79 320.58,208.27 320.58,204.71 v322.62,202.68
USR_02  (via drill 0.61)
  Top 0.254: v58.96,272.78 61,274.82 v77.76,274.82 | v98.59,261.1 99.1,261.61 105.7,261.61 v107.22,260.08 | v121.45,260.08 122.97,261.61 131.1,261.61 v131.61,262.12 | v135.16,259.58 137.2,261.61 v141.26,261.61 | v144.82,262.12 145.32,261.61 166.66,261.61 v167.17,261.1 | v181.39,254.5 182.92,252.97 184.44,252.97 184.95,252.46 v196.12,252.46
  Route2 0.254: v107.22,260.08 114.34,252.97 v121.45,260.08 | v131.61,262.12 132.62,262.12 v135.16,259.58 | v141.26,261.61 144.31,261.61 v144.82,262.12 | v196.12,252.46 201.2,247.38 v213.9,260.08 | v281.47,219.44 282.99,219.44 284.01,220.46 284.01,222.49 284.52,223 285.53,223 286.04,223.51 290.1,223.51 295.18,218.43 299.76,223 A07.V1
  Route15 0.254: v167.17,261.1 170.22,258.05 173.26,258.05 175.8,255.51 180.38,255.51 v181.39,254.5 | v218.48,257.54 220.51,259.58 222.03,258.05 v228.64,258.05 | v236.76,228.59 244.38,220.97 262.16,220.97 264.2,218.94 265.21,218.94 267.75,221.48 268.77,221.48 269.28,220.97 272.83,220.97 276.39,224.52 v281.47,219.44
  Bottom 0.254: B07.L1 300.77,177.79 301.28,178.3 301.28,204.71 300.26,205.73 300.26,221.48 A07.V1 | v58.96,272.78 58.96,270.24 A25.C1 | v77.76,274.82 79.28,276.34 79.28,276.85 80.3,277.86 85.38,277.86 85.38,274.31 v98.59,261.1 | v213.9,260.08 215.43,261.61 218.98,261.61 218.98,258.05 v218.48,257.54 | v228.64,258.05 229.65,259.07 232.19,259.07 232.19,249.92 231.68,249.42 231.68,242.3 232.19,241.8 232.19,239.76 234.73,237.22 234.73,230.62 v236.76,228.59
USR_02\  (via drill 0.61)
  Top 0.254: v350.56,176.26 320.08,176.26 316.52,172.71 308.9,172.71 308.39,173.22 304.33,173.22 B07.M1 | v351.57,191 353.6,191 B03.F1
  Bottom 0.254: v350.56,176.26 352.08,177.79 352.08,190.49 v351.57,191
UTS  (via drill 0.61)
  Top 0.254: v44.74,282.44 46.26,283.96 60.49,283.96 61,283.45 62.01,283.45 62.52,282.94 104.68,282.94 | 104.68,282.94 111.8,282.94 112.81,283.96 139.74,283.96 140.24,284.47 152.94,284.47 153.45,283.96 175.3,283.96 175.8,283.45 195.62,283.45 196.12,283.96 219.49,283.96 220.51,284.98 220.51,291.07 227.62,291.07 228.13,290.56 236.26,290.56 237.27,289.55 239.3,289.55 239.81,289.04 241.34,289.04 241.84,288.53 260.13,288.53 v260.64,289.04 | v191.55,73.14 190.03,71.62 116.88,71.62 v114.34,74.16 | 104.68,282.94 v104.68,283.45 | v188,170.68 189.52,170.68 190.54,169.66 193.08,169.66 194.6,168.14 B15.P1 | v185.96,168.64 185.46,169.15 177.33,169.15 173.77,172.71 161.58,172.71 159.55,170.68 159.04,170.68 158.53,170.17 148.37,170.17 145.83,172.71 v114.34,172.71
  Route2 0.254: v185.96,168.64 v188,170.68
  Route15 0.254: v198.16,99.56 196.63,98.03 196.63,96.51 v192.57,92.44
  Bottom 0.254: v44.74,282.44 44.74,256.02 43.22,254.5 A26.J1 | v260.64,289.04 260.64,265.16 261.66,264.15 A10.E1 | v198.16,99.56 198.16,101.08 C14.R2 | v192.57,92.44 193.08,91.94 193.08,89.9 193.58,89.4 193.58,75.17 v191.55,73.14 | v114.34,74.16 114.84,74.66 114.84,117.34 113.32,118.86 113.32,122.42 114.34,123.43 114.34,169.15 113.83,169.66 113.83,172.71 | 113.83,172.71 113.83,173.22 114.84,174.23 114.84,195.57 110.78,199.63 110.78,208.78 113.83,211.82 113.83,221.98 110.78,225.03 110.78,229.6 105.7,234.68 105.7,236.72 105.19,237.22 105.19,255 104.68,255.51 104.68,258.56 105.19,259.07 105.19,268.72 104.68,269.23 v104.68,283.45 | 113.83,172.71 v114.34,172.71
UTS\  (via drill 0.61)
  Top 0.254: C16.K1 181.9,117.84 179.87,119.88 179.36,119.88 C16.J1 | C12.L2 226.1,113.78 225.59,113.27 220,113.27 216.44,109.72 215.94,109.72 212.38,106.16 203.24,106.16 202.22,105.14 C14.P2 201.2,105.14 200.19,106.16 190.54,106.16 189.52,105.14 C15.P2 188.5,105.14 184.95,105.14 v183.42,106.67
  Bottom 0.254: C16.A1 182.41,142.23 182.41,137.15 C16.C1 182.41,136.13 182.41,132.58 179.36,129.53 | 179.36,129.53 179.36,127.5 C16.F1 179.87,126.48 182.41,126.48 182.41,124.45 C16.H1 181.9,123.43 181.9,117.84 C16.K1 182.92,116.83 183.93,115.81 183.93,107.18 v183.42,106.67 | 179.36,129.53 179.36,132.58 C16.D1 179.36,134.1 179.36,139.18 C16.B1
VCC  (via drill 0.61)
  Top 0.635: CD18.BA2 148.37,73.14 149.9,74.66 156.5,74.66 157.52,73.65 160.06,73.65 D17.A2 161.07,73.14 162.09,74.16 165.14,74.16 165.64,74.66 171.23,74.66 172.25,73.65 175.8,73.65 D16.A2 176.82,73.14 177.84,74.16 180.88,74.16 181.39,74.66 187.49,74.66 | 187.49,74.66 188.5,73.65 D15.A2 | 187.49,74.66 196.12,74.66 197.65,73.14 201.2,73.14 D14.A2 202.73,73.14 205.27,73.14 206.79,74.66 209.33,74.66 209.84,74.16 213.4,74.16 213.9,73.65 D13.A2 214.92,73.14 215.94,74.16 218.98,74.16 219.49,74.66 225.59,74.66 227.11,73.14 229.65,73.14 D12.A2 230.67,73.65 231.18,74.16 235.24,74.16 235.75,74.66 240.83,74.66 | 240.83,74.66 242.35,73.14 D11.A2 | 240.83,74.66 253.53,74.66 255.05,73.14 D10.A2 256.07,73.14 259.62,73.14 261.15,74.66 265.72,74.66 266.74,73.65 268.26,73.65 D09.A2 268.77,73.65 269.78,74.66 282.99,74.66 | 282.99,74.66 284.01,73.65 D08.A2 | 282.99,74.66 292.64,74.66 293.66,73.65 295.69,73.65 296.2,73.14 D07.A2 | CD18.AA2 148.37,142.74 149.9,141.21 157.52,141.21 158.53,142.23 160.06,142.23 C17.A2 161.07,142.74 162.6,141.21 178.34,141.21 | 178.34,141.21 176.82,142.74 C16.A2 | 187.49,141.21 178.34,141.21 | 187.49,141.21 188.5,142.23 C15.A2 | 187.49,141.21 200.19,141.21 201.2,142.23 C14.A2 202.22,142.74 202.73,142.74 204.25,141.21 212.89,141.21 213.9,142.23 C13.A2 214.92,142.74 216.44,141.21 223.56,141.21 225.08,142.74 229.14,142.74 C12.A2 230.67,142.74 232.19,141.21 240.83,141.21 | C01.A2 375.96,142.23 371.89,142.23 370.88,141.21 365.8,141.21 364.27,142.74 C02.A2 363.26,142.23 359.19,142.23 358.18,141.21 353.1,141.21 351.57,142.74 C03.A2 350.56,142.74 347,142.74 345.48,141.21 340.4,141.21 338.87,142.74 C04.A2 337.86,142.74 331.25,142.74 329.73,141.21 323.63,141.21 322.62,142.23 C05.A2 321.6,142.74 320.08,141.21 310.93,141.21 309.92,142.23 C06.A2 308.9,143.24 307.38,144.77 298.74,144.77 297.22,143.24 C07.A2 296.2,142.74 295.69,142.23 292.64,142.23 291.63,141.21 281.98,141.21
  Top 0.635: 240.83,141.21 242.35,142.74 C11.A2 | 253.53,141.21 255.05,142.74 C10.A2 | 253.53,141.21 240.83,141.21 | 266.23,141.21 267.75,142.74 C09.A2 | 266.23,141.21 253.53,141.21 | 281.98,141.21 283.5,142.74 C08.A2 | 266.23,141.21 v278.42,141.21 281.98,141.21 | 240.83,277.86 231.68,277.86 230.67,276.85 A12.A2 229.65,276.34 228.13,277.86 223.56,277.86 223.05,278.37 203.24,278.37 201.71,276.85 A14.A2 201.2,276.85 200.19,277.86 187.49,277.86 | 240.83,277.86 242.35,276.34 A11.A2 | 253.53,277.86 255.05,276.34 A10.A2 | 240.83,277.86 253.53,277.86 | 266.23,277.86 267.75,276.34 A09.A2 | 253.53,277.86 266.23,277.86 | 281.98,277.86 283.5,276.34 A08.A2 | 266.23,277.86 281.98,277.86 | 281.98,277.86 294.68,277.86 296.2,276.34 A07.A2 297.22,276.85 298.74,278.37 371.89,278.37 373.42,276.85 375.96,276.85 AB01.AA2 376.97,275.83 379,273.8 379.51,273.8 AB01.AB1 379.51,272.28 381.54,270.24 382.05,270.24 AB01.AC1 | 187.49,277.86 178.34,277.86 176.82,276.34 A16.A2 175.8,276.85 174.79,277.86 146.34,277.86 | 187.49,277.86 188.5,276.85 A15.A2 | 91.48,277.86 86.4,277.86 85.89,277.36 81.82,277.36 81.32,276.85 A23.A2 | 91.48,277.86 93,276.34 A22.A2 | 104.18,277.86 105.7,276.34 A21.A2 | 104.18,277.86 91.48,277.86 | 120.94,277.86 121.96,276.85 A20.A2 | 120.94,277.86 104.18,277.86 | 146.34,277.86 145.83,278.37 126.53,278.37 126.02,277.86 120.94,277.86 | 146.34,277.86 147.36,276.85 A18.A2 | AB01.AL1 379.51,248.4 381.54,250.43 382.05,250.43 AB01.AK1 | AB01.AE1 382.05,263.13 380.02,261.1 379.51,261.1 AB01.AF1 | AB01.BD1 380.02,197.09 382.56,199.63 AB01.BC1 | 349.54,204.71 343.44,204.71 342.94,205.22 339.89,205.22 338.87,206.24 B04.A2 337.86,206.74 337.35,207.25 331.25,207.25 330.74,207.76 325.16,207.76 324.14,206.74 322.62,206.74 B05.A2 321.6,206.24 320.08,207.76 308.39,207.76
  Top 0.635: 349.54,204.71 350.56,205.73 B03.A2 | 362.24,204.71 363.26,205.73 B02.A2 | 362.24,204.71 349.54,204.71 | 362.24,204.71 370.88,204.71 371.89,205.73 375.96,205.73 AB01.BA2 | B22.A2 94.02,206.74 95.03,207.76 102.14,207.76 103.67,206.24 105.7,206.24 B21.A2 106.72,206.74 109.26,206.74 110.27,207.76 120.94,207.76 121.96,206.74 B20.A2 122.97,206.74 124.5,206.74 126.53,208.78 147.36,208.78 147.36,206.74 B18.A2 148.37,206.74 150.4,208.78 160.06,208.78 160.56,208.27 170.72,208.27 172.25,206.74 175.8,206.74 B16.A2 176.82,206.24 177.84,207.25 180.88,207.25 181.39,207.76 187.49,207.76 188.5,206.74 B15.A2 189.52,206.24 192.57,206.24 194.09,207.76 196.12,207.76 197.65,206.24 201.2,206.24 B14.A2 202.22,206.24 203.74,207.76 212.89,207.76 213.9,206.74 B13.A2 214.92,206.24 216.44,207.76 228.13,207.76 229.65,206.24 B12.A2 230.67,206.74 231.68,207.76 240.83,207.76 | 294.68,207.76 285.53,207.76 284.52,206.74 B08.A2 284.01,206.74 282.99,207.76 269.78,207.76 268.77,206.74 B09.A2 267.75,206.24 266.23,207.76 253.53,207.76 | 294.68,207.76 296.2,206.24 B07.A2 | 308.39,207.76 309.41,206.74 B06.A2 | 308.39,207.76 294.68,207.76 | 240.83,207.76 242.35,206.24 B11.A2 | 253.53,207.76 255.05,206.24 B10.A2 | 253.53,207.76 240.83,207.76
  Bottom 0.635: D16.A2 175.8,73.65 170.22,79.24 170.22,135.12 171.23,136.13 171.23,140.7 172.76,142.23 175.8,142.23 C16.A2 | AB01.AL1 379.51,248.4 379.51,253.48 AB01.AJ1 379.51,254.5 379.51,259.58 AB01.AF1 380.02,260.08 380.02,259.58 382.05,257.54 AB01.AH1 | AB01.AE1 382.05,263.64 382.05,264.15 380.02,266.18 AB01.AD1 380.02,267.2 380.02,267.7 382.05,269.74 AB01.AC1 | AB01.BE1 382.05,194.04 379.51,194.04 379.51,196.08 AB01.BD1 379.51,197.6 379.51,202.68 AB01.BB1 379,203.19 376.46,205.73 AB01.BA2 | AB01.AK1 383.07,250.43 385.1,248.4 385.1,204.2 383.07,202.17 383.07,200.65 AB01.BC1 | v278.42,141.21 278.42,197.6 284.01,203.19 284.01,205.73 B08.A2
W01  (via drill 0.61)
  Top 0.254: v20.86,252.46 35.09,252.46 36.1,253.48 A26.J2 | v19.34,218.94 19.85,219.44 41.18,219.44 42.71,217.92 44.23,217.92 48.3,213.86 48.3,211.82 v48.8,211.82 | v53.88,147.82 52.36,146.29 v50.84,146.29 | v54.39,93.97 61.5,86.86 80.3,86.86 91.48,75.68 104.18,75.68 v104.68,76.19 | v113.32,51.3 114.84,49.77 117.89,49.77 118.4,49.26 v132.62,49.26 | v135.16,43.68 135.67,43.17 139.23,43.17 v140.75,44.69 | v139.74,50.28 140.24,50.79 CD18.BJ2
  Bottom 0.254: v20.86,252.46 19.34,252.46 19.34,224.52 19.85,224.02 19.85,219.44 v19.34,218.94 | v48.8,211.82 48.8,205.73 53.88,200.65 v53.88,147.82 | v50.84,146.29 50.84,141.72 54.39,138.16 v54.39,93.97 | v104.68,76.19 105.19,75.68 105.19,72.12 108.24,69.08 108.24,68.06 110.78,65.52 110.78,53.84 v113.32,51.3 | v132.62,49.26 133.64,48.25 133.64,46.72 135.16,45.2 v135.16,43.68 | v140.75,44.69 140.24,45.2 140.24,46.72 139.74,47.23 v139.74,50.28
W02  (via drill 0.61)
  Top 0.254: v42.71,250.43 40.17,250.43 A26.K2 | v43.22,239.26 v45.25,241.29 | v46.77,227.06 47.28,226.56 v47.28,223 | v43.22,218.94 v47.28,218.94 | v43.22,216.9 43.22,212.33 28.99,212.33 27.98,213.35 26.96,213.35 26.45,212.84 v26.45,210.3 | v20.86,203.19 19.34,201.66 19.34,153.91 v20.36,153.91 | v19.34,141.72 19.85,141.21 37.63,141.21 v55.41,123.43 | v56.93,29.45 57.44,29.96 82.84,29.96 85.89,26.91 v119.92,26.91
  Route2 0.254: v40.17,234.18 40.17,233.67 v46.77,227.06 | v26.45,210.3 26.45,208.78 v20.86,203.19
  Bottom 0.254: v42.71,250.43 44.74,248.4 44.74,241.8 v45.25,241.29 | v43.22,239.26 42.71,238.75 42.71,236.72 42.2,236.21 40.17,236.21 v40.17,234.18 | v47.28,218.94 v47.28,223 | v43.22,216.9 v43.22,218.94 | v20.36,153.91 20.36,144.77 19.34,143.75 v19.34,141.72 | v55.41,123.43 59.98,118.86 59.98,44.69 56.93,41.64 v56.93,29.45 | v119.92,26.91 128.56,18.28 128.56,10.66 130.08,9.13 143.8,9.13 143.8,18.78 CD18.BV2
W03  (via drill 0.61)
  Top 0.254: v36.1,243.32 33.06,240.27 31.53,240.27 27.98,236.72 15.28,236.72 4.61,226.05 v4.1,226.05 | v18.32,206.24 12.74,200.65 12.74,150.86 v12.23,150.86 | v23.91,86.35 54.39,55.87 v104.68,55.87 | v114.34,59.93 116.37,61.96 v128.05,61.96 | v129.07,65.01 137.2,65.01 v137.7,65.52
  Route2 0.254: v4.1,220.46 v18.32,206.24
  Route15 0.254: v137.7,65.52 140.24,65.52 143.8,61.96 146.34,61.96 147.36,60.95 CD18.BE2
  Bottom 0.254: v36.1,243.32 36.1,246.37 36.61,246.88 A26.L2 | v4.1,226.05 v4.1,220.46 | v12.23,150.86 12.23,140.7 12.74,140.2 12.74,97.52 v23.91,86.35 | v104.68,55.87 105.19,55.36 105.19,51.8 112.81,44.18 114.84,44.18 114.84,59.42 v114.34,59.93 | v128.05,61.96 129.07,62.98 v129.07,65.01
W04  (via drill 0.61)
  Top 0.254: v15.28,239.76 18.83,239.76 21.88,242.81 34.07,242.81 35.6,244.34 39.15,244.34 A26.M2 | v24.42,205.22 v36.1,193.54 | v38.14,96 38.64,96.51 99.6,96.51 102.14,93.97 v106.21,93.97 | v108.24,93.97 108.24,96.51 142.78,96.51 143.8,95.49 CD18.AT2
  Route15 0.254: v14.26,223 16.29,220.97 19.85,220.97 v23.4,217.41
  Bottom 0.254: v15.28,239.76 15.78,239.26 15.78,224.52 v14.26,223 | v23.4,217.41 24.42,216.4 v24.42,205.22 | v36.1,193.54 38.14,191.5 v38.14,96 | v106.21,93.97 v108.24,93.97
W05  (via drill 0.61)
  Top 0.254: v27.47,235.7 27.98,235.7 32.04,239.76 35.09,239.76 36.1,240.78 A26.N2 | v25.44,237.73 22.9,240.27 v20.86,240.27 | v20.36,242.81 16.8,242.81 v4.1,230.11 | v12.74,206.74 4.1,198.11 4.1,148.32 29.5,148.32 31.02,146.8 v33.06,146.8 | v35.09,55.87 38.64,52.31 104.68,52.31 107.22,49.77 108.24,49.77 108.75,49.26 115.35,49.26 v117.38,47.23 | v122.97,31.99 124.5,30.47 v133.13,30.47 | v143.29,21.83 147.36,21.83 CD18.BU2
  Route2 0.254: v4.1,216.4 13.24,207.25 v12.74,206.74
  Bottom 0.254: v25.44,237.73 v27.47,235.7 | v20.86,240.27 20.36,240.78 v20.36,242.81 | v4.1,230.11 3.08,229.1 3.08,217.41 v4.1,216.4 | v33.06,146.8 34.58,145.28 34.58,120.89 32.04,118.35 32.04,108.19 35.09,105.14 v35.09,55.87 | v117.38,47.23 117.89,46.72 117.89,41.64 120.94,38.6 120.94,34.02 v122.97,31.99 | v133.13,30.47 133.64,29.96 133.64,20.82 136.69,17.77 143.29,17.77 v143.29,21.83
W06  (via drill 0.61)
  Top 0.254: v144.82,111.24 147.36,111.24 CD18.AM2 | v141.77,108.7 141.26,109.21 108.24,109.21 108.24,108.19 105.19,108.19 103.67,109.72 v72.17,109.72 | v71.66,154.42 63.54,162.55 60.49,162.55 v52.87,170.17 | v50.84,199.63 46.26,204.2 44.23,204.2 v43.22,205.22 | v42.2,213.35 37.12,218.43 v20.86,218.43 | v20.86,221.48 20.36,220.97 16.29,220.97 16.29,227.06 26.45,227.06 33.06,233.67 v33.56,233.67 | v36.1,233.16 36.61,233.67 37.63,233.67 39.15,235.19 39.15,237.73 A26.P2
  Route2 0.254: v144.82,111.24 144.31,111.24 v141.77,108.7 | v33.56,233.67 35.09,232.14 v36.1,233.16
  Bottom 0.254: v72.17,109.72 72.68,110.22 72.68,142.74 72.17,143.24 72.17,150.36 72.68,150.86 72.68,153.4 v71.66,154.42 | v52.87,170.17 50.84,172.2 v50.84,199.63 | v43.22,205.22 42.2,206.24 v42.2,213.35 | v20.86,218.43 v20.86,221.48
W07  (via drill 0.61)
  Top 0.254: v147.36,120.38 145.83,121.91 v139.23,121.91 | v138.21,118.35 137.7,118.86 115.35,118.86 114.84,118.35 113.83,118.35 112.81,119.37 46.77,119.37 27.98,138.16 v20.86,138.16 | v12.23,209.79 4.1,209.79 2.58,211.32 2.58,224.52 11.21,224.52 20.36,233.67 31.53,233.67 v36.1,238.24
  Bottom 0.254: v147.36,120.38 147.36,117.84 CD18.AK2 | v139.23,121.91 139.74,121.4 139.74,119.88 v138.21,118.35 | v20.86,138.16 18.83,140.2 18.83,140.7 18.32,141.21 18.32,150.86 18.83,151.37 18.83,204.2 14.26,208.78 12.23,208.78 v12.23,209.79 | v36.1,238.24 36.61,237.73 36.61,235.7 A26.R2
W08  (via drill 0.61)
  Top 0.254: v147.36,114.8 150.4,114.8 CD18.AL1 | v141.77,113.78 139.74,115.81 v69.12,115.81 | v68.11,170.68 59.47,179.31 v56.42,179.31 | v55.41,205.73 53.38,207.76 43.72,207.76 v43.22,207.25 | v43.22,211.32 v46.26,214.36 | v46.26,220.97 46.26,224.02 45.25,224.02 v42.71,226.56
  Route2 0.254: v147.36,114.8 145.32,116.83 144.31,115.81 143.8,115.81 v141.77,113.78 | v42.71,226.56 39.15,230.11 40.17,231.13 A26.S2
  Bottom 0.254: v69.12,115.81 69.63,116.32 69.63,169.15 v68.11,170.68 | v56.42,179.31 56.93,179.82 56.93,204.2 v55.41,205.73 | v43.22,211.32 v43.22,207.25 | v46.26,214.36 v46.26,220.97
W09  (via drill 0.61)
  Top 0.254: v39.15,214.87 37.63,213.35 v30.52,213.35 | v26.45,201.66 25.44,200.65 25.44,156.96 53.88,156.96 57.95,152.9 63.54,152.9 64.04,153.4 79.28,153.4 v80.81,151.88 | v81.82,65.01 120.43,65.01 121.45,64 v122.46,64 | v128.56,57.9 129.07,58.41 139.74,58.41 140.75,57.39 143.8,57.39 CD18.BF2
  Route2 0.254: v30.01,205.22 v26.45,201.66 | v126.02,60.44 v128.56,57.9
  Route15 0.254: v39.15,223.51 v36.1,226.56
  Bottom 0.254: v36.1,226.56 36.1,228.08 A26.T2 | v39.15,223.51 v39.15,214.87 | v30.52,213.35 30.01,212.84 v30.01,205.22 | v80.81,151.88 82.33,150.36 82.33,65.52 v81.82,65.01 | v122.46,64 v126.02,60.44
W+UTS  (via drill 0.61)
  Top 0.254: v219.49,109.72 221.52,109.72 222.54,110.73 229.14,110.73 C12.M2 | v219.49,146.29 218.98,146.8 175.3,146.8 v174.79,146.29 | v170.72,259.07 183.42,259.07 184.95,257.54 188.5,257.54 A15.H2
  Bottom 0.254: v219.49,146.29 v219.49,109.72 | v174.79,146.29 169.71,151.37 169.71,180.33 171.23,181.85 171.23,182.87 170.22,183.88 170.22,245.35 171.23,246.37 171.23,248.4 170.72,248.91 v170.72,259.07 | A15.A1 195.11,275.83 195.11,271.77 190.54,267.2 190.54,258.56 189.52,257.54 A15.H2
W-INH\  (via drill 0.61)
  Top 0.254: v244.89,184.9 244.38,185.41 242.35,185.41 240.83,186.93 237.27,186.93 B12.H1 | v273.34,218.94 278.42,218.94 280.96,221.48 A08.V2 | v264.7,209.79 264.2,209.28 249.46,209.28 248.45,210.3 v235.75,210.3
  Bottom 0.254: v244.89,184.9 244.89,178.3 245.4,177.79 B11.L1 | v273.34,218.94 272.32,219.95 264.2,219.95 264.2,210.3 v264.7,209.79 | v235.75,210.3 235.24,209.79 235.24,188.96 236.26,187.95 236.26,187.44 B12.H1
WB00  (via drill 0.61)
  Top 0.254: v53.88,230.62 54.39,230.11 v99.6,230.11 | v152.44,222.49 152.44,223.51 141.77,223.51 139.23,220.97 102.14,220.97 v101.64,221.48 | v183.42,151.88 181.9,153.4 175.3,153.4 v174.79,152.9 | v171.23,170.17 159.55,170.17 159.04,169.66 145.83,169.66 144.82,170.68 B18.N2 | v249.46,45.71 230.67,45.71 228.13,43.17 225.59,43.17 223.05,45.71 214.92,45.71 214.41,46.22 v200.7,46.22 | v200.19,48.25 199.68,47.74 197.65,47.74 196.12,46.22 178.34,46.22 177.84,45.71 135.67,45.71 133.13,43.17 v122.97,43.17 | v121.45,125.46 121.45,129.02 120.94,129.02 120.94,138.16 126.53,138.16 v129.58,141.21 | v130.08,152.39 130.08,151.88 131.1,150.86 v145.32,150.86
  Route2 0.254: v259.62,60.44 271.82,72.63 274.36,72.63 D09.A1 | v252,46.72 250.48,46.72 v249.46,45.71
  Route15 0.254: v203.74,130.54 203.74,131.56 v183.42,151.88
  Bottom 0.254: v53.88,230.62 53.88,236.72 52.87,237.73 A25.P2 | 101.64,230.11 v99.6,230.11 | 101.64,230.11 101.64,237.22 102.65,238.24 102.65,240.78 A21.N2 | v152.44,222.49 152.44,201.16 149.39,198.11 149.39,180.33 145.32,176.26 145.32,172.71 144.82,172.2 B18.N2 144.82,170.68 145.83,169.66 145.83,151.37 v145.32,150.86 | v101.64,221.48 101.64,230.11 | v203.74,130.54 203.74,128 204.25,127.5 C14.F1 | v174.79,152.9 170.72,156.96 170.72,169.66 v171.23,170.17 | v259.62,60.44 257.08,60.44 257.08,59.42 256.58,58.92 256.58,55.36 257.08,54.85 257.08,51.8 v252,46.72 | v200.7,46.22 200.19,46.72 v200.19,48.25 | v122.97,43.17 120.43,45.71 120.43,58.92 117.38,61.96 117.38,122.42 119.92,124.96 121.45,124.96 v121.45,125.46 | v129.58,141.21 130.59,142.23 130.59,151.88 v130.08,152.39
WB00\  (via drill 0.61)
  Top 0.254: v115.35,170.68 115.86,170.17 143.8,170.17 145.32,168.64 147.36,168.64 B18.P2 148.37,168.14 151.42,168.14 152.94,166.61 174.79,166.61 175.3,166.1 186.98,166.1 187.49,165.6 189.52,165.6 v190.54,164.58 | 200.19,153.4 200.19,153.91 v192.57,153.91 | 200.19,153.4 v200.19,150.86 | v230.67,150.86 v237.27,150.86 | v224.57,146.29 v229.14,146.29 | v224.57,151.37 224.06,150.86 214.92,150.86 212.38,153.4 200.19,153.4
  Route15 0.254: v201.2,140.2 v207.3,134.1 | v237.27,150.86 243.37,144.77 245.91,144.77 246.42,144.26 249.97,144.26 258.61,135.62 258.61,134.1 C10.D1
  Bottom 0.254: v115.35,170.68 115.86,171.18 115.86,199.63 114.34,201.16 114.34,227.06 108.24,233.16 108.24,236.21 106.72,237.73 A21.P2 | v207.3,134.1 207.3,130.54 C14.E1 | v201.2,140.2 200.19,141.21 v200.19,150.86 | v192.57,153.91 190.54,155.94 v190.54,164.58 | v230.67,150.86 229.14,149.34 v229.14,146.29 | v224.57,151.37 v224.57,146.29
WB01  (via drill 0.61)
  Top 0.254: v41.69,233.67 47.79,233.67 48.8,234.68 A25.R2 | v40.68,179.31 51.85,179.31 61.5,169.66 98.59,169.66 | 98.59,169.66 105.7,169.66 108.75,172.71 112.81,172.71 113.83,171.69 118.4,171.69 B20.N2 | v195.11,115.81 194.6,115.3 193.58,115.3 193.58,113.27 193.08,113.27 192.06,112.26 v191.55,112.26 | v171.74,85.84 v166.66,85.84 | v165.14,87.87 164.63,87.36 159.04,87.36 158.53,86.86 150.4,86.86 149.9,87.36 142.28,87.36 141.26,86.35 137.7,86.35 | 137.7,86.35 127.54,86.35 127.04,86.86 126.02,86.86 125.51,87.36 106.72,87.36 103.67,90.41 99.6,90.41 v97.57,92.44 | v98.59,163.06 98.59,169.66 | v269.28,56.88 270.8,56.88 D09.F1 | v261.66,56.88 259.12,59.42 257.08,59.42 256.07,58.41 250.48,58.41 v248.96,56.88 | v247.94,36.06 244.89,33.01 237.27,33.01 v236.26,31.99 | v231.18,15.74 230.67,16.24 216.95,16.24 216.44,15.74 v212.89,15.74 | v194.6,18.28 194.09,17.77 183.93,17.77 182.92,16.75 142.78,16.75 v140.75,18.78 | 137.7,86.35 v137.7,85.33
  Route2 0.254: v191.55,112.26 189.52,114.29 v178.34,103.11 | v269.28,56.88 267.24,56.88 266.23,55.87 262.67,55.87 v261.66,56.88
  Route15 0.254: v248.96,56.88 246.42,54.34 v247.43,53.33 | v232.19,27.93 v236.26,31.99
  Bottom 0.254: v41.69,233.67 41.18,233.16 41.18,224.02 40.68,223.51 40.68,207.76 41.18,207.25 41.18,179.82 v40.68,179.31 | v195.11,115.81 196.12,115.81 196.63,116.32 196.63,118.35 198.16,119.88 C14.J2 | v178.34,103.11 171.74,103.11 v171.74,85.84 | v166.66,85.84 165.14,87.36 v165.14,87.87 | v97.57,92.44 98.08,92.95 98.08,150.86 98.59,151.37 v98.59,163.06 | v247.43,53.33 248.96,51.8 248.96,50.28 250.48,48.76 250.48,44.69 247.94,42.15 v247.94,36.06 | v232.19,27.93 231.18,26.91 231.18,23.36 231.68,22.85 231.68,16.24 v231.18,15.74 | v212.89,15.74 212.38,15.23 212.38,12.69 202.22,2.53 194.6,2.53 v194.6,18.28 | v140.75,18.78 136.69,22.85 136.69,74.16 137.7,75.17 v137.7,85.33
WB01\  (via drill 0.61)
  Top 0.254: v198.16,124.45 201.2,124.45 C14.H2 | v189.52,132.07 186.98,134.61 165.64,134.61 165.14,135.12 v126.02,135.12 | v253.02,59.42 252.51,58.92 246.92,58.92 246.42,58.41 243.37,58.41 v240.83,55.87 | v211.36,77.71 209.84,79.24 209.84,80.25 186.98,80.25 186.47,80.76 186.47,82.79 v187.49,82.79 | v154.47,80.25 v134.66,80.25 | v134.66,76.19 v128.56,76.19 | v123.48,57.39 121.96,55.87 v116.37,55.87
  Route2 0.254: v187.49,82.79 186.98,82.79 181.39,77.2 181.39,75.68 v178.34,72.63 | v170.72,72.63 167.68,75.68 161.07,75.68 155.48,81.27 v154.47,80.25
  Route15 0.254: v198.16,124.45 197.14,124.45 v189.52,132.07 | v263.69,111.75 263.69,105.65 v266.23,103.11 | v264.7,54.34 263.69,54.34 262.67,55.36 257.08,55.36 v253.02,59.42 | v240.83,55.87 238.8,55.87 234.73,59.93 234.73,60.44 233.21,61.96 232.7,61.96 230.16,64.5 228.13,64.5 227.62,65.01 226.6,65.01 226.1,65.52 225.08,65.52 213.4,77.2 211.87,77.2 v211.36,77.71
  Bottom 0.254: 125.51,135.62 123.99,137.15 123.99,163.06 122.46,164.58 122.46,167.63 B20.P2 | 125.51,135.62 v126.02,135.12 | v263.69,111.75 262.67,112.76 262.67,116.32 262.16,116.83 C10.K1 | v266.23,103.11 266.74,102.6 266.74,87.36 264.2,84.82 264.2,73.14 266.74,70.6 266.74,56.38 v264.7,54.34 | v178.34,72.63 177.33,71.62 170.72,71.62 v170.72,72.63 | v134.66,80.25 134.15,79.74 134.15,76.7 v134.66,76.19 | v128.56,76.19 120.94,68.57 120.94,64 123.48,61.46 v123.48,57.39 | v116.37,55.87 115.86,56.38 115.86,125.97 125.51,135.62
WB02  (via drill 0.61)
  Top 0.254: 88.94,224.02 90.97,224.02 91.48,223.51 96.05,223.51 99.6,227.06 110.27,227.06 112.3,229.1 113.32,229.1 v117.89,233.67 | 88.94,224.02 72.68,224.02 69.63,227.06 54.9,227.06 54.39,227.57 52.87,227.57 52.87,231.13 A25.S2 | v262.16,16.75 261.66,16.24 245.4,16.24 v244.89,16.75 | v236.26,36.56 v243.37,36.56 | v234.22,35.55 233.21,36.56 212.89,36.56 211.87,35.55 v210.86,35.55 | v208.82,38.09 206.79,40.12 203.24,40.12 202.73,39.61 194.6,39.61 v192.57,41.64 191.55,41.64 189.52,39.61 176.82,39.61 v174.79,37.58 | v203.74,110.73 207.3,110.73 C14.M1 | v88.94,221.48 88.94,224.02 | v88.94,194.04 88.94,192.01 70.14,192.01 68.11,189.98 v67.09,189.98 | v80.81,32.5 81.32,33.01 147.36,33.01 149.9,30.47 153.45,30.47 156.5,33.52 167.68,33.52 169.71,35.55 v171.74,35.55
  Route2 0.254: v236.26,36.56 235.24,36.56 v234.22,35.55
  Route15 0.254: v271.82,22.85 v275.88,26.91 | v191.55,91.43 191.55,93.46 190.54,94.48 190.54,97.52 v203.74,110.73
  Bottom 0.254: v117.89,233.67 117.89,239.76 118.91,240.78 A20.N2 | v275.88,26.91 275.88,29.45 275.37,29.96 275.37,30.98 275.88,31.48 275.88,39.61 274.86,40.63 D09.M1 | v271.82,22.85 264.7,15.74 262.16,15.74 v262.16,16.75 | v244.89,16.75 244.89,23.36 243.88,24.37 243.88,27.42 244.38,27.93 244.38,35.55 v243.37,36.56 | v210.86,35.55 208.82,37.58 v208.82,38.09 | v192.57,41.64 190.54,43.68 190.54,67.55 189.52,68.57 189.52,71.11 190.54,72.12 190.54,90.41 v191.55,91.43 | v88.94,221.48 91.98,218.43 91.98,200.14 88.94,197.09 v88.94,194.04 | v67.09,189.98 65.57,188.46 63.03,188.46 63.03,155.94 63.54,155.44 63.54,151.37 66.08,148.83 66.08,146.29 63.03,143.24 63.03,50.28 v80.81,32.5 | v171.74,35.55 174.79,35.55 v174.79,37.58
WB02\  (via drill 0.61)
  Top 0.254: v194.09,71.62 v233.72,71.62 | v237.27,82.28 239.3,84.32 v265.21,84.32 | v269.78,97.02 v258.61,97.02 | v121.96,241.8 120.94,242.81 113.83,242.81 113.32,242.3 110.78,242.3 110.27,242.81 96.05,242.81 94.52,241.29 v94.52,240.78 | v91.98,224.52 v91.98,227.57 | v93,214.36 89.44,210.81 v82.33,210.81 | v78.78,207.25 76.24,204.71 69.12,204.71 66.08,201.66 v50.33,201.66 | v43.72,146.29 43.72,144.26 v70.65,144.26 | v79.79,45.2 81.82,43.17 116.37,43.17 122.46,37.07 124.5,37.07 125,36.56 v145.32,36.56 | v152.44,29.45 152.94,29.96 158.53,29.96 v160.06,31.48 | v171.23,57.39 v168.18,57.39
  Route2 0.254: v78.78,207.25 v82.33,210.81
  Route15 0.254: v201.2,113.78 197.14,109.72 194.09,109.72 v193.08,110.73 | v43.72,195.06 v50.33,201.66 | v180.38,60.44 183.42,63.49 184.95,61.96 190.54,61.96 v191.55,60.95
  Bottom 0.254: v201.2,113.78 204.25,113.78 C14.L1 | v193.08,110.73 193.58,110.22 193.58,90.41 194.09,89.9 v194.09,71.62 194.09,63.49 v191.55,60.95 | v233.72,71.62 237.78,71.62 237.78,81.78 v237.27,82.28 | v265.21,84.32 269.78,88.89 v269.78,97.02 | v258.61,97.02 258.61,101.08 C10.R1 | v121.96,241.8 121.96,238.75 A20.P2 | v94.52,240.78 95.03,240.27 95.03,235.19 91.98,232.14 v91.98,227.57 | v91.98,224.52 93,223.51 v93,214.36 | v43.72,195.06 44.23,194.55 44.23,146.8 v43.72,146.29 | v70.65,144.26 70.14,143.75 70.14,92.44 79.79,82.79 v79.79,45.2 | v145.32,36.56 152.44,36.56 v152.44,29.45 | v160.06,31.48 165.14,36.56 168.69,36.56 168.69,56.88 v168.18,57.39 | v171.23,57.39 171.74,57.9 171.74,58.41 172.25,58.92 180.38,58.92 v180.38,60.44
WC  (via drill 0.61)
  Top 0.254: v59.98,252.46 56.93,255.51 52.36,255.51 51.85,256.02 47.79,256.02 46.77,257.04 A26.H1 | v61.5,148.32 62.01,148.83 240.83,148.83 243.88,145.78 250.48,145.78 v250.99,146.29 | B10.M1 261.66,174.23 258.61,174.23 256.07,176.77 256.07,178.3 254.54,178.3 252.51,180.33 249.97,180.33 B11.K1
  Bottom 0.254: D11.S1 249.97,28.94 250.99,29.96 250.99,74.16 249.46,75.68 249.46,89.9 250.99,91.43 v250.99,146.29 250.99,175.76 249.97,176.77 249.97,180.33 B11.K1 | v59.98,252.46 61,251.45 61,150.36 61.5,149.85 v61.5,148.32
WC0  (via drill 0.61)
  Top 0.254: v316.52,114.8 313.98,112.26 310.42,112.26 309.92,111.75 C06.M2 | v318.55,116.83 322.62,120.89 v323.12,120.89 | v344.46,134.1 347,131.56 v348.02,131.56 | v348.52,138.16 354.62,138.16 356.65,140.2 358.68,140.2 359.7,141.21 362.75,141.21 v363.26,140.7 | v372.91,131.05 373.42,131.56 379,131.56 v382.05,128.51
  Route2 0.254: v318.55,116.83 v316.52,114.8 | v323.12,120.89 324.14,121.91 325.66,121.91 326.68,122.92 326.68,123.94 328.2,125.46 329.73,125.46 v337.35,133.08
  Route15 0.254: v337.35,133.08 340.4,136.13 340.9,135.62 342.94,135.62 v344.46,134.1 | v363.26,140.7 363.26,139.18 365.29,137.15 366.81,137.15 v372.91,131.05
  Bottom 0.254: v348.02,131.56 349.03,131.56 349.03,137.66 v348.52,138.16 | v382.05,128.51 382.56,128 382.56,124.45 C01.H1
WC0\  (via drill 0.61)
  Top 0.254: v254.04,60.44 254.04,63.49 v256.07,63.49 | v262.67,70.09 263.69,71.11 267.75,71.11 v268.26,70.6
  Route2 0.254: v256.07,63.49 v262.67,70.09 | v275.37,79.24 275.37,79.74 286.04,90.41 291.12,90.41 296.71,96 296.71,96.51 297.22,97.02 297.72,97.02 v305.85,105.14
  Route15 0.254: v248.45,44.18 249.46,44.18 250.99,45.71 250.99,47.23 v252,48.25
  Bottom 0.254: v248.45,44.18 247.43,43.17 247.43,37.07 246.92,36.56 246.92,33.01 246.42,32.5 D11.R1 | v252,48.25 254.04,50.28 v254.04,60.44 | v268.26,70.6 275.37,77.71 v275.37,79.24 | v305.85,105.14 306.36,105.65 306.36,107.18 C06.N2
WC\  (via drill 0.61)