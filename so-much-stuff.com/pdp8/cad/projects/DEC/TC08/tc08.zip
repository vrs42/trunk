# EAGLE board tc08 (EAGLE 4.11), part 5 of 10
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
I/O_BAC_03  (via drill 0.61)
  Top 0.254: v388.15,55.36 371.38,55.36 370.37,54.34 D02.H1 | v386.12,6.59 381.54,2.02 297.22,2.02 296.2,3.04 290.61,3.04 289.6,2.02 247.94,2.02 246.42,3.54 245.4,3.54 244.38,2.53 117.89,2.53 v116.37,4.05 | v116.88,125.46 116.88,129.53 v116.37,129.53 | v120.94,284.98 153.45,284.98 153.96,284.47 175.8,284.47 176.31,283.96 195.11,283.96 195.62,284.47 218.98,284.47 220,285.48 220,291.58 228.13,291.58 228.64,291.07 236.76,291.07 237.78,290.06 239.81,290.06 240.32,289.55 241.84,289.55 242.35,289.04 259.12,289.04 260.13,290.06 261.15,290.06 262.67,288.53 285.53,288.53 286.04,289.04 289.6,289.04 290.61,290.06 297.22,290.06 298.23,291.07 299.25,291.07 300.77,289.55 310.42,289.55 310.93,290.06 311.95,290.06 320.58,281.42 367.83,281.42 v368.34,281.93 | v360.21,116.83 360.72,116.32 362.24,116.32 362.75,115.81 371.38,115.81 371.89,116.32 v374.94,116.32 | v373.92,147.82 374.43,148.32 v375.96,148.32 | v381.04,255 380.53,255.51 374.94,255.51 374.43,256.02 370.88,256.02 370.37,256.53 A02.H1
  Route15 0.254: v360.21,116.83 356.65,120.38 354.62,120.38 C03.J1
  Bottom 0.254: v388.15,55.36 388.66,54.85 388.66,27.42 389.16,26.91 389.16,25.9 386.12,22.85 v386.12,6.59 | v116.37,4.05 115.86,4.56 115.86,53.84 117.38,55.36 117.38,57.39 116.37,58.41 116.37,124.96 v116.88,125.46 | v116.37,129.53 115.86,130.04 115.86,142.23 120.43,146.8 120.43,155.44 120.94,155.94 120.94,209.28 117.89,212.33 117.89,225.03 120.94,228.08 120.94,241.8 117.38,245.35 117.38,268.72 120.94,272.28 v120.94,284.98 | v368.34,281.93 368.34,258.56 369.35,257.54 A02.H1 | v374.94,116.32 374.94,134.61 374.43,135.12 374.43,147.31 v373.92,147.82 | v375.96,148.32 375.96,153.4 374.94,154.42 374.94,177.28 377.99,180.33 377.99,186.93 379,187.95 379,188.96 377.99,189.98 377.99,196.08 374.94,199.12 374.94,207.25 375.96,208.27 384.08,208.27 384.08,247.38 382.05,249.42 381.04,249.42 v381.04,255
I/O_BAC_04  (via drill 0.61)
  Top 0.254: v340.4,117.84 341.41,117.84 343.44,115.81 348.52,115.81 349.54,114.8 353.6,114.8 C03.L1 | v326.68,85.84 327.19,85.84 334.81,78.22 v334.81,77.71 | v340.4,61.96 345.48,61.96 354.62,52.82 356.65,52.82 357.16,52.31 361.73,52.31 362.75,51.3 366.3,51.3 D02.J1 | v362.75,254.5 366.3,254.5 A02.J1 | v322.11,289.04 v359.7,289.04 | v315.5,284.98 313.98,286.5 296.2,286.5 295.69,285.99 v293.15,285.99 | v290.1,284.47 289.09,283.45 v281.47,283.45 | v254.54,265.67 254.04,265.16 249.97,265.16 246.92,268.21 245.4,268.21 244.89,267.7 244.89,265.16 245.4,265.16 245.91,264.66 245.91,262.12 242.35,262.12 v239.81,264.66 | v238.8,262.12 238.29,261.61 215.43,261.61 214.92,262.12 v186.47,262.12
  Route2 0.254: v260.13,263.13 258.1,263.13 255.05,266.18 v254.54,265.67 | v239.81,264.66 239.81,263.13 v238.8,262.12 | v146.34,178.8 146.34,177.28 145.32,176.26 145.32,174.74 143.29,172.71 143.29,160.01 139.74,156.45 139.74,129.53 151.93,117.34 149.39,114.8 149.39,99.05 174.79,73.65 174.79,72.12 176.31,70.6 176.82,71.11 186.98,71.11 222.54,35.55 225.08,35.55 227.62,33.01 243.37,33.01 253.53,43.17 276.9,43.17 279.44,45.71 281.98,45.71 283.5,44.18 285.02,44.18 287.56,41.64 289.09,43.17 294.68,43.17 296.2,44.69 297.72,44.69 309.92,56.88 310.42,56.88 310.93,57.39 310.93,58.41 312.46,59.93 312.46,60.44 312.96,60.95 313.98,60.95 321.09,68.06 328.71,68.06 330.74,70.09 330.74,73.65 v334.81,77.71
  Route15 0.254: v340.4,117.84 340.4,118.35 338.36,120.38 337.35,120.38 331.76,114.8 330.74,115.81 329.73,115.81 325.66,111.75 v325.16,112.26 | v281.47,283.45 278.93,280.91 278.42,281.42 275.37,281.42 v274.86,281.93 | v160.06,273.8 159.55,273.8 v157.52,275.83 | v150.4,225.03 v147.86,222.49 | v148.37,202.17 148.37,201.66 149.39,200.65 149.39,199.12 v147.36,197.09
  Bottom 0.254: v325.16,112.26 324.14,111.24 324.14,104.64 324.65,104.13 324.65,103.11 324.14,102.6 324.14,87.87 325.66,86.35 326.68,86.35 v326.68,85.84 | v334.81,77.71 336.84,75.68 336.84,65.52 v340.4,61.96 | v362.75,254.5 362.24,255 362.24,267.7 361.73,268.21 361.73,287.01 v359.7,289.04 | v322.11,289.04 315.5,289.04 v315.5,284.98 | v293.15,285.99 293.15,288.53 292.64,289.04 290.1,289.04 v290.1,284.47 | v274.86,281.93 270.8,277.86 264.7,277.86 264.7,274.82 263.18,273.29 263.18,262.62 262.67,262.12 260.13,262.12 v260.13,263.13 | v186.47,262.12 184.44,264.15 184.44,276.85 182.92,278.37 161.58,278.37 161.58,275.32 v160.06,273.8 | v157.52,275.83 155.48,277.86 152.44,277.86 152.44,227.06 v150.4,225.03 | v147.86,222.49 147.36,221.98 147.36,218.94 146.85,218.43 146.85,209.79 149.39,207.25 149.39,204.71 148.37,203.7 v148.37,202.17 | v147.36,197.09 146.34,196.08 v146.34,178.8
I/O_BAC_05  (via drill 0.61)
  Top 0.254: v361.22,22.85 361.22,21.83 361.73,21.32 361.73,17.77 351.57,17.77 349.03,20.31 v326.17,20.31 | v311.95,17.26 311.44,17.77 303.31,17.77 302.8,18.28 302.8,20.82 310.42,20.82 314.49,24.88 314.49,28.44 v311.44,28.44 | v306.87,271.26 v329.73,271.26 | v330.24,262.62 330.74,262.12 349.03,262.12 352.59,258.56 366.81,258.56 v368.34,257.04 | v335.82,110.73 330.24,116.32 330.24,118.86 321.6,118.86 319.57,116.83 319.57,115.81 v315.5,115.81
  Route2 0.254: v315.5,115.81 311.95,115.81 307.38,111.24 v307.38,110.73
  Route15 0.254: v369.86,253.48 v366.81,250.43 | v353.6,111.24 353.1,111.24 348.52,115.81 345.48,115.81 344.46,114.8 343.95,114.8 338.36,109.21 337.86,109.72 336.84,109.72 v335.82,110.73
  Bottom 0.254: v361.22,22.85 361.73,23.36 361.73,28.94 365.29,32.5 365.29,42.15 366.81,43.68 D02.L1 | v326.17,20.31 321.6,20.31 321.6,9.64 320.58,8.62 312.96,8.62 312.96,16.24 v311.95,17.26 | v311.44,28.44 310.93,28.94 310.93,36.06 310.42,36.56 307.88,36.56 307.88,74.66 309.41,76.19 309.41,88.89 307.88,90.41 307.88,110.73 | 307.88,110.73 307.88,145.78 306.87,146.8 306.87,150.36 307.88,151.37 307.88,204.2 306.87,205.22 306.87,220.46 307.88,221.48 307.88,229.6 305.34,232.14 305.34,233.67 304.84,234.18 304.84,268.21 306.87,270.24 v306.87,271.26 | v329.73,271.26 330.24,270.75 330.24,269.23 329.73,268.72 329.73,264.66 330.24,264.15 v330.24,262.62 | v368.34,257.04 368.34,256.53 369.86,255 v369.86,253.48 | v366.81,250.43 366.81,248.4 A02.L1 | v353.6,111.24 353.6,109.21 354.11,108.7 C03.N1 | 307.88,110.73 v307.38,110.73
I/O_BAC_06  (via drill 0.61)
  Top 0.254: v373.92,76.19 372.91,77.2 v356.14,77.2 | v367.32,244.84 369.35,244.84 A02.M1 | v362.24,289.04 361.22,290.06 353.6,290.06 353.1,289.55 323.12,289.55 322.62,290.06 321.6,290.06 v319.57,288.02 | v315.5,282.94 309.92,282.94 309.41,282.44 v299.76,282.44 | v291.12,273.8 290.61,274.31 279.94,274.31 277.4,271.77 264.2,271.77 263.18,272.78 261.66,272.78 260.13,274.31 256.07,274.31 253.02,271.26 v252.51,271.26 | v240.32,270.75 239.3,271.77 230.67,271.77 v229.65,272.78 | v223.05,271.26 213.4,271.26 v211.87,269.74 | v208.32,235.7 207.81,236.21 197.14,236.21 194.6,233.67 149.9,233.67 147.36,236.21 v133.13,236.21 | v125,160.52 v122.97,158.48 | v122.97,141.21 v128.05,141.21 | v129.58,13.2 130.08,12.69 132.62,12.69 133.64,11.67 188,11.67 189.01,12.69 204.25,12.69 209.33,17.77 212.38,17.77 213.4,18.78 214.92,18.78 216.44,20.31 218.98,20.31 220,19.29 225.08,19.29 226.1,20.31 237.78,20.31 238.29,20.82 252.51,20.82 254.04,22.34 254.04,22.85 255.05,23.86 257.08,23.86 v258.1,22.85
  Route2 0.254: v291.12,273.8 v299.76,282.44 | v252.51,271.26 240.83,271.26 v240.32,270.75 | v258.1,22.85 258.61,22.85 259.12,23.36 260.13,23.36 260.64,22.85 260.64,21.32 275.37,6.59 279.44,10.66 319.57,10.66 320.08,11.16 331.25,11.16 332.78,12.69 338.87,12.69 365.8,39.61 367.83,39.61 369.35,41.14 D02.M1
  Route15 0.254: v229.65,272.78 228.64,271.77 223.56,271.77 v223.05,271.26 | v211.87,269.74 v208.82,266.69
  Bottom 0.254: v373.92,76.19 374.94,75.17 374.94,48.76 374.43,48.25 374.43,41.64 370.37,41.64 D02.M1 | v356.14,77.2 356.65,77.71 356.65,89.4 354.62,91.43 354.62,91.94 352.59,93.97 352.59,96.51 353.1,97.02 354.11,97.02 354.11,101.08 C03.R1 | v367.32,244.84 365.29,246.88 365.29,252.46 364.78,252.97 364.78,266.18 362.24,268.72 v362.24,289.04 | v319.57,288.02 316.52,284.98 316.52,283.96 v315.5,282.94 | v208.82,266.69 209.33,266.18 209.33,236.72 v208.32,235.7 | v133.13,236.21 133.13,220.97 131.61,219.44 129.58,219.44 129.58,211.82 124.5,206.74 124.5,204.2 123.99,203.7 123.99,202.17 124.5,201.66 124.5,198.11 123.99,197.6 123.99,185.92 123.48,185.41 123.48,164.58 125,163.06 v125,160.52 | v122.97,158.48 123.48,157.98 123.48,141.72 v122.97,141.21 | v128.05,141.21 129.58,139.69 129.58,137.66 130.08,137.15 130.08,13.7 v129.58,13.2
I/O_BAC_07  (via drill 0.61)
  Top 0.254: v369.86,86.35 356.65,86.35 354.62,88.38 C03.V1
  Bottom 0.254: D02.P1 369.86,35.55 368.34,37.07 368.34,73.65 369.86,75.17 v369.86,86.35 369.86,88.89 368.34,90.41 368.34,206.74 369.86,208.27 369.86,223 368.34,224.52 368.34,232.14 369.86,233.67 369.86,237.73 A02.P1
I/O_BAC_08  (via drill 0.61)
  Top 0.254: v352.59,30.47 353.1,29.96 361.73,29.96 365.29,33.52 v368.34,33.52 | v358.68,246.37 358.68,248.91 352.59,248.91 350.05,246.37 349.03,246.37 348.52,245.86 346.49,245.86 345.98,246.37 336.33,246.37 335.82,245.86 331.76,245.86 330.24,247.38 v329.73,247.38 | v327.19,253.48 327.19,255.51 320.58,255.51 320.08,256.02 316.52,256.02 316.01,255.51 282.99,255.51 v280.96,257.54 | v279.94,283.45 278.93,284.47 258.61,284.47 v258.1,283.96 | v255.05,282.94 253.53,281.42 239.81,281.42 v239.3,281.93 | v209.33,293.1 196.63,293.1 195.62,292.09 164.63,292.09 163.61,293.1 162.6,293.1 162.09,293.61 147.36,293.61 146.85,294.12 139.74,294.12 137.2,291.58 117.38,291.58 116.88,292.09 111.8,292.09 109.26,289.55 99.1,289.55 98.59,289.04 66.58,289.04 66.08,289.55 61,289.55 59.98,290.56 55.41,290.56 54.39,291.58 v45.76,291.58 | v32.55,128.51 21.88,128.51 1.56,108.19 1.56,29.96 42.2,29.96 55.92,16.24 92.49,16.24 93,15.74 94.02,15.74 94.52,15.23 115.86,15.23 116.37,14.72 130.59,14.72 131.61,13.7 133.64,13.7 134.66,12.69 186.98,12.69 188,13.7 201.71,13.7 v202.22,14.21 | v205.78,11.67 206.28,11.16 222.03,11.16 223.05,12.18 v230.16,12.18 | v239.3,10.66 239.81,10.15 243.88,10.15 244.38,9.64 253.02,9.64 253.53,10.15 274.36,10.15 275.37,11.16 329.22,11.16 330.74,9.64 v342.94,9.64
  Route2 0.254: v358.68,246.37 369.86,235.19 369.86,232.14 A02.S1
  Bottom 0.254: v352.59,30.47 352.59,64 353.1,64.5 353.1,68.06 352.59,68.57 352.59,79.24 350.05,81.78 350.05,88.38 352.08,90.41 352.08,124.96 351.57,125.46 351.57,129.02 351.06,129.53 C03.E2 | D02.S1 369.35,28.94 369.35,32.5 v368.34,33.52 368.34,17.77 358.68,17.77 356.65,15.74 356.65,9.64 v342.94,9.64 | v329.73,247.38 327.19,249.92 v327.19,253.48 | v280.96,257.54 278.93,259.58 278.93,273.29 279.94,274.31 v279.94,283.45 | v258.1,283.96 257.59,284.47 257.59,284.98 257.08,285.48 255.05,285.48 v255.05,282.94 | v239.3,281.93 239.3,286.5 233.72,292.09 209.33,292.09 v209.33,293.1 | v45.76,291.58 31.53,291.58 31.53,243.83 32.04,243.32 32.04,129.02 v32.55,128.51 | v202.22,14.21 205.78,14.21 v205.78,11.67 | v230.16,12.18 230.67,11.67 230.67,10.15 237.78,3.04 238.8,3.04 239.3,3.54 v239.3,10.66
I/O_BAC_09  (via drill 0.61)
  Top 0.254: v364.27,100.06 390.69,100.06 390.69,96.51 390.18,96 390.18,76.19 387.64,73.65 386.12,73.65 386.12,70.09 386.62,69.58 390.69,69.58 390.69,68.06 390.18,67.55 389.16,67.55 388.66,68.06 373.92,68.06 370.88,65.01 369.35,65.01 368.84,65.52 365.29,65.52 364.78,65.01 361.73,65.01 360.72,64 D02.D2 | v364.27,121.91 363.76,122.42 352.59,122.42 351.57,123.43 C03.H2 | v360.72,284.47 371.38,284.47 372.4,283.45 379.51,283.45 381.54,285.48 381.54,291.07 365.29,291.07 361.73,294.63 334.81,294.63 333.79,293.61 317.03,293.61 v316.52,294.12 | v302.8,265.67 301.79,264.66 301.79,262.12 303.31,262.12 303.82,261.61 303.82,259.07 v292.64,259.07 | v292.14,243.32 291.63,242.81 v284.01,242.81 | v291.63,209.79 292.14,209.28 309.41,209.28 v309.92,209.79
  Route2 0.254: v304.84,271.77 306.36,270.24 303.82,267.7 303.31,267.7 302.8,267.2 v302.8,265.67 | v309.92,209.79 316.01,203.7 v312.46,200.14 | v357.16,133.59 351.06,127.5 v350.56,127.5
  Route15 0.254: v312.46,200.14 312.46,199.12 313.98,197.6 313.98,193.03 315,192.01 315,191 326.68,179.31 v326.68,172.2 | v325.16,162.55 325.16,161.02 328.2,157.98 332.27,157.98 337.35,152.9 338.36,152.9 357.16,134.1 v357.16,133.59
  Bottom 0.254: v364.27,100.06 364.78,100.57 364.78,121.4 v364.27,121.91 | v360.72,284.47 359.19,282.94 359.19,268.21 360.21,267.2 A02.D2 | v316.52,294.12 315,295.64 306.36,295.64 306.36,275.32 304.84,273.8 v304.84,271.77 | v292.64,259.07 292.64,255 292.14,254.5 292.14,252.46 292.64,251.96 292.64,248.91 292.14,248.4 v292.14,243.32 | v284.01,242.81 286.04,240.78 286.04,226.05 291.63,220.46 291.63,217.41 292.14,216.9 292.14,210.3 v291.63,209.79 | v326.68,172.2 326.68,163.56 325.66,162.55 v325.16,162.55 | v350.56,127.5 350.56,124.45 C03.H2
I/O_BAC_10  (via drill 0.61)
  Top 0.254: v391.7,58.92 369.35,58.92 368.84,59.42 364.78,59.42 364.27,59.93 D02.E2 | v391.7,125.46 391.2,125.97 380.53,125.97 380.02,125.46 365.29,125.46 v364.78,125.97 | v363.26,266.18 361.22,268.21 357.67,268.21 354.62,265.16 348.52,265.16 v348.02,264.66 | v309.92,221.98 311.95,219.95 v314.49,219.95 | v331.76,165.6 329.22,163.06 328.2,163.06 326.68,161.53 326.68,159.5 328.2,157.98 333.28,157.98 333.79,157.47 339.89,157.47 340.4,156.96 343.44,156.96 v343.95,157.47
  Route2 0.254: v364.78,125.97 363.26,127.5 355.13,119.37 353.1,119.37 351.57,117.84 C03.K2 | v330.74,243.83 329.22,242.3 329.22,241.29 319.57,231.64 319.57,231.13 311.95,223.51 311.44,223.51 v309.92,221.98
  Route15 0.254: v331.76,248.4 v348.02,264.66 | v312.96,205.22 317.54,200.65 317.54,200.14 320.58,197.09 320.58,186.42 327.19,179.82 327.19,173.22 327.7,172.71 327.7,171.18 330.24,168.64 330.24,167.12 v331.76,165.6 | v343.95,157.47 341.92,155.44 362.24,135.12 364.78,135.12 365.29,134.61 365.29,131.56 v365.8,131.05
  Bottom 0.254: v391.7,58.92 391.2,59.42 391.2,69.58 390.69,70.09 390.69,75.68 390.18,76.19 390.18,94.98 392.21,97.02 392.21,124.96 v391.7,125.46 | v363.26,266.18 363.26,264.15 A02.E2 | v331.76,248.4 331.76,244.84 v330.74,243.83 | v314.49,219.95 313.98,219.44 313.98,216.4 312.96,215.38 v312.96,205.22 | v365.8,131.05 365.29,130.54 365.29,126.48 v364.78,125.97
I/O_BAC_11  (via drill 0.61)
  Top 0.254: v363.76,55.87 363.76,54.34 D02.H2 | v387.13,77.71 388.15,78.73 388.15,94.98 382.56,94.98 381.54,93.97 v381.54,93.46 | v367.32,104.13 367.32,104.64 367.83,105.14 367.83,106.67 364.27,106.67 362.75,108.19 | 362.75,108.19 361.73,109.21 351.57,109.21 v351.06,108.7 | v362.24,247.89 362.24,242.81 368.84,242.81 371.89,239.76 376.97,239.76 377.48,239.26 377.48,236.72 375.45,236.72 375.45,237.22 373.42,237.22 v372.91,237.73 | v372.4,218.94 371.38,217.92 v367.83,217.92 | v367.83,215.89 369.35,214.36 369.35,211.32 355.13,211.32 v354.11,210.3 | v369.86,148.32 369.35,148.83 361.22,148.83 v360.72,148.32 | v363.76,109.21 362.75,108.19
  Route2 0.254: v363.76,55.87 363.76,57.9 373.42,67.55 374.94,67.55 382.05,74.66 384.08,74.66 v387.13,77.71 | v354.11,210.3 354.11,207.76 352.59,206.24 352.59,205.73 350.56,203.7 350.05,203.7 349.54,203.19 349.54,199.12 353.6,195.06 353.6,194.55 354.62,193.54 355.13,193.54 363.26,185.41 362.24,184.39 362.24,179.82 362.75,179.31 v363.26,179.31 | v372.91,124.45 372.91,122.92 371.89,121.91 371.89,117.34 v363.76,109.21
  Route15 0.254: v381.54,93.46 381.54,95.49 370.88,106.16 369.35,106.16 v367.32,104.13 | v372.91,237.73 370.37,235.19 371.89,233.67 372.91,233.67 v373.92,232.65 | v363.26,179.31 363.26,177.28 371.38,169.15 371.38,167.12 v370.88,166.61 | v360.72,148.32 361.22,148.32 363.76,145.78 364.78,145.78 366.3,144.26 366.3,142.74 374.43,134.61 374.43,130.54 v373.92,130.04
  Bottom 0.254: v351.06,108.7 351.06,110.73 C03.M2 | v362.24,247.89 362.24,251.96 363.76,253.48 363.76,256.53 A02.H2 | v373.92,232.65 374.43,232.14 374.43,226.05 371.89,223.51 371.89,219.44 v372.4,218.94 | v367.83,215.89 v367.83,217.92 | v370.88,166.61 371.38,166.1 371.38,149.85 v369.86,148.32 | v373.92,130.04 374.43,129.53 374.43,125.97 v372.91,124.45
I/O_BMB_00  (via drill 0.61)
  Top 0.254: v363.76,69.08 363.26,68.57 355.64,68.57 354.62,69.58 D03.B1 | v373.92,65.01 381.54,65.01 382.56,64 v389.16,64 | v383.07,115.81 381.54,115.81 v379,118.35 | v382.56,134.1 384.08,135.62 384.08,138.16 378.5,138.16 376.46,140.2 v375.96,140.2 | v373.42,143.75 372.91,143.24 370.37,143.24 C02.A1 | v355.13,268.21 336.84,268.21 336.33,268.72 333.28,268.72 v332.78,268.21 | v332.27,256.53 332.78,256.02 336.84,256.02 337.35,255.51 343.44,255.51 347,251.96 v348.52,251.96
  Route2 0.254: v379,118.35 377.48,119.88 377.48,121.91 377.99,122.42 377.99,123.43 381.04,126.48 381.04,131.05 381.54,131.56 381.54,133.08 v382.56,134.1 | v375.96,140.2 372.91,143.24 v373.42,143.75 | v349.54,247.38 349.54,246.88 345.48,242.81 345.48,241.29 342.94,238.75 342.94,224.02 345.48,221.48 345.48,215.89 351.06,210.3 351.06,208.78 349.54,207.25 349.54,204.2 349.03,203.7 349.03,192.01 353.6,187.44 356.14,189.98 357.16,189.98 360.21,186.93 359.19,185.92 359.19,168.64 v360.72,167.12
  Route15 0.254: v363.76,69.08 365.29,67.55 365.29,62.98 369.35,58.92 370.88,58.92 v372.91,60.95 | v388.66,73.14 388.66,86.86 389.67,87.87 389.67,94.48 388.15,96 388.15,110.73 v383.07,115.81 | v360.72,167.12 361.73,166.1 361.73,151.88 370.37,143.24 C02.A1
  Bottom 0.254: v372.91,60.95 374.43,62.47 374.43,64.5 v373.92,65.01 | v389.16,64 388.66,64.5 v388.66,73.14 | v355.13,268.21 355.13,271.26 354.11,272.28 A03.B1 | v332.78,268.21 332.27,267.7 v332.27,256.53 | v348.52,251.96 349.54,250.94 v349.54,247.38
I/O_BMB_01  (via drill 0.61)
  Top 0.254: v335.32,3.54 334.81,4.05 309.41,4.05 308.39,5.07 300.26,5.07 299.25,4.05 290.61,4.05 290.1,4.56 288.07,4.56 287.06,3.54 249.46,3.54 247.94,5.07 239.81,5.07 239.3,5.58 237.27,5.58 236.26,4.56 199.17,4.56 198.16,5.58 196.12,5.58 195.11,4.56 120.43,4.56 118.4,6.59 114.34,6.59 110.78,3.04 11.21,3.04 10.2,4.05 9.18,4.05 7.15,6.08 v6.64,6.08 | v6.13,260.08 6.13,285.99 55.41,285.99 55.92,285.48 62.01,285.48 62.52,284.98 63.54,284.98 64.04,284.47 102.14,284.47 103.16,285.48 117.89,285.48 119.42,287.01 139.74,287.01 140.24,286.5 154.98,286.5 155.48,285.99 217.46,285.99 218.48,287.01 218.48,293.1 229.65,293.1 230.16,292.6 238.29,292.6 239.3,291.58 248.96,291.58 249.97,290.56 257.59,290.56 258.61,291.58 262.67,291.58 264.2,290.06 284.01,290.06 285.53,291.58 295.69,291.58 296.2,292.09 299.25,292.09 301.28,290.06 309.92,290.06 310.42,290.56 v352.59,290.56 | v351.57,63.49 D03.D1 | v367.32,129.53 368.34,128.51 370.37,128.51 371.89,130.04 371.89,134.61 v380.53,134.61 | v384.08,164.58 391.7,172.2 v391.7,187.95 | v391.7,199.12 391.7,219.95 392.21,220.46 392.21,222.49 v391.2,222.49
  Bottom 0.254: v351.57,63.49 352.08,62.98 352.08,45.71 349.54,43.17 349.54,17.77 v335.32,3.54 | v6.64,6.08 7.15,6.59 7.15,244.34 3.59,247.89 3.59,257.54 v6.13,260.08 | A03.D1 353.6,267.2 352.59,268.21 v352.59,290.56 352.59,294.12 383.07,294.12 390.69,286.5 390.69,244.84 390.18,244.34 390.18,231.64 390.69,231.13 390.69,223 v391.2,222.49 | v367.32,129.53 367.32,132.07 366.81,132.58 C02.D1 | v380.53,134.61 381.04,135.12 381.04,146.29 383.07,148.32 383.07,150.36 384.59,151.88 384.59,164.07 v384.08,164.58 | v391.7,187.95 390.69,188.96 390.69,198.11 v391.7,199.12
I/O_BMB_02  (via drill 0.61)
  Top 0.254: v369.86,51.3 368.84,51.3 367.83,52.31 362.75,52.31 359.7,55.36 353.1,55.36 352.59,55.87 352.59,58.41 353.1,58.92 355.64,58.92 356.65,59.93 D03.E1 | v382.05,241.8 379.51,239.26 379.51,236.21 381.04,236.21 v382.56,234.68 | v391.7,196.08 391.7,188.96 391.2,188.96 390.69,188.46 390.69,172.2 389.16,172.2 v383.58,166.61 | v372.91,129.02 371.38,127.5 367.32,127.5 C02.F1
  Route2 0.254: v391.7,225.54 390.69,224.52 390.69,223.51 390.18,223 390.18,221.48 389.16,220.46 389.16,198.62 v391.7,196.08 | v383.58,166.61 385.1,165.09 385.1,163.56 384.59,163.06 384.59,151.88 383.07,150.36 383.07,148.32 382.05,147.31 382.05,145.28 379,142.23 379,141.21 377.48,139.69 377.48,139.18 376.97,138.67 375.96,138.67 371.89,134.61 371.89,130.04 v372.91,129.02
  Route15 0.254: v369.86,51.3 384.08,65.52 384.08,69.58 381.04,72.63 381.04,74.66 384.08,77.71 384.08,80.76 374.43,90.41 374.43,91.43 365.29,100.57 365.29,116.32 369.35,120.38 v367.32,122.42 | v374.43,257.04 374.43,255.51 v381.54,248.4 | v391.7,225.54 v382.56,234.68
  Bottom 0.254: v367.32,122.42 367.32,126.48 C02.F1 | v374.43,257.04 374.43,261.61 371.89,264.15 371.89,271.77 371.38,272.28 371.38,273.8 371.89,274.31 371.89,292.6 361.73,292.6 358.68,289.55 358.68,265.16 357.67,264.15 A03.E1 | v381.54,248.4 382.56,247.38 382.56,246.37 381.04,244.84 381.04,242.81 v382.05,241.8
I/O_BMB_03  (via drill 0.61)
  Top 0.254: 331.25,133.59 334.3,133.59 C04.D2 | 331.25,133.59 327.7,133.59 326.68,134.61 320.58,134.61 319.57,133.59 C05.D2 | v330.74,53.84 332.27,52.31 338.87,52.31 339.38,52.82 342.94,52.82 343.44,52.31 348.52,52.31 349.03,51.8 353.1,51.8 353.6,51.3 D03.J1 | 331.25,133.59 v331.25,133.08 | v385.1,252.46 359.7,252.46 359.19,252.97 355.13,252.97 354.62,253.48 A03.J1 | v385.1,122.42 368.84,122.42 367.32,120.89 C02.J1 366.3,120.38 363.26,120.38 362.24,119.37 v337.86,119.37
  Bottom 0.254: v330.74,53.84 330.24,54.34 330.24,60.44 330.74,60.95 330.74,73.65 331.76,74.66 331.76,132.58 v331.25,133.08 | v385.1,252.46 386.12,251.45 386.12,203.7 385.61,203.19 385.61,148.83 385.1,148.32 v385.1,122.42 | v337.86,119.37 336.84,120.38 336.84,127.5 335.82,128.51 335.82,132.07 335.32,132.58 C04.D2
I/O_BMB_03\  (via drill 0.61)
  Top 0.254: v319.06,91.43 318.04,90.41 315.5,90.41 313.47,92.44 v312.46,92.44 | v352.59,257.04 353.1,256.53 357.16,256.53 A03.H1
  Route2 0.254: v330.74,100.06 327.7,100.06 v319.06,91.43
  Route15 0.254: v358.18,64 357.16,65.01 356.65,65.01 349.54,72.12 349.54,76.7 335.82,90.41 335.82,91.94 333.79,93.97 333.79,97.02 v330.74,100.06 | v310.42,254.5 312.46,256.53 312.96,256.53 v320.58,264.15
  Bottom 0.254: v358.18,64 358.68,63.49 358.68,59.42 358.18,58.92 358.18,54.85 357.67,54.34 D03.H1 | v312.46,92.44 310.93,93.97 310.93,196.08 311.44,196.58 311.44,204.71 310.93,205.22 310.93,253.99 v310.42,254.5 | v320.58,264.15 324.14,267.7 324.14,288.02 333.28,297.17 348.52,297.17 348.52,276.34 350.05,274.82 350.05,271.26 349.54,270.75 349.54,267.2 352.59,264.15 v352.59,257.04
I/O_BMB_04  (via drill 0.61)
  Top 0.254: C04.E2 337.86,130.54 336.84,131.56 323.63,131.56 322.62,130.54 C05.E2 321.6,130.54 320.08,130.54 v319.57,131.05 | v371.89,43.17 363.26,43.17 362.24,42.15 358.18,42.15 357.67,41.64 D03.M1 | v344.46,113.78 341.92,116.32 v339.89,116.32 | v354.11,257.54 353.6,258.05 352.08,258.05 351.57,258.56 v327.19,258.56 | v309.92,241.8 301.79,233.67 298.74,233.67 298.74,235.19 v297.72,235.19 | v307.88,147.31 309.92,145.28 v309.92,144.77 | v373.42,111.24 374.43,111.24 374.43,115.3 373.92,115.81 372.4,115.81 371.89,115.3 367.83,115.3 367.32,114.8 C02.L1 | v381.04,88.38 381.04,85.84 v381.54,85.33
  Route2 0.254: v295.18,211.82 295.18,207.76 293.15,205.73 293.15,204.71 289.09,200.65 v289.09,198.62 | v291.63,192.01 291.63,191.5 v287.06,186.93 | v309.92,144.77 312.96,144.77 314.49,143.24 312.46,141.21 311.95,141.21 307.88,137.15 307.88,135.12 309.92,133.08 311.44,134.61 v315.5,134.61 | v381.54,85.33 381.54,79.24 379.51,77.2 377.48,77.2 v373.92,73.65
  Route15 0.254: v371.38,61.46 371.38,69.08 369.86,70.6 | 369.86,70.6 368.34,72.12 368.34,73.65 363.76,78.22 363.76,79.74 360.21,83.3 360.21,85.84 357.16,88.89 357.16,89.9 355.64,91.43 355.64,98.03 350.56,103.11 350.05,103.11 346.49,106.67 346.49,111.75 v344.46,113.78 | v356.65,247.89 356.65,248.4 v354.62,250.43 | v327.19,258.56 313.47,244.84 312.96,244.84 v309.92,241.8 | v297.72,235.19 295.18,232.65 295.69,232.14 295.69,231.13 v294.68,230.11 | v287.06,186.93 307.88,166.1 v307.88,147.31 | v315.5,134.61 319.06,131.05 v319.57,131.05 | v373.42,111.24 376.46,108.19 376.46,106.67 384.08,99.05 384.08,91.43 v381.04,88.38 | v373.92,73.65 372.4,73.65 371.38,72.63 371.38,72.12 369.86,70.6
  Bottom 0.254: v371.89,43.17 371.89,60.95 v371.38,61.46 | v339.89,116.32 339.38,116.83 339.38,128.51 338.36,129.53 C04.E2 | v356.65,247.89 356.65,244.84 A03.M1 | v354.62,250.43 355.13,250.94 355.13,252.97 355.64,253.48 355.64,255.51 354.11,257.04 v354.11,257.54 | v294.68,230.11 295.18,229.6 295.18,216.4 295.69,215.89 295.69,212.33 v295.18,211.82 | v289.09,198.62 292.14,195.57 292.14,192.52 v291.63,192.01
I/O_BMB_04\  (via drill 0.61)
  Top 0.254: v346.49,17.77 345.98,17.26 317.03,17.26 v316.52,17.77 | v312.46,20.82 311.95,20.31 305.34,20.31 v303.82,18.78 | v103.16,11.67 v113.83,11.67 | v46.77,140.2 48.8,138.16 57.44,138.16 v59.47,140.2 | v56.93,161.53 38.14,180.33 38.14,195.06 v38.64,195.06 | v40.17,197.09 51.85,185.41 72.17,185.41 v74.2,183.38 | v75.22,185.41 78.78,188.96 110.78,188.96 v111.29,189.47
  Route2 0.254: v316.52,17.77 312.96,21.32 v312.46,20.82 | v295.69,2.02 292.64,5.07 189.52,5.07 v172.76,21.83 | v125.51,13.2 115.35,13.2 v113.83,11.67 | v110.27,193.03 117.89,200.65 118.91,200.65 128.56,210.3 128.56,210.81 129.07,211.32 130.59,211.32 148.37,229.1 148.88,229.1 165.64,245.86 166.66,245.86 171.23,250.43 172.25,250.43 173.26,251.45 174.28,251.45 180.38,257.54 180.38,259.07 187.49,266.18 189.52,266.18 191.55,268.21 197.65,268.21 203.74,274.31 208.82,274.31 212.89,278.37 223.05,278.37 231.18,286.5 235.24,286.5 236.26,287.52 290.1,287.52 291.63,289.04 304.84,289.04 316.01,277.86 324.65,277.86 330.24,272.28 331.76,272.28 336.84,267.2 336.84,266.69 338.36,265.16 338.87,265.16 353.6,250.43 353.6,248.91 354.11,248.4 A03.L1
  Route15 0.254: v348.02,35.04 v353.6,40.63
  Bottom 0.254: v353.6,40.63 353.6,43.17 354.11,43.68 D03.L1 | v348.02,35.04 345.98,33.01 345.98,30.47 346.49,29.96 v346.49,17.77 | v303.82,18.78 301.28,16.24 301.28,7.61 v295.69,2.02 | v172.76,21.83 159.04,8.12 125.51,8.12 v125.51,13.2 | v103.16,11.67 47.28,11.67 47.28,139.69 v46.77,140.2 | v59.47,140.2 58.46,141.21 57.95,141.21 56.93,142.23 v56.93,161.53 | v38.64,195.06 40.17,196.58 v40.17,197.09 | v74.2,183.38 75.22,184.39 v75.22,185.41 | v111.29,189.47 110.78,189.47 110.78,192.52 v110.27,193.03
I/O_BMB_05  (via drill 0.61)
  Top 0.254: C05.F2 319.57,126.48 323.63,126.48 324.65,125.46 327.19,125.46 328.71,126.99 C04.F2 | v383.58,33.52 371.89,33.52 368.34,29.96 362.75,29.96 362.24,29.45 358.18,29.45 357.67,28.94 D03.S1 | v384.59,106.67 368.84,106.67 367.83,107.68 367.32,107.68 C02.N1 366.81,108.7 366.81,110.22 364.27,112.76 357.16,112.76 356.65,112.26 352.08,112.26 351.57,112.76 350.05,112.76 349.54,112.26 348.02,112.26 v347.51,111.75 | v387.64,233.67 368.84,233.67 368.34,233.16 358.68,233.16 357.67,232.14 A03.S1 | v336.84,108.7 337.35,109.21 343.95,109.21 v344.46,108.7
  Route2 0.254: v347.51,111.75 v344.46,108.7
  Bottom 0.254: v383.58,33.52 384.59,34.53 384.59,103.11 | 384.59,103.11 v384.59,106.67 | v387.64,233.67 387.13,233.16 387.13,202.68 386.62,202.17 386.62,147.82 386.12,147.31 386.12,123.94 386.62,123.43 386.62,105.14 384.59,103.11 | v336.84,108.7 336.84,113.27 336.33,113.78 336.33,125.46 335.32,126.48 C04.F2
I/O_BMB_05\
  Bottom 0.254: D03.P1 357.16,35.55 355.64,37.07 355.64,75.17 357.16,76.7 357.16,89.9 355.64,91.43 355.64,206.74 357.16,208.27 357.16,223.51 355.64,225.03 355.64,236.72 356.65,237.73 A03.P1
I/O_BMB_06  (via drill 0.61)
  Top 0.254: C05.H2 322.62,124.45 327.19,124.45 328.2,125.46 336.84,125.46 337.86,124.45 C04.H2 | v362.75,61.96 357.16,61.96 356.65,61.46 352.59,61.46 351.57,60.44 D03.E2 | v365.29,87.87 v362.75,87.87 | v387.13,265.16 357.16,265.16 356.65,264.66 352.59,264.66 351.57,263.64 A03.E2 | v385.61,105.65 383.07,103.11 371.38,103.11 369.86,101.59 C02.R1 366.3,102.1 362.24,102.1 358.18,106.16 331.25,106.16 330.74,106.67 323.12,106.67 v322.62,107.18
  Bottom 0.254: v362.75,61.96 362.24,62.47 362.24,87.36 v362.75,87.87 | v365.29,87.87 365.29,98.54 366.3,99.56 366.3,101.08 C02.R1 | v387.13,265.16 387.13,246.37 386.62,245.86 386.62,203.19 386.12,202.68 386.12,148.32 385.61,147.82 385.61,123.43 386.12,122.92 386.12,106.16 v385.61,105.65 | v322.62,107.18 321.09,108.7 321.09,122.92 321.6,123.43 C05.H2
I/O_BMB_06\  (via drill 0.61)
  Top 0.254: v344.97,266.18 345.48,266.69 A03.D2
  Route2 0.254: v347,218.43 347,220.46 345.98,221.48 345.98,242.3 350.56,246.88 350.56,248.4 v341.92,257.04
  Bottom 0.254: v347,218.43 346.49,217.92 346.49,65.01 347.51,64 D03.D2 | v341.92,257.04 342.43,257.54 342.43,259.07 342.94,259.58 342.94,264.15 v344.97,266.18
I/O_BMB_07  (via drill 0.61)
  Top 0.254: v350.56,90.41 365.29,90.41 366.3,89.4 C02.V1 | C05.J2 319.57,120.89 320.58,121.91 333.28,121.91 334.3,120.89 C04.J2 335.32,121.4 339.89,121.4 v347.51,129.02 | v351.06,69.08 350.56,68.57 339.38,68.57 v337.86,70.09
  Route2 0.254: v328.2,108.19 328.2,108.7 330.24,110.73 330.24,111.75 v334.81,116.32
  Route15 0.254: v337.86,70.09 337.86,71.11 336.84,72.12 336.84,77.2 335.32,78.73 335.32,81.78 333.79,83.3 333.79,84.82 327.19,91.43 327.19,107.18 v328.2,108.19
  Bottom 0.254: 349.54,69.08 349.54,89.4 v350.56,90.41 | 349.54,69.08 349.54,49.26 350.56,48.25 D03.K2 | v347.51,129.02 349.54,131.05 349.54,245.35 350.56,246.37 350.56,250.43 A03.K2 | v351.06,69.08 349.54,69.08 | v334.81,116.32 334.81,119.88 C04.J2
I/O_BMB_07\  (via drill 0.61)
  Top 0.254: v351.06,50.79 352.59,49.26 355.64,49.26 356.14,49.77 359.19,49.77 v361.73,47.23 | v366.81,42.15 367.32,42.66 370.88,42.66 371.38,42.15 374.94,42.15 375.96,43.17 v376.46,43.17 | v381.04,76.19 381.54,76.7 383.07,76.7 387.13,80.76 387.13,93.97 v383.07,93.97 | v384.59,200.65 384.59,203.7 383.07,203.7 378.5,208.27 363.26,208.27 v362.24,209.28 | v364.27,247.38 364.27,249.42 362.24,249.42 359.7,251.96 358.18,251.96 357.67,252.46 354.62,252.46 v354.11,251.96
  Route2 0.254: v366.81,42.15 v361.73,47.23
  Bottom 0.254: v351.06,50.79 351.06,53.33 D03.H2 | v376.46,43.17 377.48,44.18 377.48,72.63 v381.04,76.19 | v383.07,93.97 381.04,96 381.04,106.16 381.54,106.67 381.54,110.22 381.04,110.73 381.04,112.76 381.54,113.27 381.54,116.32 381.04,116.83 381.04,118.86 381.54,119.37 381.54,122.92 381.04,123.43 381.04,131.05 384.08,134.1 384.08,148.32 383.58,148.83 383.58,149.85 385.1,151.37 385.1,200.14 v384.59,200.65 | v362.24,209.28 362.24,240.78 364.78,243.32 364.78,246.88 v364.27,247.38 | v354.11,251.96 352.59,253.48 352.59,255 351.06,256.53 A03.H2
I/O_BMB_08  (via drill 0.61)
  Top 0.254: v323.63,103.62 327.7,103.62 328.2,103.11 338.87,103.11 | v339.89,104.13 338.87,103.11 | v354.11,129.02 354.62,128.51 358.68,128.51 360.21,130.04 363.26,130.04 C02.E2 | v351.57,43.68 351.06,43.17 349.03,43.17 348.52,42.66 v343.44,42.66 | v347.51,104.13 347,103.62 345.48,103.62 344.97,103.11 338.87,103.11
  Route2 0.254: v340.4,125.46 347,125.46 348.52,123.94 353.6,129.02 v354.11,129.02
  Route15 0.254: v342.43,65.01 342.43,67.04 v348.52,73.14 | v348.52,84.82 348.52,87.36 349.54,88.38 349.03,88.89 349.03,89.9 v348.02,90.92
  Bottom 0.254: v323.63,103.62 323.63,112.26 323.12,112.76 323.12,116.32 322.62,116.83 C05.K2 | v339.89,104.13 339.89,114.8 341.41,116.32 341.41,118.35 339.89,119.88 339.89,124.96 v340.4,125.46 | v351.57,43.68 352.08,43.17 352.08,36.56 351.06,35.55 D03.P2 | v343.44,42.66 342.94,43.17 342.94,49.26 343.44,49.77 343.44,52.82 342.94,53.33 342.94,64.5 v342.43,65.01 | v348.52,84.82 v348.52,73.14 | v348.02,90.92 348.52,91.43 348.52,93.46 349.03,93.97 349.03,102.6 v347.51,104.13 | v354.11,129.02 352.59,130.54 352.59,207.25 351.06,208.78 351.06,222.49 352.59,224.02 352.59,232.14 351.57,233.16 351.57,237.73 A03.P2
I/O_BMB_08\  (via drill 0.61)
  Top 0.254: v343.95,77.2 349.03,82.28 v351.06,82.28 | v355.64,292.6 354.11,294.12 335.32,294.12 334.3,293.1 314.49,293.1 313.47,294.12 312.46,294.12 v311.44,293.1 | v308.39,274.82 307.88,274.31 298.23,274.31 297.72,274.82 288.07,274.82 v287.56,275.32 | v287.06,284.47 286.55,284.98 257.08,284.98 v256.58,284.47 | v256.07,281.93 255.05,280.91 237.27,280.91 v235.75,282.44 | v207.81,291.58 206.79,290.56 163.1,290.56 162.09,291.58 161.07,291.58 160.56,292.09 140.75,292.09 138.72,290.06 115.86,290.06 115.35,290.56 113.32,290.56 110.78,288.02 100.62,288.02 99.6,287.01 66.58,287.01 66.08,287.52 65.06,287.52 64.55,288.02 59.47,288.02 58.46,289.04 45.76,289.04 v45.25,289.55 | v34.07,147.82 34.58,147.31 v46.77,147.31 | v63.54,15.23 64.04,15.74 91.98,15.74 92.49,15.23 93.51,15.23 94.52,14.21 130.08,14.21 131.1,13.2 133.13,13.2 134.15,12.18 187.49,12.18 188.5,13.2 203.74,13.2 209.84,19.29 209.84,20.82 220,20.82 v220.51,20.31 | v222.54,18.28 223.05,17.77 236.26,17.77 238.8,20.31 242.86,20.31 v243.37,19.8 | v296.71,43.68 298.74,45.71 v303.82,45.71
  Route2 0.254: v243.37,31.99 243.88,31.99 244.89,33.01 249.97,33.01 256.58,39.61 258.1,39.61 261.15,42.66 275.37,42.66 279.44,38.6 280.45,39.61 286.55,39.61 289.6,42.66 295.69,42.66 v296.71,43.68
  Route15 0.254: 339.89,57.9 339.89,60.95 339.38,61.46 339.38,63.49 341.92,66.03 341.92,68.06 347.51,73.65 v343.95,77.2 | 339.89,57.9 339.89,55.87 343.44,52.31 343.44,50.79 343.95,50.28 344.46,50.28 350.56,44.18 350.56,41.64 D03.M2 | v351.06,82.28 350.05,83.3 350.05,89.4 349.54,89.9 349.54,90.92 333.79,106.67 333.79,110.22 335.32,111.75 336.33,111.75 v338.36,113.78 | v353.6,245.86 353.1,246.37 351.57,244.84 A03.M2 | v303.82,45.71 308.9,50.79 311.44,48.25 313.98,48.25 319.57,53.84 327.19,46.22 329.22,46.22 333.28,50.28 333.28,51.3 339.89,57.9
  Bottom 0.254: v338.36,113.78 337.86,114.29 337.86,116.83 C04.K2 | v353.6,245.86 355.64,245.86 355.64,252.46 356.14,252.97 356.14,256.02 355.64,256.53 355.64,267.2 356.14,267.7 356.14,268.72 355.64,269.23 v355.64,292.6 | v311.44,293.1 307.88,289.55 307.88,275.32 v308.39,274.82 | v287.56,275.32 287.06,275.83 v287.06,284.47 | v256.58,284.47 256.07,283.96 v256.07,281.93 | v235.75,282.44 235.75,289.04 233.21,291.58 v207.81,291.58 | v45.25,289.55 36.61,289.55 36.61,276.34 34.58,274.31 34.58,148.32 v34.07,147.82 | v46.77,147.31 47.79,146.29 47.79,30.98 v63.54,15.23 | v222.54,18.28 v220.51,20.31 | v243.37,19.8 241.34,21.83 241.34,29.96 v243.37,31.99
I/O_BMB_09  (via drill 0.61)
  Top 0.254: v339.89,29.96 349.54,29.96 350.56,28.94 D03.S2 | v339.89,45.71 339.38,46.22 v323.63,46.22 | v366.3,124.45 365.8,123.94 364.27,123.94 C02.H2
  Route2 0.254: v323.63,59.93 324.14,59.93 329.73,65.52 329.73,67.04 337.35,74.66 338.87,74.66 343.44,79.24 343.44,81.78 352.08,90.41 352.08,91.43 354.11,93.46 354.62,93.46 358.68,97.52 358.68,102.6 361.22,105.14 361.22,106.16 361.73,106.67 361.73,121.91 363.26,123.43 C02.H2 | v383.07,197.6 384.08,197.6 391.7,189.98 390.69,188.96 390.69,164.58 390.18,164.07 390.18,153.4 389.67,152.9 389.67,148.83 387.13,146.29 387.13,125.97 383.58,122.42 382.05,122.42 380.02,124.45 383.07,127.5 383.07,128.51 384.08,129.53 384.08,134.1 383.07,135.12 382.05,135.12 381.54,134.61 381.54,134.1 381.04,133.59 381.04,132.58 v380.53,132.07
  Route15 0.254: v383.07,197.6 385.61,200.14 385.61,201.16 371.38,215.38 371.38,232.65 369.86,234.18 369.86,235.19 365.29,239.76 353.6,239.76 353.1,240.27 351.06,240.27 350.05,241.29 345.98,237.22 345.98,234.18 347,233.16 348.02,233.16 349.03,232.14 350.56,232.14 A03.S2 | v380.53,132.07 380.53,128 381.04,127.5 381.04,124.45 377.48,120.89 377.48,119.88 376.46,118.86 375.45,119.88 375.45,120.89 374.43,121.91 369.35,121.91 366.81,124.45 v366.3,124.45
  Bottom 0.254: v339.89,45.71 v339.89,29.96 | v323.63,59.93 v323.63,46.22
I/O_BMB_10  (via drill 0.61)
  Top 0.254: v339.89,23.86 345.48,23.86 347,25.39 D03.T2 | v339.38,51.3 340.4,52.31 342.43,52.31 343.44,51.3 v344.46,51.3 | v351.06,57.9 349.54,59.42 349.54,61.96 354.62,61.96 v356.65,64 | v372.91,118.86 365.29,118.86 364.27,117.84 C02.K2 | v351.57,229.1 348.02,229.1 A03.T2 | v391.7,164.58 v391.7,169.15 | v383.07,114.29 382.05,115.3 380.53,115.3 380.02,115.81 376.97,115.81 v375.45,114.29
  Route2 0.254: v351.06,57.9 v344.46,51.3 | v359.19,81.78 359.19,83.3 362.75,86.86 363.26,86.86 363.76,87.36 363.76,89.9 377.48,103.62 377.48,112.26 v375.45,114.29 | v391.7,164.58 390.69,163.56 390.69,162.55 392.21,161.02 392.21,153.4 390.69,151.88 390.69,147.82 389.67,146.8 389.67,143.75 388.66,142.74 388.66,119.88 v383.07,114.29
  Route15 0.254: v375.45,114.29 373.92,115.81 373.92,117.84 v372.91,118.86 | v351.57,229.1 353.6,231.13 355.64,229.1 355.64,228.59 356.14,228.08 358.68,228.08 359.19,227.57 359.19,226.05 363.76,221.48 363.76,220.97 364.27,220.46 365.29,220.46 v366.81,218.94 | v367.32,206.24 367.32,205.73 368.84,204.2 368.84,203.19 372.4,199.63 372.91,199.63 380.53,192.01 380.53,191.5 384.08,187.95 384.08,184.39 380.53,180.84 382.05,179.31 382.05,178.8 v391.7,169.15
  Bottom 0.254: v339.89,23.86 336.84,26.91 336.84,48.76 v339.38,51.3 | v356.65,64 358.68,66.03 358.68,76.7 359.7,77.71 359.7,81.27 v359.19,81.78 | v366.81,218.94 366.81,206.74 v367.32,206.24
I/O_BMB_11  (via drill 0.61)
  Top 0.254: v347.51,109.72 362.24,109.72 363.26,110.73 C02.M2 | v348.02,210.81 349.54,209.28 357.16,209.28 358.18,210.3 366.81,210.3 v367.83,209.28 | v367.32,194.04 v363.26,198.11 | v376.46,164.58 373.42,161.53 v372.91,161.53
  Route2 0.254: v367.83,209.28 367.83,208.27 366.3,206.74 366.3,205.22 362.24,201.16 362.24,199.12 v363.26,198.11 | v372.91,161.53 360.72,149.34 360.21,149.34 359.7,148.83 359.7,146.8 358.68,145.78 357.67,145.78 349.54,137.66 v349.54,129.02
  Route15 0.254: v367.32,194.04 367.32,193.54 v372.91,187.95 | v377.48,176.77 v373.92,180.33
  Bottom 0.254: 349.54,108.7 349.54,93.46 349.03,92.95 349.03,87.87 347.51,86.35 347.51,72.63 349.03,71.11 349.03,20.82 348.02,19.8 D03.V2 | 349.54,108.7 348.52,109.72 v347.51,109.72 | v348.02,210.81 348.52,211.32 348.52,220.97 348.02,221.48 A03.V2 | v372.91,187.95 374.43,186.42 374.43,180.84 v373.92,180.33 | v377.48,176.77 377.48,165.6 v376.46,164.58 | v349.54,129.02 349.54,108.7
I/O_BRK_RQ\  (via drill 0.61)
  Top 0.254: v386.12,46.22 361.22,46.22 358.18,49.26 356.65,49.26 356.14,48.76 352.08,48.76 351.57,49.26 337.35,49.26 336.84,48.76 333.79,48.76 332.78,49.77 328.2,49.77 327.19,48.76 323.63,48.76 322.62,47.74 D05.K2 | v389.16,245.86 364.27,245.86 363.26,246.88 363.26,248.91 361.73,248.91 361.22,249.42 323.63,249.42 322.62,250.43 A05.K2 | v318.04,195.06 324.14,195.06 325.16,196.08 B05.D1 | v317.54,219.95 v321.6,219.95
  Bottom 0.254: v386.12,46.22 385.61,46.72 385.61,88.38 387.13,89.9 387.13,99.56 388.66,101.08 388.66,106.16 388.15,106.67 388.15,140.2 387.64,140.7 387.64,145.78 389.16,147.31 389.16,150.86 388.15,151.88 388.15,180.84 389.16,181.85 389.16,183.88 387.64,185.41 387.64,201.16 388.15,201.66 388.15,231.64 389.16,232.65 v389.16,245.86 | v318.04,195.06 317.54,195.57 v317.54,219.95 | v321.6,219.95 324.14,219.95 324.14,245.35 322.62,246.88 322.62,250.43 A05.K2
I/O_BWC0\  (via drill 0.61)
  Top 0.254: v329.73,33.52 321.09,33.52 320.08,34.53 317.54,34.53 316.52,33.52 310.93,33.52 309.92,34.53 D06.P2 | v329.73,19.29 331.25,17.77 336.84,17.77 v337.35,18.28 | v344.97,11.67 v340.4,11.67 | v355.64,34.53 355.64,36.06 356.65,36.06 357.16,36.56 358.68,36.56 v359.7,35.55 | v364.27,63.49 365.8,65.01 368.34,65.01 368.84,64.5 371.89,64.5 v373.92,66.54 | v372.4,86.35 372.4,87.87 371.89,87.87 371.89,90.41 v375.96,90.41 | v369.35,102.6 368.34,103.62 368.34,106.16 378.5,106.16 v380.02,104.64 | v315,236.72 310.93,236.72 309.92,237.73 A06.P2 | v360.72,175.25 360.72,172.71 362.24,172.71 365.8,169.15 365.8,166.1 365.29,166.1 v364.78,165.6
  Route2 0.254: v350.56,202.68 362.24,191 v363.26,192.01 | v363.26,183.88 364.78,182.36 365.8,182.36 366.3,181.85 366.3,180.84 v360.72,175.25
  Route15 0.254: v375.96,90.41 375.45,90.41 374.94,90.92 374.94,97.02 v369.35,102.6 | v315,236.72 319.57,232.14 319.57,230.62 327.19,223 327.19,221.48 338.36,210.3 339.89,210.3 342.94,207.25 342.94,205.73 343.95,204.71 348.52,204.71 v350.56,202.68 | v364.78,165.6 364.78,163.06 368.34,159.5 368.34,154.93 374.94,148.32 374.94,139.69 376.46,138.16 376.97,138.16 377.99,137.15 377.99,128.51 379,127.5 C01.F1
  Bottom 0.254: v329.73,33.52 330.24,33.01 330.24,19.8 v329.73,19.29 | v337.35,18.28 340.4,15.23 v340.4,11.67 | v344.97,11.67 355.64,11.67 v355.64,34.53 | v359.7,35.55 361.73,35.55 361.73,43.17 364.27,45.71 364.27,46.22 364.78,46.72 364.78,62.98 v364.27,63.49 | v373.92,66.54 371.89,68.57 371.89,85.84 v372.4,86.35 | v380.02,104.64 380.53,105.14 380.53,106.67 381.04,107.18 381.04,108.7 380.02,109.72 379,109.72 379,111.75 381.04,113.78 381.04,115.81 380.53,116.32 380.53,119.37 381.04,119.88 381.04,122.42 380.02,123.43 380.02,126.48 C01.F1 | v363.26,192.01 364.78,190.49 364.78,185.41 v363.26,183.88
I/O_DATA_IN  (via drill 0.61)
  Top 0.254: 318.55,184.39 318.55,188.46 315,188.46 313.98,187.44 311.44,187.44 310.42,188.46 299.25,188.46 v297.22,190.49 | v296.2,197.6 295.69,198.11 v293.15,198.11 | v292.64,219.44 293.15,218.94 301.79,218.94 303.82,220.97 v303.82,223 | v313.47,59.93 311.44,61.96 311.44,63.49 v310.42,63.49 | v309.92,184.39 310.42,184.9 311.44,184.9 311.95,185.41 315,185.41 316.01,184.39 318.55,184.39 | 318.55,184.39 B05.J2
  Route2 0.254: v303.82,223 304.84,223 318.04,236.21 318.04,238.24 320.58,240.78 320.58,242.3 322.11,243.83 A05.M2 | v315.5,51.3 313.98,52.82 314.49,53.33 314.49,58.92 v313.47,59.93 | v310.42,78.73 306.36,82.79 306.36,86.35 303.82,88.89 v305.85,90.92 | v298.74,119.37 298.74,140.7 v304.84,146.8 | v294.17,162.04 294.17,163.06 295.18,164.07 295.18,168.64 306.87,180.33 306.87,181.34 v309.92,184.39
  Route15 0.254: v305.85,90.92 305.85,93.46 304.84,94.48 304.84,113.27 v298.74,119.37 | v304.84,146.8 304.84,150.86 298.74,156.96 298.74,157.47 v294.17,162.04
  Bottom 0.254: v297.22,190.49 295.69,192.01 295.69,197.09 v296.2,197.6 | v293.15,198.11 292.14,199.12 292.14,208.78 292.64,209.28 v292.64,219.44 | v315.5,51.3 316.01,51.3 319.57,47.74 319.57,46.72 320.58,45.71 320.58,42.66 D05.M2 | v310.42,63.49 310.93,64 310.93,78.22 v310.42,78.73
I/O_INT_RQ\  (via drill 0.61)
  Top 0.254: v341.41,46.72 342.94,46.72 342.94,43.68 342.43,43.68 342.43,41.14 341.41,40.12 339.89,40.12 338.87,41.14 D04.M2 | v391.7,126.99 391.7,141.72 392.21,142.23 392.21,148.32 v380.53,148.32 | v381.04,161.53 377.99,164.58 377.99,168.14 380.02,168.14 382.56,170.68 382.56,173.22 383.58,173.22 390.18,179.82 390.18,197.6 v391.7,197.6 | v383.58,204.71 384.59,205.73 384.59,208.27 381.54,208.27 v380.53,209.28 | v373.42,209.28 372.4,210.3 371.38,210.3 369.86,211.82 369.86,216.9 362.24,216.9 359.7,219.44 343.44,219.44 v342.94,218.94 | v330.24,241.8 333.28,241.8 335.32,243.83 337.86,243.83 A04.M2 | v329.73,213.86 333.79,217.92 v335.32,217.92
  Route2 0.254: v341.41,46.72 352.08,57.39 352.08,62.47 352.59,62.98 352.59,66.03 358.68,72.12 358.68,74.16 364.27,79.74 365.29,79.74 365.8,80.25 368.84,80.25 369.35,80.76 369.35,81.78 373.92,86.35 374.43,86.35 374.94,86.86 374.94,87.87 380.53,93.46 380.53,93.97 381.04,94.48 381.04,99.05 383.07,101.08 383.58,101.08 384.08,101.59 384.08,102.6 386.62,105.14 386.62,116.83 389.16,119.37 389.16,124.45 v391.7,126.99 | v380.53,209.28 376.46,209.28 374.94,210.81 v373.42,209.28 | v329.73,213.86 333.28,210.3 333.28,193.03 331.76,191.5 330.74,191.5 329.22,193.03 B05.E1
  Route15 0.254: v391.7,197.6 390.69,197.6 v383.58,204.71 | v339.38,223 340.9,224.52 339.89,225.54 339.89,226.05 v330.24,235.7
  Bottom 0.254: v380.53,148.32 381.04,148.83 v381.04,161.53 | v342.94,218.94 340.9,220.97 339.38,220.97 | 339.38,220.97 v339.38,223 | v330.24,235.7 v330.24,241.8 | v335.32,217.92 335.32,219.44 336.84,220.97 339.38,220.97
I/O_PWR_CLR  (via drill 0.61)
  Top 0.254: v330.74,107.68 331.76,106.67 v359.19,106.67
  Bottom 0.254: v330.74,107.68 331.25,108.19 331.25,121.4 329.22,123.43 C05.H1 | D02.V2 360.21,19.8 359.19,20.82 359.19,30.47 358.68,30.98 358.68,57.9 359.19,58.41 359.19,71.11 360.21,72.12 360.21,82.28 359.19,83.3 v359.19,106.67 359.19,204.2 360.21,205.22 360.21,221.48 A02.V2
I/O_SKP_RQ\  (via drill 0.61)
  Top 0.254: v329.22,183.88 v325.16,187.95 | v318.55,200.65 319.57,201.66 320.08,201.66 322.11,203.7 v323.63,203.7 | v328.2,209.79 v334.3,215.89 | v335.32,27.93 v337.86,30.47 | v334.3,23.36 331.25,26.4 326.17,26.4 325.66,26.91 323.12,26.91 312.46,16.24 v309.92,16.24 | v308.9,3.04 308.39,3.54 290.1,3.54 289.6,4.05 288.58,4.05 287.56,3.04 248.96,3.04 247.43,4.56 239.3,4.56 238.8,5.07 237.78,5.07 236.76,4.05 198.66,4.05 197.65,5.07 196.63,5.07 195.62,4.05 119.92,4.05 117.89,6.08 114.84,6.08 111.29,2.53 10.7,2.53 9.69,3.54 8.67,3.54 7.66,4.56 v7.15,4.56 | v7.66,273.29 19.34,284.98 61.5,284.98 62.01,284.47 63.03,284.47 63.54,283.96 102.65,283.96 103.67,284.98 118.4,284.98 119.92,286.5 139.23,286.5 139.74,285.99 154.47,285.99 154.98,285.48 217.97,285.48 218.98,286.5 218.98,292.6 229.14,292.6 229.65,292.09 237.78,292.09 238.8,291.07 248.45,291.07 249.46,290.06 258.1,290.06 259.12,291.07 262.16,291.07 263.69,289.55 284.52,289.55 286.04,291.07 v296.71,291.07 | v308.9,283.45 v296.2,283.45 | v312.96,293.1 313.47,292.6 335.32,292.6 v335.82,293.1
  Route15 0.254: v324.65,192.52 324.65,194.04 318.55,200.14 v318.55,200.65 | v335.82,264.15 v338.36,266.69
  Bottom 0.254: v329.22,183.88 329.22,181.85 328.71,181.34 B05.K1 | v325.16,187.95 324.14,188.96 324.14,192.01 v324.65,192.52 | v323.63,203.7 328.2,208.27 v328.2,209.79 | v334.3,215.89 333.79,216.4 333.79,231.13 336.84,234.18 336.84,249.42 337.86,250.43 A04.K2 337.86,251.45 336.33,252.97 336.33,263.64 v335.82,264.15 | v337.86,30.47 339.38,31.99 339.38,42.15 338.87,42.66 338.87,47.23 D04.K2 | v335.32,27.93 333.79,26.4 333.79,23.86 v334.3,23.36 | v309.92,16.24 308.9,15.23 v308.9,3.04 | v7.15,4.56 7.66,5.07 v7.66,273.29 | v296.71,291.07 296.2,290.56 v296.2,283.45 | v308.9,283.45 308.9,289.04 v312.96,293.1 | v335.82,293.1 336.84,292.09 336.84,268.21 v338.36,266.69
I/O_TS03  (via drill 0.61)
  Top 0.254: v309.92,57.9 310.93,56.88 311.44,56.88 311.44,55.36 v325.66,55.36 | v323.63,24.37 327.19,20.82 v360.72,20.82 | v372.4,232.65 371.89,233.16 369.35,233.16 368.84,232.65 364.78,232.65 364.27,232.14 A02.S2 | v377.48,249.42 v374.94,246.88 | v323.12,288.02 v372.91,288.02 | v317.54,282.44 316.01,283.96 309.92,283.96 309.41,284.47 v293.15,284.47 | v290.1,281.42 289.6,280.91 v286.04,280.91 | v284.52,252.46 280.96,252.46 v278.93,250.43 | v262.16,216.9 259.12,213.86 v259.12,211.32 | v299.76,91.43 300.26,90.92 301.28,90.92 v302.8,89.4
  Route2 0.254: v302.8,89.4 324.65,111.24 325.66,111.24 326.17,111.75 326.17,112.26 333.79,119.88 333.79,121.91 334.3,122.42 338.87,122.42 339.89,123.43 343.95,123.43 C04.H1 | v290.1,281.42 v293.15,284.47 | v278.93,244.84 266.74,232.65 v266.74,232.14
  Route15 0.254: v302.3,77.71 302.3,76.19 299.76,73.65 300.77,72.63 300.77,71.62 301.28,71.11 301.28,66.54 v309.92,57.9 | v259.12,211.32 263.18,207.25 263.18,205.22 263.69,204.71 263.69,194.55 263.18,194.04 263.18,192.52 263.69,192.01 263.69,182.36 267.24,178.8 267.24,177.28 269.78,174.74 269.78,154.42 270.29,153.91 270.29,149.34 275.88,143.75 275.88,126.99 277.4,125.46 277.4,120.38 292.14,105.65 292.14,100.06 292.64,99.56 292.64,98.54 v299.76,91.43
  Bottom 0.254: v302.8,89.4 301.79,88.38 301.79,78.22 v302.3,77.71 | v325.66,55.36 326.17,54.85 326.17,51.8 326.68,51.3 326.68,49.26 326.17,48.76 326.17,45.71 326.68,45.2 326.68,43.17 324.14,40.63 324.14,39.1 323.63,38.6 323.63,36.06 324.14,35.55 324.14,33.01 323.63,32.5 323.63,29.96 324.14,29.45 324.14,26.4 323.63,25.9 v323.63,24.37 | v360.72,20.82 362.24,22.34 362.24,26.91 363.26,27.93 D02.S2 | v372.4,232.65 371.89,233.16 371.89,243.83 v374.94,246.88 | v377.48,249.42 377.99,249.92 377.99,277.36 378.5,277.86 378.5,282.44 v372.91,288.02 | v317.54,282.44 v323.12,288.02 | v286.04,280.91 285.53,280.4 285.53,274.31 282.48,271.26 282.48,256.53 283.5,255.51 283.5,253.48 v284.52,252.46 | v278.93,250.43 278.42,249.92 278.42,245.35 v278.93,244.84 | v266.74,232.14 266.74,221.48 266.23,220.97 261.66,220.97 261.66,217.41 v262.16,216.9
I/O_TS04  (via drill 0.61)
  Top 0.254: v370.88,26.91 366.3,26.91 365.8,26.4 361.22,26.4 360.72,25.9 D02.T2
  Route2 0.254: v354.62,83.3 354.62,86.35 356.65,88.38 356.65,89.4 358.68,91.43 358.68,96.51 359.19,97.02 359.19,98.03 361.73,100.57 361.73,105.65 373.92,117.84 373.92,118.86 374.43,119.37 374.43,122.42 374.94,122.92 374.94,132.58 381.04,138.67 381.04,143.24 384.08,146.29 384.08,147.31 385.61,148.83 385.61,162.04 386.12,162.55 386.12,185.92 374.94,197.09 374.94,204.2 371.38,207.76 371.38,219.95 363.26,228.08 360.72,228.08 A02.T2
  Route15 0.254: v371.89,40.63 371.89,41.64 v369.35,44.18 | v353.6,72.63 v369.35,56.88
  Bottom 0.254: v370.88,26.91 371.89,27.93 v371.89,40.63 | v369.35,44.18 371.38,46.22 371.38,54.85 v369.35,56.88 | v353.6,72.63 353.6,79.24 354.62,80.25 v354.62,83.3
IM_00\  (via drill 0.61)
  Top 0.254: v332.27,71.11 339.89,71.11 340.9,70.09 D04.B1 | v335.82,138.16 v332.27,138.16 | v336.84,188.46 339.89,191.5 339.89,195.06 340.4,195.06 340.9,195.57 | 340.9,195.57 341.41,196.08 B04.D1 | 340.9,195.57 352.59,195.57 353.6,196.58 B03.D1 | v363.26,271.77 342.94,271.77 341.92,272.78 A04.B1 | v363.26,229.1 361.22,227.06 v358.18,227.06 | v358.18,208.78 343.44,208.78 v342.94,209.28
  Route2 0.254: v363.26,229.1 v368.84,234.68
  Route15 0.254: v337.86,202.68 339.89,200.65 339.89,199.12 341.41,197.6 B04.D1
  Bottom 0.254: v332.27,71.11 332.78,71.62 332.78,137.66 v332.27,138.16 | v335.82,138.16 336.84,139.18 v336.84,188.46 | v363.26,271.77 364.78,271.77 364.78,271.26 365.29,270.75 365.29,253.48 368.34,250.43 368.34,235.19 v368.84,234.68 | v358.18,227.06 358.68,226.56 358.68,219.44 357.67,218.43 357.67,209.28 v358.18,208.78 | v342.94,209.28 340.9,207.25 340.9,205.73 v337.86,202.68
IM_01\  (via drill 0.61)