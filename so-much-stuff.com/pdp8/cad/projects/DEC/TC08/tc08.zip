# EAGLE board tc08 (EAGLE 4.11), part 2 of 10
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
BAC_03\  (via drill 0.61) (continued)
  Route15 0.254: v254.54,44.18 254.54,42.66 v254.04,42.15 | v315.5,183.38 323.63,175.25 323.63,171.18 324.14,170.68 324.14,169.66 331.25,162.55 333.28,162.55 334.3,161.53 334.3,161.02 334.81,160.52 335.82,160.52 v363.26,133.08
  Bottom 0.254: v254.04,42.15 254.04,38.6 257.08,35.55 257.08,21.83 257.59,21.32 v257.59,12.18 | v333.28,11.67 332.78,12.18 332.78,60.44 v333.28,60.95 | v329.73,61.46 v329.73,70.6 | v334.81,83.81 335.32,84.32 335.32,86.86 336.84,88.38 v336.84,90.92 | v357.67,113.78 357.67,116.83 C03.K1 | v363.26,133.08 364.78,131.56 364.78,127.5 v363.26,125.97
BAC_04  (via drill 0.61)
  Top 0.254: C07.N2 293.66,108.7 295.69,110.73 296.2,110.73 C07.M2 | v313.47,173.72 315.5,173.72 B06.M1 | v306.87,155.94 306.36,156.45 300.26,156.45 297.22,153.4 v288.58,153.4 | v288.58,143.24 287.06,144.77 v284.52,144.77 | v279.44,126.48 278.93,125.97 277.4,125.97 v276.39,124.96 | v276.9,114.8 277.91,115.81 282.48,115.81 283.5,114.8 285.53,114.8 v286.04,115.3 | v287.56,105.65 288.07,106.16 292.64,106.16 v293.15,105.65
  Route2 0.254: v306.87,155.94 v312.46,161.53 | v284.52,144.77 284.01,144.77 283.5,144.26 282.99,144.26 v278.42,139.69
  Bottom 0.254: v313.47,173.72 313.98,173.22 313.98,163.06 v312.46,161.53 | v288.58,143.24 v288.58,153.4 | v278.42,139.69 278.93,139.18 278.93,128.51 279.44,128 v279.44,126.48 | v276.39,124.96 277.4,123.94 277.4,115.3 v276.9,114.8 | v286.04,115.3 286.04,106.67 287.06,105.65 v287.56,105.65 | v293.15,105.65 293.66,106.16 293.66,107.18 C07.N2
BAC_04\  (via drill 0.61)
  Top 0.254: v276.9,12.18 277.4,11.67 331.76,11.67 332.78,10.66 384.59,10.66 v389.67,15.74 | v387.64,53.84 v390.69,53.84 | v387.64,65.52 387.13,65.01 382.56,65.01 382.05,65.52 380.02,65.52 v379,66.54 | v372.91,78.22 371.89,79.24 v366.3,79.24 | v330.74,177.28 327.19,177.28 327.19,178.3 326.68,178.8 318.04,178.8 317.54,178.3 313.98,178.3 313.47,177.79 B06.L1
  Route2 0.254: v351.06,158.48 351.06,157.98 346.49,153.4 346.49,149.85 345.48,148.83 345.48,145.78 339.89,140.2 v339.89,137.66
  Route15 0.254: v258.61,42.15 v255.56,45.2 | v262.16,31.99 264.7,34.53 v270.29,28.94 | v372.91,72.63 v379,66.54 | v366.3,84.82 366.3,85.33 364.27,87.36 364.27,88.89 362.24,90.92 362.24,96 358.68,99.56 358.68,100.57 355.64,103.62 355.64,109.72 356.65,110.73 C03.M1 357.16,111.75 355.64,113.27 355.64,114.8 349.54,120.89 349.54,122.92 349.03,123.43 348.52,123.43 v338.87,133.08 | v330.74,177.28 331.76,177.28 338.87,170.17 339.89,170.17 351.06,158.99 v351.06,158.48
  Bottom 0.254: v255.56,45.2 255.56,47.23 D10.K2 | v258.61,42.15 259.62,41.14 259.62,39.61 260.64,38.6 260.64,33.52 v262.16,31.99 | v270.29,28.94 276.39,22.85 277.4,22.85 277.4,12.69 v276.9,12.18 | v389.67,15.74 390.69,16.75 390.69,51.3 391.2,51.8 391.2,53.33 v390.69,53.84 | v387.64,53.84 387.13,54.34 387.13,65.01 v387.64,65.52 | v372.91,78.22 v372.91,72.63 | v366.3,84.82 v366.3,79.24 | v339.89,137.66 339.89,135.12 338.87,134.1 v338.87,133.08
BAC_05
  Top 0.254: B07.R1 300.77,165.09 303.31,167.63 B07.P1 303.82,168.14 304.84,169.15 315,169.15 315.5,168.64 B06.P1
BAC_05\  (via drill 0.61)
  Top 0.254: v331.76,167.63 329.73,169.66 324.65,169.66 324.14,170.17 324.14,174.74 323.12,175.76 320.58,175.76 320.58,173.72 320.08,173.22 319.06,173.22 318.04,172.2 314.49,172.2 313.47,171.18 B06.N1 | v360.21,156.45 360.72,156.96 363.26,156.96 v363.76,157.47 | v372.4,112.26 371.89,112.76 365.29,112.76 362.75,115.3 361.73,115.3 361.22,115.81 v356.65,115.81
  Route15 0.254: v331.76,167.63 331.76,167.12 332.78,166.1 332.78,165.09 335.32,162.55 335.82,162.55 336.84,161.53 336.84,161.02 337.35,160.52 342.43,160.52 350.05,152.9 352.08,152.9 357.16,157.98 357.67,157.47 359.19,157.47 v360.21,156.45 | v363.76,157.47 372.4,148.83 v372.4,148.32
  Bottom 0.254: v372.4,148.32 371.89,147.82 371.89,112.76 v372.4,112.26 | v356.65,115.81 356.65,113.27 357.16,112.76 358.68,112.76 358.68,110.22 357.16,108.7 357.16,105.14 C03.P1
BAC_06  (via drill 0.61)
  Top 0.254: v247.94,148.83 296.2,148.83 v296.71,148.32 | B07.T2 296.2,155.94 296.71,155.94 B07.U2 297.22,155.94 298.23,155.94 299.25,156.96 v316.01,156.96
  Bottom 0.254: v247.94,148.83 247.94,68.06 248.96,67.04 D11.C1 | v296.71,148.32 296.71,154.93 B07.U2 | v316.01,156.96 316.01,161.02 B06.S1
BAC_06\  (via drill 0.61)
  Top 0.254: v360.21,105.65 360.72,106.16 366.3,106.16 v366.81,105.65 | v369.35,107.68 370.88,109.21 382.56,109.21 383.07,108.7 384.08,108.7 389.16,113.78 389.16,118.35 390.69,118.35 391.2,118.86 391.2,121.4 381.04,121.4 380.53,121.91 370.37,121.91 367.83,119.37 v363.76,119.37 | v347.51,136.13 v344.46,139.18
  Route2 0.254: v360.21,105.65 v357.67,103.11 | v366.81,105.65 367.32,105.65 v369.35,107.68 | v319.06,162.55 317.54,162.55 314.49,165.6 313.47,164.58 B06.R1
  Route15 0.254: v363.76,119.37 363.76,119.88 357.16,126.48 356.14,126.48 355.64,126.99 355.64,129.02 354.62,130.04 353.6,130.04 v347.51,136.13 | v344.46,139.18 339.38,144.26 337.35,144.26 v319.06,162.55
  Bottom 0.254: v357.67,103.11 357.67,99.05 C03.S1
BAC_07  (via drill 0.61)
  Top 0.254: v246.92,135.12 298.74,135.12 299.76,134.1 C07.D1 300.26,134.1 300.77,134.1 302.8,136.13 C07.C1 | v303.82,153.4 304.33,153.91 310.42,153.91 310.93,154.42 315,154.42 315.5,154.93 B06.U1
  Bottom 0.254: v246.92,135.12 247.43,134.61 247.43,68.57 246.42,67.55 246.42,66.03 243.88,63.49 243.88,61.46 243.37,60.95 D11.E2 | v303.82,153.4 303.82,144.26 304.84,143.24 304.84,142.23 303.31,140.7 303.31,137.15 C07.C1
BAC_07\  (via drill 0.61)
  Top 0.254: v316.52,151.88 313.47,151.88 B06.V1 | v353.6,91.43 354.11,91.94 356.65,91.94 C03.U1
  Route15 0.254: v316.52,144.77 331.25,130.04 331.25,128.51 341.92,117.84 341.92,116.83 339.89,114.8 339.38,115.3 v338.87,115.3 | v338.36,107.68 338.36,107.18 353.6,91.94 v353.6,91.43
  Bottom 0.254: v316.52,144.77 v316.52,151.88 | v338.87,115.3 339.38,114.8 339.38,108.7 v338.36,107.68
BAC_08  (via drill 0.61)
  Top 0.254: v276.9,52.31 247.43,52.31 246.42,51.3 D11.J1 | v276.39,123.43 278.42,125.46 288.58,125.46 289.6,126.48 293.15,126.48 C07.F2 294.17,127.5 294.68,127.5 296.71,129.53 C07.E2 | v305.85,192.01 305.34,191.5 296.71,191.5 295.69,190.49 295.69,183.38 v296.71,183.38
  Route2 0.254: v296.71,183.38 296.71,182.87 v291.63,177.79
  Route15 0.254: v291.12,166.1 291.12,163.06 296.2,157.98 v296.2,157.47 | v296.2,144.77 293.66,142.23 v300.26,135.62
  Bottom 0.254: v276.9,52.31 277.4,52.82 277.4,95.49 276.9,96 276.9,111.24 275.88,112.26 275.88,115.3 276.39,115.81 v276.39,123.43 | v305.85,192.01 305.85,196.08 B06.D2 | v291.63,177.79 292.14,177.28 292.14,167.12 v291.12,166.1 | v296.2,157.47 295.69,156.96 295.69,145.28 v296.2,144.77 | v300.26,135.62 299.25,135.62 297.22,133.59 297.22,130.54 C07.E2
BAC_08\  (via drill 0.61)
  Top 0.254: v316.52,196.58 317.03,197.09 317.54,197.09 318.55,198.11 326.17,198.11 v326.68,197.6 | v343.95,185.41 350.56,185.41 v351.06,184.9 | v351.57,134.1 349.03,131.56 349.03,130.04 348.52,129.53 348.52,127.5 348.02,127.5 C03.F2
  Route2 0.254: v343.95,185.41 v340.9,188.46 | v363.26,147.82 363.26,146.8 353.6,137.15 353.6,136.13 v351.57,134.1
  Route15 0.254: v326.68,197.6 331.76,192.52 335.32,192.52 v336.33,191.5 | v351.06,184.9 355.64,180.33 355.64,173.72 363.26,166.1 v363.26,165.6
  Bottom 0.254: v316.52,196.58 316.52,199.12 B06.C1 | v336.33,191.5 339.38,191.5 339.38,189.98 v340.9,188.46 | v363.26,165.6 364.78,164.07 364.78,149.34 v363.26,147.82
BAC_09  (via drill 0.61)
  Top 0.254: C07.J1 300.26,119.88 300.26,117.34 302.8,117.34 C07.K1 | v302.3,189.98 305.85,189.98 B06.F2 | v285.02,152.39 285.02,150.86 289.09,150.86 v289.6,151.37
  Route2 0.254: v302.3,184.9 302.3,183.88 300.77,182.36 299.76,182.36 298.74,181.34 298.74,180.33 291.63,173.22 291.63,172.71 289.6,170.68 289.09,170.68 288.58,170.17 288.58,167.63 287.06,166.1 286.55,166.1 v285.02,164.58
  Route15 0.254: v289.6,144.26 291.12,144.26 292.14,143.24 292.14,137.15 298.23,131.05 298.23,126.99 298.74,126.48 298.74,125.97 v300.26,124.45
  Bottom 0.254: v302.3,189.98 301.79,189.47 301.79,185.41 v302.3,184.9 | v285.02,164.58 285.53,164.07 285.53,152.9 v285.02,152.39 | v289.6,144.26 v289.6,151.37 | v300.26,124.45 300.26,121.4 C07.J1
BAC_09\  (via drill 0.61)
  Top 0.254: v351.06,153.91 351.57,153.91 352.08,154.42 352.08,156.96 v347.51,156.96
  Route2 0.254: v341.92,131.56 342.94,132.58 342.94,139.18 345.98,142.23 345.98,148.32 351.06,153.4 v351.06,153.91 | v328.2,178.3 312.96,193.54 309.92,193.54 B06.E2
  Route15 0.254: v341.41,129.02 347.51,122.92 347.51,121.4 C03.J2 | v347.51,156.96 347,156.96 341.92,162.04 341.92,162.55 338.87,165.6 338.36,165.6 336.33,167.63 334.81,167.63 332.78,169.66 332.78,173.72 v328.2,178.3
  Bottom 0.254: v341.41,129.02 341.92,129.53 v341.92,131.56
BAC_10\  (via drill 0.61)
  Top 0.254: v254.04,261.1 254.54,261.61 275.37,261.61 v275.88,261.1 | v274.36,217.92 279.44,212.84 279.44,209.28 v282.99,209.28 | v306.36,187.44 308.9,187.44 B06.H2 | v289.6,196.08 292.64,199.12 v294.17,199.12
  Route2 0.254: v314.49,83.3 315.5,84.32 318.04,84.32 318.55,84.82 327.19,84.82 336.33,93.97 336.33,94.48 347,105.14 347.51,105.14 349.54,107.18 349.54,112.26 348.02,113.78 C03.L2 | v271.82,98.03 274.86,101.08 275.37,101.08 275.88,101.59 275.88,105.65 276.39,106.16 276.39,108.7 279.94,112.26 281.98,112.26 285.02,115.3 285.02,115.81 288.58,119.37 288.58,121.91 289.09,122.42 291.12,122.42 292.14,123.43 292.14,124.45 287.56,129.02 287.06,128.51 286.55,128.51 v284.52,126.48 | v274.36,177.79 276.39,179.82 276.39,181.34 282.99,187.95 282.99,189.47 283.5,189.98 285.02,189.98 288.58,193.54 288.58,195.06 v289.6,196.08
  Route15 0.254: v275.88,249.42 v273.34,246.88 | v282.99,209.28 283.5,209.28 293.66,199.12 | 293.66,199.12 295.18,197.6 295.18,197.09 296.71,195.57 298.23,195.57 v306.36,187.44 | v314.49,83.3 306.36,83.3 305.85,83.81 304.84,83.81 303.31,85.33 292.64,85.33 288.58,89.4 288.58,89.9 288.07,90.41 284.52,90.41 282.99,88.89 281.98,89.9 281.98,91.94 277.4,96.51 277.4,98.03 275.37,100.06 273.85,100.06 v271.82,98.03 | v284.52,126.48 284.52,127.5 282.99,129.02 282.99,135.12 279.44,138.67 279.44,142.74 275.37,146.8 275.37,150.86 274.86,151.37 274.86,152.9 273.34,154.42 273.34,176.77 v274.36,177.79 | 293.66,199.12 v294.17,199.12
  Bottom 0.254: v254.04,261.1 253.53,261.61 253.53,265.67 253.02,266.18 A10.D2 | v275.88,261.1 276.39,260.59 276.39,249.92 v275.88,249.42 | v273.34,246.88 273.34,243.32 276.9,239.76 276.9,224.52 274.36,221.98 v274.36,217.92
BAC_11\  (via drill 0.61)
  Top 0.254: v246.42,81.78 v262.16,81.78 | v289.09,76.19 294.17,81.27 311.44,81.27 313.47,79.24 313.47,78.22 315,78.22 317.54,80.76 v317.54,85.33 | v305.85,180.84 308.9,180.84 B06.K2 | v289.6,118.86 v289.6,121.4
  Route2 0.254: v262.16,81.78 265.21,81.78 268.26,84.82 270.29,84.82 | 270.29,84.82 274.86,84.82 v275.37,85.33 | v321.09,88.38 324.14,85.33 331.76,92.95 331.76,94.48 343.44,106.16 345.48,106.16 347,107.68 C03.N2 | v294.17,192.01 293.66,192.52 292.14,191 292.14,184.39 286.04,178.3 286.04,177.79 284.01,175.76 283.5,175.76 282.99,175.25 282.99,174.23 281.47,172.71 280.45,172.71 279.44,171.69 279.44,168.64 v274.86,164.07 | v289.6,118.86 289.09,118.35 289.09,113.78 287.06,111.75 287.06,110.22 279.44,102.6 279.44,99.56 273.34,93.46 273.34,92.44 271.31,90.41 270.8,90.41 270.29,89.9 270.29,84.82
  Route15 0.254: v240.32,91.43 240.32,90.41 241.34,89.4 241.34,87.87 243.37,85.84 243.37,84.82 v246.42,81.78 | v275.37,85.33 275.88,85.33 284.01,77.2 288.07,77.2 v289.09,76.19 | v305.85,180.84 305.34,180.84 302.3,183.88 301.79,183.88 301.28,184.39 301.28,184.9 v294.17,192.01 | v274.86,164.07 274.86,163.56 275.88,162.55 275.88,153.4 276.9,152.39 276.9,148.83 277.4,148.32 277.4,145.78 285.53,137.66 285.53,133.08 286.04,132.58 286.04,124.96 v289.6,121.4
  Bottom 0.254: v240.32,91.43 240.32,92.95 241.34,93.97 241.34,96 239.3,98.03 239.3,101.08 C11.R2 | v317.54,85.33 320.58,88.38 v321.09,88.38
BLK_IN_SYNC  (via drill 0.61)
  Top 0.254: v222.54,112.26 223.05,112.76 228.13,112.76 230.16,114.8 231.68,114.8 232.7,115.81 234.22,115.81 236.76,113.27 238.8,113.27 239.3,112.76 240.32,112.76 v241.34,113.78 | v241.84,122.42 244.89,122.42 v246.42,123.94 | v248.96,126.48 245.91,129.53 243.37,129.53 C11.E2 | v149.39,54.85 149.9,55.36 223.05,55.36 v225.08,57.39
  Route2 0.254: v246.42,123.94 v248.96,126.48
  Route15 0.254: v225.08,88.89 224.06,89.9 224.06,94.98 221.02,98.03 C13.S1
  Bottom 0.254: v222.54,112.26 222.54,108.7 219.49,105.65 219.49,100.06 220.51,99.05 C13.S1 | v241.34,113.78 241.34,118.35 241.84,118.86 v241.84,122.42 | v149.39,54.85 149.39,73.65 148.37,74.66 148.37,86.86 148.88,87.36 148.88,103.11 147.86,104.13 CD18.AP2 | v225.08,57.39 224.57,57.9 224.57,88.38 v225.08,88.89
BLK_IN_SYNC\  (via drill 0.61)
  Top 0.254: v221.52,101.08 217.97,101.08 C13.R1 | v232.7,92.44 233.21,92.95 235.24,92.95 235.75,93.46 240.32,93.46 v241.34,92.44 | v241.34,72.12 241.84,71.62 249.46,71.62 v249.97,71.11 | v249.97,50.79 D10.J2 | v258.61,276.34 261.66,276.34 A10.A1 | v222.54,272.78 221.52,271.77 171.23,271.77 170.22,270.75 v168.18,270.75 | v167.68,164.58 170.72,161.53 v171.74,161.53 | v212.89,110.22 213.4,109.72 214.92,109.72 215.94,110.73 v215.94,111.24
  Route15 0.254: v221.52,101.08 222.03,101.08 222.54,100.57 223.56,100.57 226.1,98.03 227.11,98.03 v232.7,92.44 | v258.61,276.34 257.59,276.34 256.07,277.86 250.48,277.86 243.37,284.98 240.32,284.98 237.78,287.52 232.7,287.52 222.54,277.36 v222.54,276.85 | v177.33,151.88 177.33,144.26 177.84,143.75 177.84,141.72 175.3,139.18 176.31,138.16 177.84,138.16 185.46,130.54 186.47,130.54 189.52,127.5 189.52,125.46 197.65,117.34 199.68,117.34 204.25,112.76 210.35,112.76 v212.89,110.22
  Bottom 0.254: v241.34,92.44 241.34,82.28 241.84,81.78 241.84,74.16 241.34,73.65 v241.34,72.12 | v249.97,71.11 250.48,70.6 250.48,51.3 v249.97,50.79 | v222.54,276.85 v222.54,272.78 | v168.18,270.75 168.18,266.18 167.68,265.67 167.68,264.66 168.18,264.15 168.18,223.51 166.66,221.98 166.66,220.97 167.68,219.95 167.68,209.28 165.14,206.74 165.14,180.33 167.17,178.3 168.18,178.3 168.18,165.09 v167.68,164.58 | v171.74,161.53 171.74,157.47 v177.33,151.88 | v215.94,111.24 218.48,111.24 218.48,109.21 218.98,108.7 218.98,107.18 217.97,106.16 217.97,102.1 C13.R1
BMB_00
  Top 0.254: C08.B1 288.07,139.69 288.58,140.2 292.14,140.2 293.15,141.21 309.41,141.21 310.42,140.2 312.46,140.2 C06.B1
BMB_00\
  Top 0.254: C06.A1 316.52,143.24 320.08,143.24 321.6,144.77 376.97,144.77 377.99,143.75 377.99,141.21 372.4,141.21 371.38,140.2 367.32,140.2 C02.B1
BMB_01
  Top 0.254: C08.H1 291.12,123.94 292.14,124.96 295.69,124.96 296.2,125.46 300.77,125.46 303.82,128.51 310.42,128.51 311.44,129.53 315.5,129.53 C06.E1
BMB_01\  (via drill 0.61)
  Top 0.254: v319.57,135.12 318.55,135.12 317.03,133.59 313.47,133.59 C06.D1 | v330.24,129.53 330.74,129.02 v336.84,129.02 | v341.92,136.64 343.44,135.12 367.32,135.12 369.35,133.08 370.37,133.08 370.88,132.58 370.88,130.54 370.37,130.54 C02.E1
  Route15 0.254: v319.57,135.12 v321.6,133.08
  Bottom 0.254: v321.6,133.08 324.65,130.04 324.65,129.53 325.66,128.51 330.24,128.51 v330.24,129.53 | v336.84,129.02 336.84,131.05 337.86,132.07 339.89,132.07 339.89,134.1 341.92,136.13 v341.92,136.64
BMB_02
  Top 0.254: C08.N1 288.07,108.19 291.63,108.19 299.25,115.81 304.84,115.81 309.41,120.38 309.92,120.38 312.96,123.43 315.5,123.43 C06.H1
BMB_02\  (via drill 0.61)
  Top 0.254: v323.12,125.46 318.55,125.46 317.54,126.48 313.98,126.48 313.47,126.99 C06.F1 | v328.71,93.97 329.73,92.95 336.84,92.95 337.35,93.46 339.38,93.46 340.4,92.44 v340.9,92.44 | v343.44,85.33 343.95,85.84 355.13,85.84 355.64,85.33 364.27,85.33 v364.78,84.82 | v365.29,122.92 365.8,123.43 369.35,123.43 C02.H1
  Route15 0.254: v323.12,125.46 323.63,125.46 v325.66,123.43
  Bottom 0.254: v325.66,123.43 327.19,121.91 327.19,106.67 326.68,106.16 326.68,96.51 328.71,94.48 v328.71,93.97 | v340.9,92.44 343.44,89.9 v343.44,85.33 | v364.78,84.82 364.27,85.33 364.27,90.41 364.78,90.92 364.78,99.05 365.29,99.56 v365.29,122.92
BMB_03  (via drill 0.61)
  Top 0.254: v285.02,121.91 285.53,122.42 310.93,122.42 313.47,124.96 315,124.96 315.5,125.46 316.52,125.46 317.54,124.45 317.54,117.84 316.52,117.84 C06.K1
  Bottom 0.254: v285.02,121.91 285.53,122.42 285.53,128.51 284.52,129.53 C08.E2
BMB_03\  (via drill 0.61)
  Top 0.254: v297.72,112.76 300.77,112.76 301.79,113.78 303.82,113.78 308.9,118.86 311.44,118.86 312.46,119.88 C06.J1 | v296.71,114.8 294.68,112.76 289.6,112.76 v288.07,111.24 | v292.14,76.19 307.38,76.19 307.88,75.68 316.01,75.68 316.52,76.19 320.58,76.19 321.6,75.17 329.22,75.17 330.24,74.16 336.84,74.16 337.35,74.66 v387.13,74.66 | v390.18,119.37 374.94,119.37 373.42,117.84 370.37,117.84 C02.K1
  Bottom 0.254: v297.72,112.76 296.71,113.78 v296.71,114.8 | v288.07,111.24 288.58,110.73 288.58,100.57 289.09,100.06 289.09,90.92 290.1,89.9 290.1,84.82 291.12,83.81 291.12,82.79 292.14,81.78 v292.14,76.19 | v387.13,74.66 388.66,76.19 388.66,98.03 390.18,99.56 390.18,107.68 389.67,108.19 389.67,118.86 v390.18,119.37
BMB_04  (via drill 0.61)
  Top 0.254: v281.47,110.22 282.99,108.7 282.99,106.67 313.98,106.67 315,107.68 315,110.73 315.5,110.73 C06.M1
  Bottom 0.254: v281.47,110.22 281.47,113.78 C08.L2
BMB_04\  (via drill 0.61)
  Top 0.254: v303.82,112.76 306.87,112.76 307.38,113.27 311.95,113.27 312.46,113.78 C06.L1 | v301.79,118.35 301.79,121.91 298.74,121.91 297.22,120.38 296.71,120.38 294.68,118.35 v294.68,117.84 | v294.68,90.41 298.23,86.86 313.47,86.86 v313.98,87.36 | v313.47,71.62 331.25,71.62 331.76,72.12 336.84,72.12 337.35,71.62 v383.58,71.62 | v383.58,109.72 371.38,109.72 370.37,110.73 C02.M1
  Bottom 0.254: v303.82,112.76 302.3,114.29 302.3,116.32 301.79,116.83 v301.79,118.35 | v294.68,117.84 295.18,117.34 295.18,90.92 v294.68,90.41 | v313.98,87.36 313.47,86.86 v313.47,71.62 | v383.58,71.62 384.08,72.12 384.08,105.65 383.58,106.16 v383.58,109.72
BMB_05
  Top 0.254: C08.S2 284.52,98.03 288.58,98.03 289.6,97.02 298.23,97.02 304.33,103.11 311.44,103.11 312.96,104.64 315.5,104.64 C06.P1
BMB_05\  (via drill 0.61)
  Top 0.254: v313.47,103.62 313.98,103.11 v321.6,103.11 | v321.09,90.92 321.6,90.41 327.19,90.41 327.7,89.9 333.79,89.9 334.3,90.41 335.82,90.41 338.87,87.36 345.98,87.36 346.49,86.86 351.57,86.86 v352.08,87.36 | v352.08,84.82 363.26,84.82 364.27,83.81 v372.91,83.81 | v374.43,104.64 370.37,104.64 C02.P1
  Bottom 0.254: v313.47,103.62 313.47,106.67 312.96,107.18 C06.N1 | v321.6,103.11 321.09,102.6 v321.09,90.92 | v352.08,87.36 v352.08,84.82 | v372.91,83.81 373.42,84.32 373.42,85.33 374.94,86.86 374.94,104.13 v374.43,104.64
BMB_06  (via drill 0.61)
  Top 0.254: v315.5,127.5 314.49,128.51 311.44,128.51 310.42,127.5 v309.92,127.5
  Route2 0.254: v281.98,188.46 281.98,188.96 282.48,189.47 282.48,194.04 v286.04,197.6
  Route15 0.254: v316.52,101.59 316.52,103.11 319.06,105.65 317.54,107.18 317.54,125.46 v315.5,127.5 | v309.92,127.5 304.84,132.58 304.84,138.16 289.6,153.4 289.6,153.91 289.09,154.42 289.09,155.44 287.56,156.96 286.55,156.96 286.04,157.47 286.04,162.04 282.99,165.09 282.99,173.22 279.44,176.77 279.44,185.92 v281.98,188.46
  Bottom 0.254: v316.52,101.59 316.52,99.56 316.01,99.05 C06.S1 | v286.04,197.6 287.06,198.62 287.06,202.17 B08.B1
BMB_06\  (via drill 0.61)
  Top 0.254: v297.72,96 298.23,96 302.3,100.06 306.87,100.06 307.88,101.08 312.46,101.08 C06.R1 | v297.72,68.57 324.14,68.57 324.65,68.06 372.91,68.06 373.42,68.57 v389.67,68.57 | v389.67,97.02 375.45,97.02 374.43,98.03 370.37,98.03 C02.S1
  Bottom 0.254: v297.72,96 298.23,95.49 298.23,69.08 v297.72,68.57 | v389.67,68.57 389.67,74.66 389.16,75.17 389.16,96.51 v389.67,97.02
BMB_07  (via drill 0.61)
  Top 0.254: v319.06,104.13 316.52,106.67 v316.52,107.68
  Route2 0.254: v316.52,96 316.52,97.02 317.54,98.03 317.54,102.6 v319.06,104.13
  Route15 0.254: v316.52,107.68 316.52,108.19 314.49,110.22 314.49,146.29 310.93,149.85 310.93,170.68 303.82,177.79 303.82,178.3 302.8,179.31 302.3,179.31 300.77,180.84 300.77,181.34 299.76,182.36 299.25,182.36 290.61,191 290.61,193.03 B08.E1
  Bottom 0.254: v316.52,96 316.52,92.44 C06.U1
BMB_07\  (via drill 0.61)
  Top 0.254: v319.57,77.2 v315,77.2 | v323.63,65.01 332.78,65.01 333.28,65.52 336.84,65.52 337.35,65.01 v339.38,65.01 | v342.94,76.19 343.44,75.68 367.83,75.68 v368.34,76.19 | v367.32,91.94 369.35,91.94 C02.U1
  Bottom 0.254: v315,77.2 315.5,77.71 315.5,88.89 C06.V1 | v319.57,77.2 319.57,72.63 323.63,68.57 v323.63,65.01 | v339.38,65.01 339.89,65.52 339.89,73.14 v342.94,76.19 | v368.34,76.19 369.35,77.2 369.35,85.33 368.84,85.84 368.84,88.89 367.32,90.41 v367.32,91.94
BMB_08  (via drill 0.61)
  Top 0.254: v312.96,143.24 312.96,147.31 332.78,147.31 v333.28,146.8 | v308.9,195.57 308.39,195.06 298.23,195.06 297.72,194.55 289.09,194.55 288.07,193.54 284.52,193.54 B08.E2
  Route2 0.254: v306.36,135.62 306.36,136.64 v312.96,143.24 | v319.57,174.23 319.57,175.76 320.58,176.77 320.58,178.8 316.52,182.87 316.52,183.88 308.39,192.01 308.39,195.06 v308.9,195.57
  Route15 0.254: v332.78,161.53 331.25,161.53 323.63,169.15 323.63,170.17 v319.57,174.23
  Bottom 0.254: v306.36,135.62 306.36,134.1 C06.D2 | v333.28,146.8 332.78,147.31 v332.78,161.53
BMB_08\  (via drill 0.61)
  Top 0.254: v316.01,139.69 315.5,139.18 314.49,139.18 313.47,138.16 305.85,138.16 304.84,139.18 301.79,139.18 300.77,138.16 299.25,138.16 v297.72,139.69 | v299.25,147.82 299.76,148.32 356.65,148.32 v358.18,146.8 | v358.18,127.5 358.68,126.99 C02.F2
  Bottom 0.254: v316.01,139.69 316.01,137.15 C06.C1 | v297.72,139.69 298.23,140.2 298.23,145.28 297.72,145.78 297.72,146.8 298.74,147.82 v299.25,147.82 | v358.18,146.8 358.68,146.29 358.68,128 v358.18,127.5
BMB_09  (via drill 0.61)
  Top 0.254: v305.85,129.53 303.82,131.56 v294.68,131.56 | v295.69,138.16 293.15,138.16 292.14,139.18 289.09,139.18 288.07,138.16 277.4,138.16 276.39,139.18 273.34,139.18 272.32,138.16 264.7,138.16 263.18,139.69 v260.64,139.69 | v260.13,143.24 v262.16,145.28 | v261.66,153.4 262.16,153.91 v264.7,153.91 | v266.74,165.6 267.24,166.1 278.42,166.1 278.93,166.61 287.56,166.61 288.58,167.63 288.58,173.72 290.1,173.72 B08.M1
  Bottom 0.254: v305.85,129.53 305.85,127.5 C06.F2 | v294.68,131.56 295.18,132.07 295.18,137.66 v295.69,138.16 | v260.64,139.69 260.13,140.2 v260.13,143.24 | v262.16,145.28 261.66,145.78 v261.66,153.4 | v264.7,153.91 266.23,155.44 266.23,157.47 266.74,157.98 v266.74,165.6
BMB_09\  (via drill 0.61)
  Top 0.254: v321.6,128.51 320.58,128.51 317.54,131.56 310.93,131.56 309.92,130.54 C06.E2 | v324.14,113.27 324.14,109.72 345.98,109.72 347,110.73 v348.52,110.73 | v348.52,122.42 349.03,121.91 358.68,121.91 359.7,120.89 C02.J2
  Bottom 0.254: v321.6,128.51 324.14,125.97 v324.14,113.27 | v348.52,110.73 349.03,111.24 349.03,121.91 v348.52,122.42
BMB_10  (via drill 0.61)
  Top 0.254: v306.87,123.94 307.88,124.96 308.39,124.96 308.9,125.46 314.49,125.46 315,125.97 317.03,125.97 320.58,122.42 338.87,122.42 345.98,129.53 345.98,131.56 345.48,131.56 340.9,136.13 340.9,138.16 337.86,141.21 v335.82,141.21 | v335.82,166.61 319.57,166.61 316.52,169.66 311.44,169.66 308.9,172.2 307.38,172.2 306.87,172.71 297.22,172.71 292.14,167.63 292.14,165.09 288.07,165.09 B08.R1
  Bottom 0.254: v306.87,123.94 306.87,121.91 306.36,121.4 C06.J2 | v335.82,141.21 336.33,141.72 336.33,166.1 v335.82,166.61
BMB_10\  (via drill 0.61)
  Top 0.254: v335.82,112.76 348.52,112.76 349.03,113.27 352.08,113.27 352.59,112.76 354.62,112.76 356.65,114.8 359.19,114.8 359.7,114.29 C02.L2 | v325.66,99.56 325.16,100.06 v309.92,100.06
  Route2 0.254: v335.82,112.76 335.82,112.26 334.81,111.24 334.81,110.22 333.28,108.7 333.28,107.18 v325.66,99.56
  Bottom 0.254: v309.92,100.06 308.39,101.59 308.39,122.92 308.9,123.43 C06.H2
BMB_11  (via drill 0.61)
  Top 0.254: v306.36,118.86 305.85,119.37 v302.8,119.37 | v280.45,144.26 279.44,145.28 v269.28,145.28 | v269.28,151.37 269.78,150.86 277.4,150.86 v280.45,153.91 | v281.47,162.04 279.44,164.07 279.44,166.1 283.5,166.1 v284.01,165.6
  Route2 0.254: v280.45,156.45 278.42,158.48 281.47,161.53 v281.47,162.04 | v284.01,177.28 284.01,178.8 284.52,179.31 285.02,179.31 285.53,179.82 285.53,180.84 288.07,183.38 B08.J1
  Route15 0.254: v301.28,123.43 299.76,123.43 298.23,124.96 298.23,125.97 280.45,143.75 v280.45,144.26
  Bottom 0.254: v306.36,118.86 306.36,114.8 C06.L2 | v302.8,119.37 301.28,119.37 v301.28,123.43 | v269.28,145.28 v269.28,151.37 | v280.45,153.91 v280.45,156.45 | v284.01,165.6 285.53,167.12 285.53,175.76 v284.01,177.28
BMB_11\  (via drill 0.61)
  Top 0.254: v351.06,101.08 349.03,103.11 345.98,103.11 343.44,100.57 342.43,100.57 341.92,100.06 338.87,100.06 v337.35,101.59 | v312.46,117.84 309.92,117.84 C06.K2
  Route2 0.254: v351.06,101.08 357.16,107.18 357.16,108.7 358.18,109.72 359.7,108.19 C02.N2
  Route15 0.254: v337.35,101.59 337.35,102.1 333.28,106.16 333.28,110.22 329.73,113.78 328.71,113.78 323.12,108.19 322.11,108.19 319.57,105.65 320.08,105.14 320.08,103.62 319.57,103.11 318.55,103.11 317.54,102.1 317.54,101.08 316.52,100.06 315.5,101.08 315.5,103.11 314.49,104.13 314.49,109.21 313.98,109.72 313.98,116.32 v312.46,117.84
BMB_TO_DTB  (via drill 0.61)
  Top 0.254: B08.D2 281.47,196.08 287.06,196.08 B08.D1 | v278.42,43.17 234.22,43.17 233.72,43.68 D12.L1
  Bottom 0.254: C08.M1 290.1,111.75 289.6,112.26 289.6,116.32 288.58,117.34 288.58,122.92 287.56,123.94 287.56,126.48 C08.F1 287.56,127.5 289.09,129.02 289.09,141.21 290.1,142.23 C08.A1 290.61,143.24 290.61,152.9 289.09,154.42 289.09,166.61 290.1,167.63 B08.P1 290.61,168.64 290.61,171.69 288.07,174.23 288.07,176.26 287.56,176.77 B08.L1 288.07,177.79 289.09,178.8 289.09,181.85 290.1,182.87 290.1,186.42 B08.H1 289.09,188.46 289.09,195.06 288.07,196.08 B08.D1 287.56,197.09 287.56,198.62 288.58,199.63 288.58,204.2 290.1,205.73 B08.A1 | v278.42,43.17 278.42,90.41 282.48,94.48 282.48,98.03 280.96,99.56 280.96,101.08 C08.R2 281.47,102.1 282.48,103.11 282.48,116.32 283.5,117.34 C08.K2 283.5,117.84 282.48,118.86 282.48,129.02 280.96,130.54 280.96,132.58 C08.D2 280.96,134.1 279.44,135.62 279.44,195.06 280.45,196.08 B08.D2
BMR00  (via drill 0.61)
  Top 0.254: v93.51,261.1 93,261.61 85.89,261.61 84.87,260.59 A23.F1 | v101.64,250.43 102.65,249.42 v126.02,249.42 | v125,237.73 123.99,236.72 120.43,236.72 v119.92,237.22 | v119.92,230.11 120.94,229.1 v123.48,229.1 | v128.56,217.41 129.58,216.4 152.44,216.4 154.47,214.36 v154.47,210.3
  Route2 0.254: v127.04,218.94 v128.56,217.41
  Route15 0.254: v154.47,210.3 154.47,209.79 158.02,206.24 158.02,205.22 160.56,202.68 162.09,202.68 166.15,198.62 167.17,198.62 175.8,189.98 177.33,189.98 184.95,182.36 189.52,182.36 195.62,176.26 197.14,176.26 201.71,171.69 201.71,168.64 B14.P2
  Bottom 0.254: v93.51,261.1 101.64,252.97 v101.64,250.43 | v126.02,249.42 127.04,248.4 127.04,239.76 v125,237.73 | v119.92,237.22 120.43,236.72 120.43,230.62 v119.92,230.11 | v123.48,229.1 123.99,228.59 123.99,226.05 127.04,223 v127.04,218.94
BMR00\  (via drill 0.61)
  Top 0.254: v133.13,256.53 131.1,258.56 121.45,258.56 120.94,258.05 113.83,258.05 113.32,258.56 93,258.56 92.49,258.05 88.43,258.05 87.92,257.54 A23.H1 | v136.18,252.46 142.78,252.46 143.8,251.45 v144.31,251.45 | v149.39,238.75 151.42,236.72 v172.76,236.72 | v182.41,217.92 182.92,217.41 189.52,217.41 190.54,216.4 v198.16,216.4 | v205.78,169.66 205.27,169.15 200.7,169.15 199.17,167.63 199.17,165.09 B14.R2
  Route2 0.254: v211.87,175.76 v205.78,169.66
  Route15 0.254: v176.31,223 176.31,222.49 180.88,217.92 v182.41,217.92 | v198.16,207.76 198.16,205.73 199.68,204.2 199.68,199.63 206.28,193.03 206.79,193.03 206.79,191.5 207.81,190.49 207.81,189.47 209.33,187.95 209.33,186.93 v209.84,186.42
  Bottom 0.254: v133.13,256.53 136.18,253.48 v136.18,252.46 | v144.31,251.45 149.39,246.37 v149.39,238.75 | v172.76,236.72 174.28,236.72 174.28,236.21 177.84,232.65 177.84,224.52 v176.31,223 | v198.16,216.4 197.65,215.89 197.65,208.27 v198.16,207.76 | v209.84,186.42 209.84,181.34 212.38,178.8 212.38,176.26 v211.87,175.76
BMR01  (via drill 0.61)
  Top 0.254: v90.97,264.15 93,262.12 v107.73,262.12 | v108.75,230.11 v112.81,230.11 | v111.29,223 111.8,223.51 133.13,223.51 v134.66,221.98 | v140.24,213.35 v134.66,213.35 | v141.26,201.66 140.75,201.16 140.24,201.16 v138.72,199.63 | v137.2,188.96 154.47,188.96 156.5,186.93 v157.52,186.93 | v171.23,175.25 171.74,175.76 185.46,175.76 v185.96,175.25
  Route2 0.254: v185.96,175.25 186.98,176.26 186.98,178.3 188,179.31 190.03,179.31 201.71,191 203.74,191 204.25,190.49 B14.F1
  Route15 0.254: v157.52,186.93 157.52,186.42 163.61,180.33 165.14,180.33 167.17,178.3 168.18,178.3 v171.23,175.25
  Bottom 0.254: v90.97,264.15 85.89,269.23 85.89,270.75 84.36,272.28 A23.B1 | v107.73,262.12 108.24,261.61 108.24,244.84 110.78,242.3 110.78,233.67 110.27,233.16 110.27,232.14 112.3,230.11 v112.81,230.11 | v108.75,230.11 108.24,229.6 108.24,226.05 v111.29,223 | v134.66,213.35 v134.66,221.98 | v140.24,213.35 143.29,213.35 143.29,205.22 141.26,203.19 v141.26,201.66 | v138.72,199.63 136.69,197.6 136.69,195.57 137.2,195.06 137.2,191.5 136.69,191 136.69,189.47 v137.2,188.96
BMR01\  (via drill 0.61)
  Top 0.254: v111.29,266.18 112.3,267.2 117.38,267.2 118.4,268.21 126.02,268.21 127.04,267.2 130.08,267.2 131.1,268.21 134.15,268.21 v137.2,265.16 | v193.08,193.03 193.08,194.55 196.63,194.55 198.16,193.03 199.68,193.03 v200.7,192.01
  Route2 0.254: v107.22,266.69 109.26,264.66 109.76,265.16 110.27,265.16 v111.29,266.18 | v200.7,192.01 204.25,192.01 205.27,193.03 207.3,193.03 B14.E1
  Route15 0.254: v137.2,265.16 141.77,265.16 143.8,263.13 145.83,263.13 153.45,255.51 153.96,255.51 v154.98,254.5 | v154.98,228.59 158.02,231.64 159.55,230.11 160.56,230.11 162.09,228.59 162.09,227.06 v163.1,226.05 | v165.64,218.94 167.68,218.94 176.31,210.3 177.84,210.3 181.39,206.74 181.39,204.71 184.44,201.66 184.44,200.14 191.55,193.03 v193.08,193.03
  Bottom 0.254: v107.22,266.69 107.73,267.2 107.73,284.47 96.05,284.47 87.92,276.34 A23.A1 | v154.98,254.5 155.48,253.99 155.48,242.81 153.96,241.29 153.96,240.27 155.48,238.75 155.48,229.1 v154.98,228.59 | v163.1,226.05 165.64,223.51 v165.64,218.94
C00  (via drill 0.61)
  Top 0.254: v224.06,134.1 223.05,134.1 221.02,132.07 191.04,132.07 189.52,130.54 C15.E2 | B13.S1 221.02,162.04 223.05,164.07 226.6,164.07 B12.R2 | v41.69,274.31 46.26,278.88 84.87,278.88 85.38,279.39 125,279.39 126.53,280.91 142.78,280.91 143.29,281.42 145.32,281.42 145.83,280.91 172.25,280.91 172.76,280.4 198.66,280.4 199.17,280.91 224.06,280.91 v224.57,281.42 | v204.76,83.81 204.25,83.3 188.5,83.3 v187.49,84.32
  Route2 0.254: v242.35,88.89 241.84,88.89 240.32,87.36 231.68,87.36 215.94,71.62 213.4,71.62 v206.79,78.22 | v187.49,84.32 179.87,91.94 179.87,92.44 176.31,96 v177.33,97.02 | v175.3,114.8 175.8,114.8 188,126.99 v188.5,126.99
  Route15 0.254: v243.88,81.27 250.99,74.16 252.51,74.16 253.02,73.65 253.02,73.14 259.12,67.04 261.66,67.04 D10.C1 | v176.82,102.1 174.79,104.13 v174.79,107.68
  Bottom 0.254: v224.06,134.1 223.56,134.61 223.56,166.1 225.08,167.63 225.59,167.63 | 225.59,167.63 226.6,167.63 226.6,165.09 B12.R2 | 225.59,167.63 225.59,172.71 225.08,173.22 225.08,182.87 225.59,183.38 225.59,241.8 226.1,242.3 226.1,245.86 227.11,246.88 A12.L2 227.11,248.4 224.57,250.94 v224.57,281.42 | v41.69,274.31 41.69,265.67 40.17,264.15 A26.E2 | v243.88,81.27 243.37,81.78 243.37,87.36 242.35,88.38 v242.35,88.89 | v206.79,78.22 204.76,80.25 v204.76,83.81 | v177.33,97.02 177.84,97.52 177.84,101.08 v176.82,102.1 | v174.79,107.68 177.84,110.73 177.84,111.75 175.3,114.29 v175.3,114.8 | v188.5,126.99 188.5,129.53 C15.E2
C00\  (via drill 0.61)
  Top 0.254: v222.03,122.42 196.12,122.42 195.62,121.91 187.49,121.91 186.47,120.89 C15.J2 | v197.14,174.74 198.66,173.22 200.7,173.22 201.2,172.71 205.27,172.71 208.32,169.66 210.35,169.66 213.4,166.61 217.97,166.61 218.98,167.63 220,167.63 B13.P1 | v194.09,236.72 221.52,236.72 222.54,237.73 229.65,237.73 A12.P2 | v193.08,198.11 195.11,196.08 v195.62,196.08
  Bottom 0.254: v222.03,122.42 222.03,131.05 221.52,131.56 221.52,135.12 222.03,135.62 222.03,153.91 B13.U1 220.51,155.94 219.49,156.96 219.49,165.09 220.51,166.1 220.51,167.63 B13.P1 220,167.63 217.97,167.63 214.92,164.58 214.92,162.04 B13.S2 | v197.14,174.74 197.14,184.9 195.62,186.42 B15.H1 195.62,187.44 195.62,187.95 196.63,188.96 196.63,195.06 v195.62,196.08 | v194.09,236.72 194.09,219.44 194.6,218.94 194.6,209.79 193.58,208.78 193.58,198.62 v193.08,198.11
C01  (via drill 0.61)
  Top 0.254: v257.59,150.86 255.05,153.4 241.34,153.4 240.32,152.39 B11.V2 239.3,152.39 235.75,152.39 234.73,153.4 219.49,153.4 v218.98,152.9 | B13.P2 214.92,168.14 215.94,169.15 222.03,169.15 222.03,166.61 v219.49,166.61 218.98,166.1 v203.74,166.1 | v37.63,276.34 42.71,281.42 58.96,281.42 59.98,280.4 83.35,280.4 83.86,280.91 113.83,280.91 114.84,281.93 141.77,281.93 142.28,282.44 146.34,282.44 146.85,281.93 173.26,281.93 173.77,281.42 197.65,281.42 198.16,281.93 222.03,281.93 v222.54,282.44 | A12.M2 229.65,244.34 v224.06,244.34 222.54,242.81 213.4,242.81 v212.89,242.3 | v200.7,171.18 199.17,172.71 190.54,172.71 189.52,171.69 v189.01,171.69 | v184.44,195.57 184.95,195.06 197.65,195.06 v198.16,194.55 | v199.17,218.94 199.68,219.44 208.82,219.44 209.33,218.94 v211.87,218.94
  Route15 0.254: v189.01,171.69 188,171.69 v185.96,173.72
  Bottom 0.254: v257.59,150.86 257.59,156.96 257.08,157.47 257.08,163.56 257.59,164.07 257.59,167.63 260.13,170.17 260.13,178.8 258.61,180.33 258.61,183.38 B10.J1 | v219.49,166.61 218.98,166.1 v218.98,152.9 | v37.63,276.34 35.09,273.8 35.09,262.62 36.61,261.1 A26.F2 | v222.54,282.44 223.56,281.42 223.56,272.28 224.06,271.77 v224.06,244.34 | v203.74,166.1 203.24,166.61 203.24,168.64 v200.7,171.18 | v185.96,173.72 184.44,175.25 v184.44,195.57 | v198.16,194.55 199.68,194.55 199.68,218.43 v199.17,218.94 | v211.87,218.94 212.89,219.95 v212.89,242.3
C01\  (via drill 0.61)
  Top 0.254: v257.59,85.33 257.08,85.84 243.37,85.84 242.86,86.35 237.78,86.35 v237.27,85.84 | v235.75,128.51 232.7,128.51 232.19,128 227.62,128 227.11,127.5 C12.F2 226.1,127.5 222.54,131.05 222.03,131.05 221.52,131.56 206.79,131.56 v206.28,131.05 | v262.16,165.6 261.66,166.1 250.48,166.1 v249.97,165.6 | v249.97,170.17 249.46,169.66 230.67,169.66 224.57,175.76 215.94,175.76 214.92,174.74 B13.M2 | v208.82,233.67 225.59,233.67 226.6,234.68 A12.R2 | v205.78,192.01 206.28,191.5 v208.32,191.5 | v208.82,156.96 v213.9,156.96 | v215.94,164.07 215.43,164.58 211.87,164.58 B13.R2
  Bottom 0.254: v257.59,85.33 258.1,84.82 258.1,73.65 257.59,73.14 257.59,68.57 258.1,68.06 258.1,64.5 258.61,64 D10.D1 | v237.27,85.84 237.78,86.35 237.78,126.48 v235.75,128.51 | 212.89,170.68 213.9,171.69 213.9,173.72 B13.M2 | 212.89,170.68 211.87,169.66 211.87,165.09 B13.R2 | v262.16,165.6 262.16,167.63 B10.P1 | v249.97,165.6 250.48,166.1 250.48,169.66 v249.97,170.17 | v208.82,233.67 206.79,233.67 206.79,201.66 206.28,201.16 206.28,192.52 v205.78,192.01 | v208.32,191.5 209.33,190.49 209.33,188.46 212.89,184.9 212.89,170.68 | v206.28,131.05 206.28,138.16 209.33,141.21 209.33,156.45 v208.82,156.96 | v213.9,156.96 215.43,158.48 215.43,160.52 215.94,161.02 v215.94,164.07
CK00  (via drill 0.61)
  Top 0.254: v198.16,169.15 197.14,170.17 v195.62,170.17 | v183.42,178.3 182.92,178.8 168.69,178.8 168.18,178.3 165.14,178.3 164.12,179.31 v160.56,179.31 | v158.02,210.3 154.98,213.35 154.98,216.9 130.59,216.9 v128.56,218.94 | v127.04,228.59 128.56,230.11 130.08,230.11 130.59,230.62 133.64,230.62 134.15,230.11 v145.32,230.11 | v145.32,237.73 147.36,237.73 A18.P2
  Route15 0.254: v203.74,162.55 206.28,162.55 206.79,162.04 207.3,162.04 B14.S1 | v195.62,170.17 186.98,178.8 183.93,178.8 v183.42,178.3
  Bottom 0.254: v203.74,162.55 202.73,162.55 200.7,164.58 199.68,164.58 199.68,167.63 v198.16,169.15 | v160.56,179.31 159.04,179.31 159.04,209.28 v158.02,210.3 | v128.56,218.94 127.54,219.95 127.54,224.52 127.04,225.03 v127.04,228.59 | v145.32,230.11 145.83,230.62 145.83,237.22 v145.32,237.73
CK00\  (via drill 0.61)
  Top 0.254: B14.U1 207.3,155.44 206.28,156.45 200.7,156.45 199.17,157.98 B14.T2 198.16,157.98 v195.11,157.98 | v172.25,242.81 166.66,242.81 166.15,243.32 162.6,243.32 162.09,242.81 153.96,242.81 153.45,243.32 149.9,243.32 148.37,241.8 144.82,241.8 A18.N2
  Route15 0.254: v183.42,201.16 v175.3,209.28 | v183.42,170.68 183.42,169.66 v195.11,157.98
  Bottom 0.254: v172.25,242.81 171.74,242.3 171.74,211.32 172.76,210.3 173.77,210.3 174.79,209.28 v175.3,209.28 | v183.42,201.16 183.93,200.65 183.93,196.58 183.42,196.08 183.42,195.06 183.93,194.55 183.93,179.82 183.42,179.31 182.41,179.31 182.41,176.77 183.93,175.25 183.93,171.18 v183.42,170.68
CK01  (via drill 0.61)
  Top 0.254: C16.R1 179.87,102.1 181.9,104.13 182.41,104.13 C16.P1 | v171.74,132.07 v149.39,132.07 | v152.44,157.98 152.94,157.47 171.74,157.47 172.25,156.96 196.63,156.96 v198.16,155.44
  Bottom 0.254: 179.36,106.16 179.36,102.1 C16.R1 | 179.36,106.16 179.36,107.18 C16.N1 | B14.P1 207.3,167.63 206.79,167.12 206.79,157.98 203.24,154.42 203.24,152.39 199.17,152.39 B14.V2 198.16,152.39 v198.16,155.44 | 179.36,106.16 171.23,106.16 171.23,131.56 v171.74,132.07 | v149.39,132.07 149.39,141.21 150.4,142.23 150.4,149.85 152.44,151.88 v152.44,157.98
CK01\  (via drill 0.61)
  Top 0.254: C16.T2 173.26,94.48 173.26,91.94 175.8,91.94 C16.U2 | v202.73,144.26 199.17,144.26 v198.16,143.24 | v185.46,129.02 184.95,128.51 164.12,128.51 v163.61,129.02 | v162.09,99.05 164.12,97.02 170.72,97.02 171.74,98.03 175.8,98.03 C16.S2
  Route2 0.254: v198.16,143.24 186.47,131.56 v185.96,131.56
  Bottom 0.254: C16.S2 175.8,98.03 175.8,92.44 C16.U2 | v202.73,144.26 202.73,149.34 204.76,151.37 B14.V1 | v185.96,131.56 185.46,131.05 v185.46,129.02 | v163.61,129.02 162.09,127.5 v162.09,99.05
CLR_DF\  (via drill 0.61)
  Top 0.254: v208.32,57.9 207.81,58.41 197.65,58.41 v196.12,56.88 | v183.93,18.78 182.41,17.26 143.8,17.26 v142.28,18.78 | v129.07,44.18 127.54,45.71 114.34,45.71 v113.83,45.2 | v103.16,76.7 92.49,87.36 87.92,87.36 84.87,90.41 80.3,90.41 v75.73,94.98 | v73.19,143.75 73.7,144.26 v101.13,144.26 | v103.16,154.93 108.24,160.01 122.97,160.01 124.5,161.53 126.53,161.53 v128.05,160.01 | v137.7,174.23 139.74,176.26 145.32,176.26 149.9,180.84 v152.44,180.84 | v185.46,213.86 200.7,213.86 201.2,213.35 v208.32,213.35
  Route2 0.254: v208.32,57.9 v213.9,63.49 | v129.07,44.18 v137.7,35.55 | v128.05,165.6 129.07,166.61 130.59,166.61 137.7,173.72 v137.7,174.23 | v152.44,180.84 152.44,181.85 154.47,183.88 154.47,185.41 158.53,189.47 158.53,194.04 166.15,201.66 168.18,201.66 170.72,204.2 171.74,204.2 175.3,207.76 179.36,207.76 v185.46,213.86 | v208.32,213.35 209.33,213.35 213.9,217.92 215.43,217.92 222.03,224.52 222.03,227.57 223.56,229.1 225.59,229.1 226.6,230.11 229.14,230.11 233.21,226.05 233.72,226.56 235.24,226.56 235.75,227.06 247.94,227.06 248.96,226.05 A11.U1
  Route15 0.254: v239.81,40.63 228.13,52.31 225.08,52.31 v213.9,63.49
  Bottom 0.254: v239.81,40.63 239.81,38.6 D11.N2 | v196.12,56.88 194.09,54.85 194.09,30.47 186.47,22.85 183.93,22.85 v183.93,18.78 | v142.28,18.78 139.74,21.32 139.74,33.52 v137.7,35.55 | v113.83,45.2 114.34,45.71 114.34,48.76 108.24,54.85 108.24,67.04 105.19,70.09 105.19,71.11 103.16,73.14 v103.16,76.7 | v75.73,94.98 73.19,97.52 v73.19,143.75 | v101.13,144.26 101.64,144.77 101.64,152.9 103.16,154.42 v103.16,154.93 | v128.05,160.01 130.08,160.01 130.08,163.56 v128.05,165.6
CLR_DTF\  (via drill 0.61)
  Top 0.254: v222.54,20.82 237.27,20.82 237.78,21.32 241.84,21.32 242.35,21.83 D11.U2
  Route15 0.254: v221.52,88.38 221.52,90.92 221.02,91.43 C13.U1
  Bottom 0.254: v222.54,20.82 222.54,48.76 219.49,51.8 219.49,54.85 221.02,56.38 222.54,56.38 222.54,87.36 v221.52,88.38
COMP+SH  (via drill 0.61)
  Top 0.254: v211.87,263.64 210.35,265.16 v188,265.16 | v187.49,243.32 186.98,242.81 v182.92,242.81 | v172.76,209.28 v172.76,211.82 | v219.49,266.69 A12.D2
  Route2 0.254: v219.49,266.69 214.92,262.12 213.4,262.12 v211.87,263.64
  Route15 0.254: v172.76,209.28 172.76,205.73 174.28,204.2 174.28,199.63 175.8,198.11 176.82,198.11 v177.84,197.09 | v178.85,154.93 189.52,144.26 190.03,144.26 196.63,137.66 196.63,135.62 198.16,134.1 C14.D2
  Bottom 0.254: 196.12,122.42 196.12,118.35 195.62,117.84 C15.K1 | 196.12,122.42 197.14,123.43 197.14,129.02 198.66,130.54 198.66,132.58 C14.D2 198.66,134.1 199.68,135.12 199.68,139.18 204.25,139.18 C14.B1 | 196.12,122.42 202.22,122.42 203.24,123.43 207.3,123.43 C14.H1 | v188,265.16 187.49,264.66 v187.49,243.32 | v182.92,242.81 180.88,240.78 180.88,226.05 172.25,217.41 172.25,212.33 v172.76,211.82 | v177.84,197.09 177.84,195.06 180.88,192.01 180.88,168.64 177.84,165.6 177.84,155.94 v178.85,154.93
CSTA  (via drill 0.61)
  Top 0.254: v179.87,35.55 177.33,35.55 176.82,35.04 D16.P2 | v241.34,18.28 241.84,18.78 243.88,18.78 244.38,19.29 244.38,20.31 256.07,20.31 v256.58,20.82 | v268.77,25.9 269.78,26.91 274.36,26.91 275.37,25.9 276.39,25.9 279.44,28.94 282.48,28.94 283.5,29.96 286.55,29.96 287.56,28.94 288.58,28.94 289.6,29.96 292.64,29.96 v293.15,29.45 | v304.84,8.62 305.34,8.12 v311.95,8.12 | v334.81,76.19 333.79,77.2 v328.2,77.2 | v329.22,112.76 326.17,115.81 v326.17,116.32
  Route2 0.254: v293.15,29.45 293.15,27.93 297.22,23.86 298.23,23.86 v301.28,20.82 | v326.17,116.32 326.17,117.34 327.7,118.86 329.73,118.86 340.9,130.04 341.92,130.04 343.44,131.56 343.44,135.62 343.95,136.13 C04.C1
  Route15 0.254: v189.52,30.98 190.54,30.98 191.04,30.47 196.12,30.47 198.16,28.44 199.17,28.44 209.84,17.77 220.51,17.77 222.54,19.8 225.59,19.8 228.13,22.34 229.65,20.82 235.75,20.82 238.8,17.77 240.83,17.77 v241.34,18.28 | v256.58,20.82 263.69,20.82 v268.77,25.9 | v334.3,59.93 335.32,60.95 335.32,61.46 v336.84,62.98 | v328.2,77.2 328.2,82.79 321.09,89.9 320.58,89.9 320.08,90.41 320.08,91.94 317.54,94.48 317.54,96 322.62,101.08 323.63,101.08 324.14,101.59 324.14,102.6 326.68,105.14 326.68,108.7 327.7,109.72 329.22,109.72 330.74,111.24 v329.22,112.76
  Bottom 0.254: v179.87,35.55 183.93,39.61 187.49,39.61 187.49,33.01 v189.52,30.98 | v301.28,20.82 304.84,20.82 v304.84,8.62 | v311.95,8.12 323.12,8.12 323.12,5.07 323.63,4.56 334.3,4.56 334.3,16.24 333.28,17.26 333.28,58.92 v334.3,59.93 | v336.84,62.98 336.33,63.49 336.33,74.66 v334.81,76.19
CSTA\  (via drill 0.61)
  Top 0.254: v294.17,237.22 294.68,236.72 v299.76,236.72 | v322.11,140.7 322.11,138.16 328.71,138.16 329.22,137.66 329.73,137.66 v331.25,136.13 | v334.81,135.12 335.32,134.61 339.89,134.61 340.9,133.59 C04.D1
  Route2 0.254: v270.29,263.13 270.29,262.62 267.24,259.58 266.74,259.58 259.62,252.46 259.62,250.94 258.1,249.42 257.08,249.42 256.58,248.91 254.04,248.91 253.02,247.89 A10.L2
  Route15 0.254: v270.29,263.13 271.31,263.13 272.83,261.61 272.83,260.59 274.86,258.56 275.37,258.56 275.88,258.05 275.88,256.02 285.53,246.37 286.55,246.37 290.1,242.81 290.61,242.81 292.14,241.29 292.14,240.78 292.64,240.27 292.64,238.75 v294.17,237.22 | v300.77,232.14 300.77,231.64 303.82,228.59 303.82,227.06 307.88,223 307.88,221.98 v308.9,220.97 | v308.39,210.3 308.39,209.79 310.93,207.25 310.93,198.11 311.44,197.6 311.44,195.57 312.46,194.55 v312.96,194.55 | v311.95,150.36 312.96,149.34 315,149.34 319.57,144.77 319.57,143.24 v322.11,140.7 | v331.25,136.13 333.79,136.13 v334.81,135.12
  Bottom 0.254: v299.76,236.72 301.28,236.72 301.28,232.65 v300.77,232.14 | v308.9,220.97 308.9,210.81 v308.39,210.3 | v312.96,194.55 311.44,193.03 311.44,150.86 v311.95,150.36
DATA  (via drill 0.61)
  Top 0.254: v24.42,243.83 26.45,245.86 44.74,245.86 45.76,244.84 A26.M1 | v31.02,77.71 53.38,55.36 102.65,55.36 105.7,52.31 116.37,52.31 116.88,52.82 120.94,52.82 121.45,52.31 123.48,52.31 123.99,52.82 128.05,52.82 128.56,52.31 132.62,52.31 | 132.62,52.31 145.32,52.31 v147.36,50.28 | v214.41,126.48 216.95,126.48 C13.F1 | v168.18,94.48 167.68,94.98 165.64,94.98 164.12,93.46 v164.12,92.95 | v154.47,83.3 v138.72,83.3 | v132.62,54.34 132.62,52.31
  Route2 0.254: v214.41,126.48 214.41,125.97 211.87,123.43 210.35,123.43 203.24,116.32 202.22,116.32 199.68,113.78 199.68,113.27 189.52,103.11 182.92,103.11 179.87,100.06 173.77,100.06 v168.18,94.48
  Route15 0.254: v164.12,92.95 v154.47,83.3 | v138.72,83.3 136.18,83.3 133.64,80.76 v132.62,81.78
  Bottom 0.254: v24.42,243.83 24.93,243.32 24.93,242.3 25.44,241.8 25.44,239.26 24.42,238.24 24.42,236.72 25.44,235.7 25.44,154.93 28.48,151.88 28.48,144.77 28.99,144.26 28.99,99.05 31.53,96.51 31.53,78.22 v31.02,77.71 | v147.36,50.28 147.36,48.25 CD18.BK2 | v132.62,81.78 133.13,81.27 133.13,54.85 v132.62,54.34
DATA\  (via drill 0.61)
  Top 0.254: 181.39,132.07 183.93,132.07 187.49,128.51 v220.51,128.51 | 181.39,132.07 174.79,132.07 173.77,133.08 C16.D2 | C11.L2 239.3,114.8 238.29,115.81 235.24,115.81 231.68,119.37 225.59,119.37 223.05,121.91 223.05,123.43 221.02,123.43 C13.H1 | v225.59,166.61 v233.21,166.61 | v220.51,170.68 218.48,172.71 212.89,172.71 209.84,175.76 192.57,175.76 189.52,172.71 v184.95,172.71 | 181.39,132.07 v181.39,133.08
  Route15 0.254: v225.59,166.61 224.57,166.61 v220.51,170.68
  Bottom 0.254: v220.51,128.51 220.51,124.45 C13.H1 | v233.21,166.61 233.21,170.68 B12.N1 | v184.95,172.71 184.44,172.2 184.44,165.09 183.42,164.07 183.42,163.06 183.93,162.55 183.93,153.91 181.39,151.37 v181.39,133.08
DB_00\  (via drill 0.61)
  Top 0.254: v317.03,70.6 313.98,70.6 313.47,70.09 D06.B1 | v358.68,79.74 360.72,81.78 v364.78,81.78 | v372.91,163.06 371.89,164.07 371.89,169.66 371.38,169.66 369.86,171.18 369.86,172.71 368.84,172.71 365.8,175.76 364.78,175.76 364.27,176.26 362.75,176.26 362.24,175.76 362.24,173.22 v365.8,173.22 | v385.1,266.18 383.58,266.18 374.94,274.82 350.05,274.82 349.54,275.32 348.52,275.32 348.02,274.82 315,274.82 313.47,273.29 A06.B1 | v385.1,257.54 386.12,256.53 387.13,256.53 388.66,255 v388.66,251.45 | v388.15,244.84 386.12,242.81 379,242.81 377.99,241.8 377.99,234.68 v376.46,234.68 | v374.43,218.94 371.89,216.4 371.89,210.81 373.42,210.81 v374.94,209.28 | v377.99,206.24 377.99,204.71 372.4,204.71 370.88,203.19 v370.37,203.19
  Route2 0.254: v317.03,70.6 317.03,71.62 317.54,72.12 317.54,73.14 320.08,75.68 324.14,75.68 v338.87,90.41 | v356.65,127.5 355.13,129.02 355.13,130.04 358.18,133.08 358.18,134.1 364.27,140.2 364.27,141.21 366.3,143.24 366.3,149.34 374.43,157.47 374.43,161.53 v372.91,163.06 | v365.8,173.22 365.8,174.74 368.34,177.28 368.34,194.55 366.81,196.08 B02.D1 366.81,197.6 368.34,199.12 368.34,200.65 370.37,202.68 v370.37,203.19 | v376.46,234.68 376.46,234.18 374.94,232.65 374.94,219.44 v374.43,218.94 | v374.94,209.28 376.46,207.76 377.48,207.76 378.5,206.74 v377.99,206.24
  Route15 0.254: v338.87,90.41 341.92,90.41 347.51,84.82 347.51,84.32 350.56,81.27 351.57,81.27 353.1,79.74 v358.68,79.74 | v364.78,81.78 368.84,85.84 368.84,88.89 366.3,91.43 366.3,92.95 359.19,100.06 359.19,105.14 357.16,107.18 357.16,108.7 363.26,114.8 361.22,116.83 361.22,117.34 v358.18,120.38
  Bottom 0.254: v358.18,120.38 358.68,120.89 358.68,125.46 v356.65,127.5 | v385.1,257.54 v385.1,266.18 | v388.66,251.45 388.15,250.94 v388.15,244.84
DB_01\  (via drill 0.61)
  Top 0.254: v341.92,60.44 340.4,60.44 338.87,61.96 334.3,61.96 333.79,62.47 329.22,62.47 328.71,61.96 324.65,61.96 324.14,62.47 321.09,62.47 320.58,61.96 315,61.96 313.47,63.49 D06.D1 | v375.45,112.76 383.58,112.76 v384.08,113.27 | v383.07,139.69 384.59,141.21 390.18,141.21 391.7,142.74 391.7,147.82 381.54,147.82 381.04,147.31 379,147.31 v377.99,148.32 | v373.92,174.74 379,179.82 v379,180.84 | v380.53,227.06 381.04,227.57 390.69,227.57 390.69,254.5 386.62,258.56 372.4,258.56 368.84,262.12 350.05,262.12 349.54,262.62 348.52,262.62 345.98,265.16 315,265.16 313.47,266.69 A06.D1 | v375.96,222.49 374.43,220.97 368.84,220.97 v368.34,221.48 | v375.96,202.68 374.94,201.66 374.94,199.63 373.42,199.63 v372.4,198.62
  Route2 0.254: v341.92,60.44 345.48,64 345.48,65.01 352.08,71.62 352.08,75.68 357.16,80.76 357.16,83.3 361.73,87.87 361.73,93.46 375.45,107.18 v375.45,107.68 | v384.08,124.96 384.08,128.51 384.59,129.02 384.59,138.16 v383.07,139.69 | v380.53,227.06 379,227.06 377.48,225.54 377.48,224.52 375.96,223 v375.96,222.49 | v372.4,198.62 371.38,197.6 371.38,195.06 370.37,194.04 B02.E1
  Route15 0.254: v377.99,148.32 377.99,149.34 v374.94,152.39 | v379,180.84 372.91,186.93 372.4,186.93 v370.37,188.96 | v368.34,212.33 369.86,210.81 369.86,208.78 v375.96,202.68
  Bottom 0.254: v375.45,107.68 374.94,108.19 374.94,112.26 v375.45,112.76 | v384.08,124.96 v384.08,113.27 | v374.94,152.39 374.43,152.9 374.43,174.23 v373.92,174.74 | v370.37,188.96 370.37,193.03 B02.E1 | v368.34,221.48 368.84,220.97 368.84,212.84 v368.34,212.33
DB_02\  (via drill 0.61)
  Top 0.254: v323.63,61.46 323.12,61.96 321.6,61.96 321.09,61.46 317.54,61.46 316.52,60.44 D06.E1 | v321.09,234.68 321.09,236.72 v317.03,236.72 | v365.29,214.87 364.78,215.38 v347.51,215.38 | v349.03,274.31 330.74,274.31 v328.71,272.28 | v327.19,262.12 321.6,262.12 320.58,263.13 316.52,263.13 A06.E1
  Route2 0.254: v347.51,232.14 352.59,237.22 v352.59,237.73
  Route15 0.254: v323.63,61.46 325.16,61.46 328.2,64.5 326.68,66.03 326.68,74.16 334.3,81.78 333.28,82.79 333.28,83.81 v320.08,97.02 | v365.29,209.28 365.29,196.08 366.3,195.06 366.3,193.54 368.34,191.5 368.34,186.93 369.35,185.92 369.35,181.34 B02.K1
  Bottom 0.254: v320.08,97.02 320.58,97.52 320.58,166.1 318.55,168.14 318.55,169.15 319.06,169.66 319.57,169.66 320.58,170.68 320.58,171.69 318.55,173.72 318.55,174.74 320.58,176.77 320.58,203.7 318.04,206.24 318.04,218.94 320.58,221.48 320.58,226.05 321.09,226.56 v321.09,234.68 | v317.03,236.72 317.54,237.22 317.54,239.76 317.03,240.27 317.03,243.32 317.54,243.83 317.54,245.86 317.03,246.37 317.03,249.42 317.54,249.92 317.54,252.46 317.03,252.97 317.03,256.02 317.54,256.53 317.54,258.56 316.52,259.58 316.52,263.13 A06.E1 | v365.29,214.87 v365.29,209.28 | v347.51,215.38 348.02,215.89 348.02,219.44 346.49,220.97 346.49,231.13 v347.51,232.14 | v352.59,237.73 352.59,244.34 352.08,244.84 352.08,251.96 349.54,254.5 349.54,266.18 349.03,266.69 v349.03,274.31 | v328.71,272.28 327.19,270.75 v327.19,262.12
DB_03\  (via drill 0.61)