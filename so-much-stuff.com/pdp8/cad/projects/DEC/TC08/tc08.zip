# EAGLE board tc08 (EAGLE 4.11), part 7 of 10
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
MK_END\  (via drill 0.61) (continued)
  Top 0.254: v150.4,124.45 148.88,124.45 148.37,123.94 CD18.AH2 | v225.59,251.45 226.6,252.46 v231.18,252.46 | v250.48,261.61 250.48,259.58 250.99,259.58 251.5,259.07 260.13,259.07 261.15,260.08 v261.15,260.59 | v266.74,266.18 271.31,266.18 A09.D1
  Route2 0.254: v148.37,133.08 159.55,144.26 161.07,144.26 v174.79,157.98 | v171.23,177.79 171.23,178.3 181.39,188.46 181.39,189.98 193.58,202.17 193.58,207.76 196.63,210.81 196.63,213.35 188.5,221.48 192.06,225.03 192.06,225.54 192.57,226.05 193.58,226.05 203.74,236.21 207.3,236.21 207.81,236.72 210.86,236.72 v225.59,251.45 | v231.18,252.46 240.83,252.46 246.92,258.56 248.96,258.56 249.97,259.58 249.97,261.1 v250.48,261.61 | v261.15,260.59 v266.74,266.18
  Bottom 0.254: v150.4,124.45 148.88,125.97 148.88,131.05 148.37,131.56 v148.37,133.08 | v174.79,157.98 174.28,158.48 174.28,159.5 173.77,160.01 173.77,163.06 174.28,163.56 174.28,173.72 171.23,176.77 v171.23,177.79
MKT  (via drill 0.61)
  Top 0.254: v63.54,258.56 41.18,258.56 40.17,257.54 A26.H2 | v64.55,147.31 65.06,147.82 114.84,147.82 116.37,146.29 118.4,146.29 119.42,147.31 168.69,147.31 170.22,145.78 173.77,145.78 174.28,145.28 183.42,145.28 | 193.08,145.28 197.14,145.28 198.16,146.29 210.86,146.29 v211.36,145.78 | 183.42,145.28 193.08,145.28 | v183.42,119.37 183.93,119.37 183.93,117.84 184.95,116.83 185.46,116.83 185.46,114.8 C15.L2 | 183.42,145.28 v183.42,145.78 | 193.08,145.28 v193.08,145.78 | v228.64,152.39 228.64,150.36 213.4,150.36 211.87,151.88 B13.V2
  Bottom 0.254: v63.54,258.56 63.03,258.05 63.03,253.99 62.52,253.48 62.52,196.58 63.54,195.57 63.54,192.01 62.01,190.49 62.01,151.37 62.52,150.86 62.52,149.85 64.55,147.82 v64.55,147.31 | v211.36,145.78 211.36,151.37 B13.V2 | v183.42,119.37 183.93,119.88 183.93,145.28 v183.42,145.78 | v193.08,145.78 193.58,146.29 193.58,175.76 192.57,176.77 B15.L1 | v228.64,152.39 228.64,155.94 229.14,156.45 229.14,160.52 B12.S2
MKT\  (via drill 0.61)
  Top 0.254: v217.46,156.45 215.94,157.98 211.87,157.98 B13.T2 | v256.58,165.09 258.1,165.09 B10.R1 | v250.99,200.65 250.48,201.16 248.45,201.16 247.94,200.65 244.38,200.65 243.88,201.16 229.65,201.16 229.14,200.65 222.03,200.65 221.52,201.16 v219.49,201.16 | v218.48,188.46 217.97,187.95 215.43,187.95 214.92,188.46 v206.79,188.46 206.28,188.96 v155.99,188.96 | v223.05,52.82 229.65,52.82 230.16,52.31 v241.84,52.31 | v152.44,124.45 152.44,122.42 181.9,122.42 184.44,119.88 184.44,118.86 v186.47,118.86 | v186.47,106.16 186.98,106.67 200.19,106.67 201.2,107.68 204.25,107.68 C14.N1
  Route2 0.254: v247.94,51.3 248.96,51.3 249.46,51.8 251.5,51.8 252,52.31 253.53,52.31 255.05,53.84 D10.H2
  Bottom 0.254: v217.46,156.45 217.46,152.39 B13.V1 | v256.58,165.09 257.08,165.6 257.08,169.15 251.5,174.74 251.5,176.26 250.99,176.77 v250.99,200.65 | v219.49,201.16 218.98,200.65 218.98,188.96 v218.48,188.46 | v206.79,188.46 206.79,177.79 209.84,174.74 209.84,163.06 210.86,162.04 210.86,158.99 B13.T2 | v223.05,52.82 223.56,53.33 223.56,92.44 222.03,93.97 222.03,97.02 217.97,97.02 209.33,105.65 209.33,107.68 205.27,107.68 C14.N1 | v241.84,52.31 247.43,52.31 247.43,51.8 v247.94,51.3 | v155.99,188.96 155.99,152.39 154.98,151.37 154.98,145.78 152.44,143.24 v152.44,124.45 | v186.47,118.86 186.98,118.35 186.98,106.67 v186.47,106.16
MKTK  (via drill 0.61)
  Top 0.254: v57.44,247.38 62.52,252.46 66.08,252.46 v68.11,254.5 | v70.14,271.77 76.74,271.77 77.25,271.26 109.76,271.26 110.27,271.77 110.78,271.77 v111.29,272.28 | v113.83,262.12 114.84,263.13 v118.91,263.13 | v120.43,255 122.97,252.46 134.15,252.46 v134.66,252.97 | v189.01,240.78 191.55,243.32 v192.57,243.32
  Route2 0.254: v192.57,243.32 194.6,241.29 198.66,245.35 200.19,245.35 200.7,245.86 211.87,245.86 v217.46,251.45 | v273.34,240.78 v270.29,237.73
  Route15 0.254: v70.14,256.53 v68.11,254.5 | v134.66,252.97 141.26,259.58 149.39,251.45 151.42,251.45 153.45,249.42 164.12,249.42 166.15,247.38 168.18,247.38 169.71,245.86 172.76,245.86 178.85,239.76 188,239.76 v189.01,240.78 | v217.46,251.45 217.97,251.45 220,249.42 221.02,249.42 228.64,241.8 228.64,240.78 229.14,240.27 231.18,240.27 232.19,239.26 233.21,239.26 235.75,236.72 269.28,236.72 v270.29,237.73 | v273.34,240.78 275.88,240.78 280.96,235.7 A08.R2
  Bottom 0.254: v57.44,247.38 57.44,239.76 58.46,238.75 A25.P1 | v70.14,271.77 v70.14,256.53 | v111.29,272.28 114.34,272.28 114.34,262.62 v113.83,262.12 | v118.91,263.13 120.43,261.61 v120.43,255
MKTK\  (via drill 0.61)
  Top 0.254: 276.9,246.37 275.88,246.37 273.34,248.91 270.29,248.91 268.77,250.43 A09.K2 | 276.9,246.37 277.91,245.35 277.91,238.75 284.01,238.75 A08.P2 | v330.24,206.24 335.82,206.24 337.86,204.2 340.4,204.2 340.9,203.7 B04.B1 | v327.19,245.86 312.46,245.86 311.95,246.37 307.88,246.37 307.38,245.86 305.85,245.86 305.34,246.37 276.9,246.37
  Bottom 0.254: v330.24,206.24 330.74,206.74 330.74,220.97 327.19,224.52 v327.19,245.86
MOVE\  (via drill 0.61)
  Top 0.254: v290.1,71.11 v296.71,71.11 | v272.32,61.96 269.28,58.92 v265.72,58.92 | v259.62,109.72 259.62,112.26 260.64,112.26 v263.69,115.3 | v283.5,239.76 280.45,239.76 278.93,241.29 278.93,243.83 279.44,243.83 v280.96,245.35
  Route2 0.254: v299.76,67.55 298.74,68.57 298.74,69.08 v296.71,71.11 | v290.1,71.11 285.53,71.11 280.96,66.54 276.9,66.54 v272.32,61.96 | v262.67,126.99 277.91,142.23 279.94,142.23 v282.99,145.28 | v268.26,196.08 268.26,197.09 275.88,204.71 275.88,210.81 284.52,219.44 284.52,221.48 v285.02,221.98
  Route15 0.254: v282.99,145.28 282.99,147.82 279.44,151.37 279.44,175.76 278.93,176.26 278.93,178.8 267.24,190.49 267.24,192.01 266.74,192.52 266.74,194.55 v268.26,196.08 | v280.96,245.35 282.99,247.38 282.48,247.89 282.48,248.4 279.44,251.45 277.4,251.45 275.88,252.97 274.86,252.97 269.28,258.56 267.75,258.56 266.74,259.58 266.23,259.58 265.72,260.08 A09.F2
  Bottom 0.254: v299.76,67.55 299.76,64 D07.D1 | v265.72,58.92 264.2,60.44 264.2,61.96 260.64,65.52 260.64,108.7 v259.62,109.72 | v263.69,115.3 263.18,115.81 263.18,126.48 v262.67,126.99 | v285.02,221.98 285.53,222.49 285.53,234.68 282.99,237.22 282.99,239.26 v283.5,239.76
MR00  (via drill 0.61)
  Top 0.254: v204.25,218.43 203.74,217.92 197.14,217.92 195.62,219.44 181.9,219.44 v181.39,218.94 | v183.93,251.96 183.42,252.46 178.85,252.46 178.34,251.96 176.82,251.96 176.31,252.46 v149.9,252.46 | v149.39,274.31 148.88,274.82 140.75,274.82 139.23,276.34 v138.72,276.34 | v74.2,267.2 73.19,268.21 63.54,268.21 62.52,267.2 55.92,267.2 A25.D1 | v266.74,129.53 266.23,129.02 263.18,129.02 262.67,128.51 247.94,128.51 246.42,130.04 245.4,130.04 243.88,131.56 240.32,131.56 v239.81,131.05
  Route2 0.254: v267.24,133.08 286.04,151.88 286.04,152.9 293.15,160.01 297.72,160.01 298.74,161.02 298.74,166.1 B07.P2
  Route15 0.254: v204.76,186.42 204.76,187.95 203.24,189.47 203.24,194.04 v202.22,195.06 | v203.24,200.65 203.24,204.2 v204.76,205.73 | v239.81,131.05 231.68,139.18 231.68,140.7 231.18,141.21 229.14,141.21 228.13,142.23 228.13,144.26 221.02,151.37 220.51,151.37 220,151.88 220,153.4 219.49,153.91 219.49,158.48 217.97,160.01 212.89,160.01 210.35,162.55 209.33,162.55 v204.76,167.12
  Bottom 0.254: v204.76,186.42 203.24,184.9 203.24,179.82 202.22,178.8 202.22,174.74 B14.M2 202.22,173.72 202.22,171.69 203.74,170.17 203.74,168.14 v204.76,167.12 | v202.22,195.06 202.73,195.57 202.73,198.62 203.24,199.12 v203.24,200.65 | v204.76,205.73 204.25,206.24 v204.25,218.43 | v181.39,218.94 181.39,239.76 183.93,242.3 v183.93,251.96 | v149.9,252.46 149.39,252.97 v149.39,274.31 | v138.72,276.34 118.4,296.66 78.78,296.66 78.78,277.36 76.24,274.82 76.24,269.23 v74.2,267.2 | v267.24,133.08 266.74,132.58 v266.74,129.53
MR00\  (via drill 0.61)
  Top 0.254: v299.25,167.63 298.23,166.61 295.69,166.61 294.17,165.09 B07.R2 | v303.31,166.1 316.01,166.1 v316.52,165.6
  Route2 0.254: v299.25,167.63 300.77,167.63 302.8,165.6 v303.31,166.1 | v347.51,169.15 344.97,171.69 346.49,173.22 346.49,174.23 355.64,183.38 355.64,185.92 356.65,186.93 B03.H1
  Route15 0.254: v319.57,168.64 v316.52,165.6 | v324.14,185.41 326.17,185.41 330.24,181.34 330.24,180.33 337.35,173.22 343.44,173.22 v347.51,169.15
  Bottom 0.254: v319.57,168.64 321.09,170.17 321.09,173.22 320.58,173.72 320.58,175.76 321.09,176.26 321.09,182.36 v324.14,185.41
MR01  (via drill 0.61)
  Top 0.254: v5.12,239.26 6.13,239.26 25.94,259.07 44.23,259.07 50.33,265.16 57.44,265.16 58.46,264.15 A25.E1 | v5.12,18.28 17.82,5.58 110.27,5.58 112.81,8.12 119.92,8.12 121.96,6.08 193.58,6.08 194.6,7.1 199.68,7.1 200.7,6.08 234.73,6.08 235.75,7.1 240.83,7.1 241.34,6.59 249.97,6.59 251.5,5.07 285.53,5.07 286.55,6.08 v292.14,6.08 | v293.15,67.55 294.17,68.57 296.2,68.57 v299.76,72.12 | v300.26,104.13 297.22,104.13 C07.P2 | v230.67,140.2 232.7,140.2 C12.B1 | v208.32,150.86 202.22,150.86 v201.71,151.37 | v192.57,155.44 191.04,153.91 141.26,153.91 140.75,154.42 138.21,154.42 135.67,156.96 120.94,156.96 114.34,150.36 62.01,150.36 61.5,150.86 44.74,150.86 43.72,149.85 v5.12,149.85
  Route2 0.254: v296.2,64.5 v293.15,67.55
  Route15 0.254: v300.77,92.44 302.8,94.48 301.79,95.49 301.79,96 v300.77,97.02 | v230.67,140.2 228.13,140.2 227.11,141.21 226.1,141.21 220,147.31 211.87,147.31 v208.32,150.86 | v201.71,151.37 199.68,153.4 194.6,153.4 v192.57,155.44
  Bottom 0.254: v5.12,239.26 5.62,238.75 5.62,149.85 | 5.62,149.85 5.62,18.78 v5.12,18.28 | v292.14,6.08 293.66,7.61 293.66,14.21 295.69,16.24 295.69,64 v296.2,64.5 | v299.76,72.12 300.26,72.63 300.26,77.2 301.28,78.22 301.28,91.94 v300.77,92.44 | v300.77,97.02 301.28,97.52 301.28,103.11 v300.26,104.13 | 5.62,149.85 v5.12,149.85
MR01\  (via drill 0.61)
  Top 0.254: v291.12,102.1 293.15,102.1 C07.R2 | v353.6,175.76 355.64,175.76 356.65,174.74 B03.M1
  Route2 0.254: v343.95,189.98 341.92,192.01 340.9,192.01 339.89,191 339.89,186.93 338.87,185.92 337.86,185.92 336.84,184.9 336.84,183.38 336.33,182.87 334.81,182.87 326.17,174.23 324.65,174.23 323.12,172.71 319.57,172.71 315,177.28 313.98,176.26 311.44,176.26 309.92,177.79 308.9,177.79 303.82,172.71 303.31,172.71 302.8,172.2 302.8,171.18 v309.41,164.58 | v312.96,130.54 312.96,129.53 311.44,128 311.44,121.91 308.9,119.37 308.39,119.37 302.8,113.78 302.8,112.76 299.25,109.21 298.74,109.21 298.23,108.7 298.23,107.68 296.71,106.16 296.2,106.16 295.69,105.65 295.69,103.62 294.17,102.1 C07.R2
  Route15 0.254: v291.12,102.1 289.09,104.13 289.09,105.65 288.07,106.67 284.52,106.67 281.98,109.21 278.93,109.21 275.88,112.26 275.88,113.27 275.37,113.78 274.36,113.78 267.24,120.89 267.24,122.92 266.74,123.43 266.74,127.5 263.18,131.05 263.18,132.07 250.48,144.77 249.46,144.77 244.89,149.34 244.89,150.86 235.24,160.52 235.24,161.02 234.73,161.53 233.72,161.53 232.19,163.06 232.19,168.64 222.03,178.8 222.03,182.36 216.44,187.95 215.94,187.95 v207.81,196.08 | v353.6,175.76 346.49,182.87 346.49,187.44 v343.95,189.98 | v309.41,164.58 308.39,163.56 308.39,152.39 308.9,151.88 309.41,151.88 309.92,151.37 309.92,148.83 310.93,147.82 310.93,143.75 313.98,140.7 313.98,131.56 v312.96,130.54
  Bottom 0.254: v207.81,196.08 207.81,199.12 B14.C1
N$1
  Top 0.254: B08.S2 284.52,162.04 285.53,163.06 304.33,163.06 305.85,161.53 308.9,161.53 B06.S2
N$2  (via drill 0.61)
  Top 0.254: C16.L2 v168.69,114.29
  Bottom 0.254: C16.N2 173.77,108.19 175.8,110.22 175.8,110.73 C16.M2 175.8,111.75 173.77,113.78 173.77,114.29 | v168.69,114.29 169.2,114.8 169.2,132.58 166.66,132.58 166.15,133.08 166.15,134.1 165.14,135.12 165.14,138.16 164.12,139.18 C17.B1 | 173.77,114.29 173.77,114.8 175.8,116.83 C16.K2 | 173.77,114.29 C16.L2
N$3  (via drill 0.61)
  Route2 0.254: v243.37,170.68 243.37,172.71 244.38,173.72 244.38,178.8 v248.96,183.38
  Route15 0.254: v248.96,222.49 v246.42,225.03
  Bottom 0.254: v243.37,170.68 244.38,169.66 244.38,167.12 242.86,165.6 242.86,162.04 B11.S2 | v248.96,183.38 250.48,184.9 250.48,196.08 247.94,198.62 247.94,200.65 248.45,201.16 248.45,204.71 247.94,205.22 247.94,207.76 248.96,208.78 248.96,215.89 248.45,216.4 248.45,221.98 v248.96,222.49 | v246.42,225.03 244.38,227.06 244.38,229.1 245.91,230.62 245.91,234.18 A11.R1
N$4
  Bottom 0.254: D13.S2 213.9,28.94 211.87,30.98 211.87,31.48 D13.R2
N$5  (via drill 0.61)
  Top 0.254: v157.01,83.81 156.5,84.32 136.18,84.32 v135.16,85.33 | v134.66,88.38 132.62,90.41 104.68,90.41 101.64,93.46 v88.43,93.46 | v88.94,152.39 88.94,153.4 115.86,153.4 v117.89,155.44 | v139.23,217.92 v147.86,217.92 | v160.06,247.38 161.58,247.38 162.09,247.89 162.09,248.91 166.15,248.91 v166.66,248.4 | v171.74,256.53 175.8,256.53 A16.H2
  Route2 0.254: v166.66,248.4 168.18,249.92 168.18,252.97 v171.74,256.53
  Route15 0.254: v157.01,83.81 157.52,83.3 159.04,84.82 163.1,84.82 163.61,84.32 164.63,84.32 166.66,82.28 172.76,88.38 C16.V2 | v119.42,162.55 v124.5,167.63 | v128.05,196.08 v138.21,206.24 | v147.86,217.92 149.39,217.92 160.06,228.59 160.56,228.08 v161.07,228.08
  Bottom 0.254: v135.16,85.33 134.66,85.84 v134.66,88.38 | v88.43,93.46 88.94,93.97 v88.94,152.39 | v117.89,155.44 117.89,161.02 v119.42,162.55 | v124.5,167.63 123.99,168.14 123.99,184.9 126.53,187.44 126.53,189.47 127.04,189.98 127.04,195.06 v128.05,196.08 | v138.21,206.24 139.23,207.25 v139.23,217.92 | v161.07,228.08 161.58,228.59 161.58,245.86 v160.06,247.38
N$6
  Top 0.254: D12.A1 236.26,72.63 234.22,70.6 233.72,70.6 D12.B1 | D13.F2 211.87,57.39 212.89,58.41 220,58.41 220.51,58.92 224.57,58.92 227.11,61.46 229.14,61.46 231.18,63.49 D12.D1
  Bottom 0.254: D12.B1 233.72,69.58 236.26,67.04 D12.C1 236.26,66.03 233.72,66.03 233.72,64 D12.D1
N$7
  Bottom 0.254: A12.P1 236.26,238.24 233.72,240.78 A12.N1 233.21,241.8 232.19,242.81 232.19,248.91 232.7,249.42 232.7,252.97 233.21,253.48 A12.J1
N$8
  Bottom 0.254: D17.F2 157.52,57.9 159.04,59.42 159.04,61.46 166.66,69.08 168.18,69.08 168.18,88.38 165.14,91.43 165.14,96.51 164.12,97.52 164.12,101.08 C17.R1
N$10  (via drill 0.61)
  Top 0.254: v249.46,134.1 249.97,134.61 267.75,134.61 270.29,132.07 v285.02,132.07 | v280.45,180.33 278.93,178.8 268.77,178.8 262.67,172.71 250.48,172.71 249.46,171.69 247.94,171.69 246.92,172.71 242.35,172.71 240.83,174.23 237.27,174.23 B12.M1
  Bottom 0.254: v249.46,134.1 249.46,136.13 C11.C1 | v285.02,132.07 285.53,132.58 285.53,146.29 281.98,149.85 281.98,150.86 282.48,151.37 282.48,178.3 v280.45,180.33
N$11  (via drill 0.61)
  Top 0.254: v243.88,128.51 245.4,126.99 C11.F1 | v243.88,133.08 241.84,135.12 v233.72,135.12 | v230.67,138.67 228.13,141.21 225.59,141.21 v225.08,140.7 | v225.59,162.55 226.6,163.56 231.68,163.56 232.7,164.58 B12.R1
  Route2 0.254: v233.72,135.12 230.67,138.16 v230.67,138.67
  Bottom 0.254: v243.88,128.51 244.38,129.02 244.38,132.58 v243.88,133.08 | v225.08,140.7 225.59,141.21 v225.59,162.55
N$12
  Top 0.254: D17.E2 160.06,60.95 160.06,63.49 D17.D2
N$13
  Top 0.254: A14.K2 201.2,251.45 199.17,253.48 198.66,253.48 A14.J2
  Bottom 0.254: B15.F1 192.57,190.49 194.09,192.01 194.09,196.08 197.14,199.12 197.14,249.42 198.16,250.43 198.16,253.48 A14.J2 | A14.H2 201.2,256.53 201.2,251.45 A14.K2
N$14
  Bottom 0.254: A16.E2 175.8,264.15 173.77,266.18 173.77,266.69 A16.D2
N$15  (via drill 0.61)
  Top 0.254: v162.09,143.75 161.58,144.26 v158.02,144.26 | v157.01,161.53 154.47,164.07 v152.94,164.07 | v152.44,177.28 156.5,181.34 v157.01,181.34 | v157.01,205.73 154.98,207.76 151.93,207.76 v151.42,207.25 | v151.42,217.92 151.93,218.43 v157.01,218.43 | v162.09,259.07 169.2,259.07 170.22,260.08 172.76,260.08 A16.F2
  Route2 0.254: v165.64,139.69 162.09,143.24 v162.09,143.75
  Route15 0.254: v158.02,225.03 v160.06,223
  Bottom 0.254: v165.64,139.69 165.64,138.16 166.66,137.15 C17.C1 | v158.02,144.26 158.53,144.77 158.53,160.01 v157.01,161.53 | v152.94,164.07 152.44,164.58 v152.44,177.28 | v157.01,181.34 158.53,182.87 158.53,204.2 v157.01,205.73 | v151.42,207.25 151.93,207.76 151.93,217.41 v151.42,217.92 | v157.01,218.43 157.52,218.94 157.52,219.95 158.53,220.97 158.53,224.52 v158.02,225.03 | v160.06,223 162.09,225.03 v162.09,259.07
N$16  (via drill 0.61)
  Top 0.254: v168.69,265.16 186.47,265.16 187.49,266.18 191.55,266.18 A15.D1
  Bottom 0.254: v168.69,265.16 168.69,148.83 158.02,138.16 158.02,134.61 157.52,134.1 C17.D2 | A15.C1 194.6,269.74 192.57,267.7 192.57,267.2 A15.D1
N$17  (via drill 0.61)
  Top 0.254: 194.09,163.56 197.14,163.56 198.66,162.04 201.2,162.04 B14.S2 | v184.44,163.56 194.09,163.56 | 194.09,163.56 200.19,169.66 203.24,169.66 204.25,170.68 B14.N1
  Bottom 0.254: v184.44,163.56 184.44,87.87 184.95,87.36 184.95,71.62 184.44,71.11 184.44,65.01 185.46,64 D15.D2
N$18  (via drill 0.61)
  Top 0.254: v199.17,192.01 194.6,192.01 194.09,191.5 187.49,191.5 186.47,190.49 B15.F2
  Bottom 0.254: 199.17,241.29 201.2,243.32 201.2,243.83 A14.M2 | v199.17,192.01 200.19,193.03 200.19,236.72 201.2,237.73 A14.P2 201.2,238.75 201.2,239.26 199.17,241.29 | 199.17,241.29 A14.N2
N$19
  Bottom 0.254: A14.L2 199.17,247.89 202.22,247.89 202.22,248.4 207.81,253.99 207.81,256.53 A14.H1
N$20
  Bottom 0.254: A16.S2 175.8,232.14 173.77,234.18 173.77,234.68 A16.R2
N$21
  Bottom 0.254: A14.E2 201.2,264.15 199.17,266.18 199.17,266.69 A14.D2
N$22  (via drill 0.61)
  Top 0.254: v239.3,232.65 238.8,233.16 211.87,233.16 208.82,230.11 204.25,230.11 203.24,229.1 199.68,229.1 199.17,228.59 A14.T2
  Bottom 0.254: v239.3,232.65 240.32,231.64 240.32,230.11 242.86,227.57 242.86,226.05 A11.U2
N$23  (via drill 0.61)
  Top 0.254: v223.05,259.07 200.19,259.07 199.17,260.08 A14.F2 | v223.05,235.7 225.59,235.7 226.1,236.21 242.35,236.21 v242.86,235.7
  Bottom 0.254: v223.05,235.7 v223.05,259.07 | v242.86,235.7 242.86,237.73 A11.P2
N$24  (via drill 0.61)
  Top 0.254: v175.8,88.38 173.77,90.41 171.74,90.41 171.23,89.9 164.63,89.9 164.12,90.41 v142.78,90.41 | v140.75,126.48 138.72,128.51 v132.62,128.51 | v130.08,177.28 130.08,178.8 130.59,178.8 131.1,179.31 143.8,179.31 146.85,182.36 167.68,182.36 169.2,180.84 175.8,180.84 B16.K2
  Route15 0.254: v179.36,97.52 179.87,98.03 181.9,98.03 C16.S1
  Bottom 0.254: v179.36,97.52 177.84,96 177.84,90.92 175.8,88.89 v175.8,88.38 | v142.78,90.41 142.78,124.45 v140.75,126.48 | v132.62,128.51 133.13,129.02 133.13,161.53 130.08,164.58 v130.08,177.28
N$25
  Bottom 0.254: A14.V2 198.66,223 199.68,224.02 199.68,233.16 198.66,234.18 A14.R2
N$26
  Top 0.254: A14.S2 202.22,231.64 207.3,231.64 A14.S1
N$27
  Bottom 0.254: D15.S2 188.5,28.94 186.98,30.47 186.98,36.56 185.96,37.58 D15.N2
N$28  (via drill 0.61)
  Route2 0.254: v207.81,157.98 208.32,157.98 220,169.66 221.02,169.66 223.05,171.69 223.05,173.22 226.6,176.77 B12.L2
  Route15 0.254: v233.21,105.14 225.08,113.27 225.08,117.34 210.35,132.07 209.84,132.07 209.84,133.59 208.32,135.12 207.3,135.12 203.24,139.18 v203.24,140.2
  Bottom 0.254: v233.21,105.14 234.73,103.62 234.73,98.03 235.24,97.52 235.24,92.95 235.75,92.44 C12.U1 | v203.24,140.2 206.79,143.75 206.79,156.96 v207.81,157.98
N$29
  Top 0.254: B16.D2 173.77,196.08 175.8,194.04 B16.E2
N$30  (via drill 0.61)
  Top 0.254: v140.75,133.59 142.28,132.07 147.86,132.07 148.88,131.05 149.9,131.05 150.4,131.56 159.04,131.56 160.06,130.54 C17.E2 | v139.74,183.88 141.26,185.41 v172.76,185.41
  Bottom 0.254: v140.75,133.59 139.74,134.61 v139.74,183.88 | v172.76,185.41 172.76,189.47 B16.F2
N$31  (via drill 0.61)
  Top 0.254: v170.72,262.12 184.95,262.12 185.96,263.13 188.5,263.13 A15.E2
  Bottom 0.254: v170.72,262.12 169.2,260.59 169.2,148.32 158.53,137.66 158.53,128.51 157.52,127.5 C17.F2 | A15.D2 189.01,266.69 189.01,264.15 A15.E2
N$32  (via drill 0.61)
  Top 0.254: v139.74,118.35 140.24,118.86 154.98,118.86 159.04,114.8 163.1,114.8 C17.L1 | v143.29,155.94 144.31,156.96 171.23,156.96 171.74,156.45 184.95,156.45 v185.46,155.94 | v189.52,160.01 191.04,161.53 194.6,161.53 B15.S1
  Route2 0.254: v185.46,155.94 v189.52,160.01
  Bottom 0.254: v139.74,118.35 140.24,118.86 140.24,122.92 139.74,123.43 139.74,131.05 142.78,134.1 142.78,151.88 143.29,152.39 v143.29,155.94
N$33  (via drill 0.61)
  Top 0.254: v267.75,163.56 267.24,163.06 263.69,163.06 262.67,162.04 B10.S1 | v259.12,175.25 262.67,178.8 267.75,178.8 268.26,179.31 269.78,179.31 v271.31,180.84 | v266.74,196.08 268.26,197.6 270.29,197.6 270.8,198.11 275.37,198.11 v278.42,201.16 | v278.42,205.73 v282.48,205.73 | v280.96,211.32 279.94,212.33 279.94,217.41 v280.96,217.41
  Route15 0.254: v264.7,169.15 259.12,174.74 v259.12,175.25 | v271.31,180.84 v269.28,182.87
  Bottom 0.254: v267.75,163.56 267.75,166.1 v264.7,169.15 | v269.28,182.87 265.72,186.42 265.72,188.46 266.74,189.47 v266.74,196.08 | v278.42,201.16 v278.42,205.73 | v282.48,205.73 280.96,207.25 v280.96,211.32 | v280.96,217.41 284.01,220.46 284.01,225.03 A08.U2
N$34  (via drill 0.61)
  Top 0.254: v167.17,76.7 v170.22,76.7
  Bottom 0.254: v167.17,76.7 167.68,77.2 167.68,86.86 162.09,92.44 162.09,97.02 161.07,98.03 C17.S2 | v170.22,76.7 169.71,76.19 169.71,34.53 171.74,32.5 171.74,26.91 172.76,25.9 D16.T2
N$35  (via drill 0.61)
  Top 0.254: v239.81,85.33 239.3,84.82 v236.26,84.82 | v206.79,83.81 205.78,82.79 190.03,82.79 v189.52,82.28 | v245.91,276.34 247.43,274.82 270.8,274.82 v271.31,275.32
  Route2 0.254: v256.07,96.51 246.92,87.36 243.37,87.36 242.35,86.35 240.83,86.35 v239.81,85.33 | v164.12,162.55 164.12,163.56 168.18,167.63 168.18,170.17 v192.06,194.04 | v210.86,238.75 222.03,249.92 222.03,251.96 v226.6,256.53 | v273.34,273.29 275.88,270.75 275.88,267.2 273.34,264.66 273.34,262.62 271.82,261.1 A09.F1
  Route15 0.254: v236.26,84.82 234.22,84.82 233.72,85.33 229.14,85.33 227.62,86.86 221.52,86.86 217.97,90.41 214.92,90.41 211.36,86.86 209.84,86.86 v206.79,83.81 | v189.52,88.89 189.52,89.4 187.49,91.43 187.49,99.56 195.11,107.18 185.46,116.83 184.95,116.83 184.44,117.34 184.44,125.97 174.79,135.62 174.79,142.23 v165.64,151.37 | v192.06,194.04 197.65,199.63 v189.52,207.76 | v188.5,223 191.04,225.54 192.57,224.02 193.58,224.02 194.09,224.52 194.09,226.56 208.32,240.78 210.35,238.75 v210.86,238.75 | v233.72,285.48 234.22,285.48 238.8,280.91 241.34,280.91 v245.91,276.34
  Bottom 0.254: v256.07,96.51 257.08,97.52 257.08,99.05 255.56,100.57 255.56,104.13 C10.P2 | v189.52,88.89 v189.52,82.28 | v165.64,151.37 165.14,151.88 165.14,161.53 v164.12,162.55 | v189.52,207.76 188.5,208.78 v188.5,223 | v226.6,256.53 227.62,257.54 227.62,258.56 228.64,259.58 228.64,280.4 v233.72,285.48 | v271.31,275.32 273.34,275.32 v273.34,273.29
N$36  (via drill 0.61)
  Top 0.254: v208.82,133.08 210.86,133.08 C13.D2
  Bottom 0.254: v208.82,133.08 209.33,132.58 209.33,129.02 209.84,128.51 209.84,122.42 209.33,121.91 209.33,114.8 203.24,108.7 203.24,107.18 205.27,105.14 207.3,105.14 C14.P1
N$37
  Top 0.254: B16.R2 173.26,164.07 175.3,162.04 175.8,162.04 B16.S2
N$38
  Bottom 0.254: C15.H1 195.62,124.45 196.63,125.46 196.63,131.05 195.11,132.58 195.11,136.13 C15.C1
N$39
  Bottom 0.254: C15.J1 192.06,121.4 192.06,126.48 C15.F1
N$40
  Bottom 0.254: D14.V2 199.17,19.8 200.7,21.32 200.7,39.61 201.71,40.63 D14.M2
N$41
  Bottom 0.254: D14.V1 205.27,19.8 206.79,21.32 206.79,23.86 207.3,24.37 207.3,27.42 206.79,27.93 206.79,29.96 207.81,30.98 207.81,34.53 D14.P1
N$42
  Top 0.254: C11.L1 246.42,114.8 248.45,116.83 248.96,116.83 C11.K1
N$43
  Bottom 0.254: A12.T2 227.62,229.1 228.64,230.11 228.64,236.72 227.62,237.73 227.62,240.78 A12.N2
N$44  (via drill 0.61)
  Top 0.254: v246.42,104.64 247.43,103.62 247.94,103.62 248.45,103.11 v256.58,103.11 | v256.07,115.81 253.53,115.81 v253.02,116.32 | v252.51,118.35 252,118.86 239.81,118.86 v239.3,118.35
  Route15 0.254: v239.3,118.35 239.3,118.86 231.68,126.48 231.68,132.07 228.13,135.62 228.13,137.66 v229.14,138.67
  Bottom 0.254: v246.42,104.64 246.42,107.18 C11.N1 | v256.58,103.11 257.08,103.62 257.08,114.8 v256.07,115.81 | v253.02,116.32 252.51,116.83 v252.51,118.35 | v229.14,138.67 228.64,139.18 228.64,141.72 228.13,142.23 228.13,150.36 229.65,151.88 229.65,154.93 B12.U2
N$45
  Bottom 0.254: A12.U2 230.16,226.05 230.16,231.13 A12.S2
N$46
  Top 0.254: A10.K1 262.67,250.94 264.2,252.46 267.24,252.46 268.77,253.99 A09.J1
N$47  (via drill 0.61)
  Top 0.254: v205.78,187.44 205.27,187.95 v203.24,187.95 | v204.25,193.54 205.78,195.06 212.89,195.06 215.94,198.11 217.97,198.11 218.98,197.09 225.59,197.09 226.6,198.11 v227.62,198.11 | v235.24,218.94 236.26,217.92 v240.83,217.92 | v241.34,192.52 243.88,189.98 v244.38,189.98
  Route15 0.254: v214.92,145.78 220.51,140.2 220.51,137.15 C13.C1 | v214.41,152.9 v205.78,161.53
  Bottom 0.254: v214.92,145.78 214.41,146.29 v214.41,152.9 | v205.78,161.53 206.28,162.04 206.28,168.64 206.79,169.15 206.79,176.77 206.28,177.28 206.28,186.93 v205.78,187.44 | v203.24,187.95 203.24,191.5 204.25,192.52 v204.25,193.54 | v227.62,198.11 228.13,198.62 228.13,201.66 228.64,202.17 228.64,204.2 226.1,206.74 226.1,216.9 229.14,219.95 235.24,219.95 v235.24,218.94 | v240.83,217.92 240.32,217.41 240.32,204.71 241.34,203.7 v241.34,192.52 | v244.38,189.98 243.37,188.96 243.37,187.44 B11.H2
N$48  (via drill 0.61)
  Top 0.254: v255.05,107.18 254.54,106.67 251.5,106.67 249.97,105.14 C11.P1 | v258.61,110.73 258.61,112.76 259.62,112.76 260.64,113.78 260.64,119.37 v261.66,119.37 | v245.91,149.85 244.89,150.86 v240.83,150.86
  Route2 0.254: v255.05,107.18 v258.61,110.73
  Route15 0.254: v261.66,121.91 254.04,129.53 254.04,134.1 248.96,139.18 248.96,140.2 v245.4,143.75
  Bottom 0.254: v261.66,119.37 v261.66,121.91 | v245.4,143.75 245.91,144.26 v245.91,149.85 | v240.83,150.86 241.34,151.37 241.34,153.4 240.32,154.42 240.32,155.44 238.8,156.96 237.78,156.96 237.27,156.45 235.75,156.45 235.75,160.52 236.26,161.02 B12.S1
N$49  (via drill 0.61)
  Top 0.254: v232.19,191.5 232.7,192.01 239.3,192.01 240.83,193.54 242.35,193.54 B11.E2
  Bottom 0.254: v232.19,191.5 232.19,178.3 232.7,177.79 B12.L1
N$50  (via drill 0.61)
  Top 0.254: v222.54,91.43 223.05,91.94 v225.59,91.94 | v227.11,99.05 227.62,98.54 229.14,98.54 C12.S2
  Bottom 0.254: v222.54,91.43 220.51,89.4 220.51,87.36 208.82,87.36 207.81,88.38 207.81,88.89 203.24,93.46 203.24,99.05 198.66,103.62 198.66,104.13 195.62,104.13 C15.P1 | v225.59,91.94 225.08,92.44 225.08,97.02 v227.11,99.05
N$51  (via drill 0.61)
  Top 0.254: v230.16,126.99 C12.F1
  Bottom 0.254: v230.16,126.99 228.64,128.51 228.64,135.12 228.13,135.62 228.13,141.21 227.11,142.23 227.11,151.37 B12.V2
N$52  (via drill 0.61)
  Top 0.254: v243.88,100.06 245.4,98.54 248.96,98.54 C11.S1 | v244.38,113.78 244.38,117.34 v244.89,117.34 | v244.89,123.94 243.37,125.46 241.84,125.46 v241.34,125.97 | v242.35,128.51 241.34,129.53 236.76,129.53 C12.E1
  Bottom 0.254: v243.88,100.06 244.38,100.57 244.38,105.65 243.88,106.16 243.88,109.72 244.38,110.22 v244.38,113.78 | v244.89,117.34 v244.89,123.94 | v241.34,125.97 242.35,126.99 v242.35,128.51
N$53
  Bottom 0.254: C15.R1 192.06,102.1 192.06,107.18 C15.N1
N$54  (via drill 0.61)
  Top 0.254: v236.26,126.48 239.3,126.48 C11.F2
  Bottom 0.254: C12.H1 v236.26,126.48
N$55
  Top 0.254: B12.E1 236.76,194.04 238.8,196.08 239.3,196.08 B11.D2
N$56
  Bottom 0.254: B11.F2 240.32,190.49 242.86,190.49 242.86,191.5 243.37,192.01 244.38,192.01 244.38,195.06 245.4,196.08 B11.D1
N$58  (via drill 0.61)
  Top 0.254: v269.28,153.4 268.26,152.39 268.26,150.86 268.77,150.36 278.93,150.36 280.45,151.88 B08.V2 | v268.26,160.01 267.75,160.01 266.74,161.02 263.69,161.02 262.67,160.01 261.15,160.01 v258.61,162.55 | v257.08,189.47 v254.04,192.52 | v250.48,221.98 249.97,221.48 246.42,221.48 A11.V1
  Route15 0.254: v258.61,162.55 257.59,163.56 257.59,168.64 256.07,170.17 256.07,172.71 257.59,174.23 257.59,182.87 v257.08,183.38 | v254.04,192.52 254.04,195.57 v254.54,196.08
  Bottom 0.254: v269.28,153.4 269.78,153.91 269.78,156.45 268.26,157.98 v268.26,160.01 | v257.08,183.38 v257.08,189.47 | v254.54,196.08 254.04,196.58 254.04,198.11 252,200.14 252,201.16 250.99,202.17 250.99,210.3 251.5,210.81 251.5,220.97 v250.48,221.98
N$59  (via drill 0.61)
  Top 0.254: v215.94,97.02 222.03,97.02 223.05,98.03 228.13,98.03 229.14,97.02 v233.72,97.02 | v234.73,89.4 239.3,89.4 C11.V2
  Bottom 0.254: v215.94,97.02 215.94,90.41 216.95,89.4 C13.V1 | v233.72,97.02 234.73,96 v234.73,89.4
N$60  (via drill 0.61)
  Route2 0.254: v234.73,120.38 234.73,121.4 233.21,122.92 232.19,122.92 231.18,123.94 231.18,132.07 226.1,137.15 228.13,139.18 228.13,150.36 231.68,153.91 231.68,159.5 v232.7,160.52
  Route15 0.254: v232.7,175.25 v230.67,177.28
  Bottom 0.254: v234.73,120.38 234.73,113.78 234.22,113.27 234.22,109.72 233.21,108.7 C12.N1 | v232.7,160.52 232.19,161.02 232.19,174.74 v232.7,175.25 | v230.67,177.28 230.67,180.33 B12.K2
N$61  (via drill 0.61)
  Top 0.254: v225.59,64.5 225.08,64 218.98,64 217.97,65.01 v216.44,65.01 | v215.94,54.34 215.94,52.82 214.92,52.82 214.41,52.31 146.34,52.31 145.83,52.82 144.82,52.82 142.28,55.36 117.38,55.36 116.88,54.85 114.84,54.85 113.83,55.87 v107.22,55.87 | v104.68,159.5 105.19,160.01 107.22,160.01 110.27,163.06 118.4,163.06 118.91,163.56 131.1,163.56 134.15,160.52 v174.79,160.52 | v175.3,184.9 175.8,185.41 196.63,185.41 198.16,186.93 v199.17,186.93 | v202.22,189.98 206.79,194.55 210.86,194.55 v211.36,194.04 | v227.11,175.25 227.62,174.74 229.65,174.74 B12.M2
  Route2 0.254: v225.59,84.32 226.1,84.82 228.13,84.82 231.68,88.38 232.7,88.38 C12.V1 | v199.17,186.93 v202.22,189.98
  Route15 0.254: v216.44,188.96 222.54,182.87 222.54,179.82 v227.11,175.25
  Bottom 0.254: v225.59,84.32 225.08,83.81 225.08,65.01 v225.59,64.5 | v216.44,65.01 215.94,64.5 v215.94,54.34 | v107.22,55.87 104.68,58.41 104.68,70.6 102.14,73.14 102.14,85.84 104.68,88.38 v104.68,159.5 | v174.79,160.52 174.79,184.39 v175.3,184.9 | v211.36,194.04 v216.44,188.96
N$62
  Bottom 0.254: B12.N2 226.6,171.69 226.1,172.2 226.1,176.26 225.59,176.77 225.59,182.36 B12.J2
N$63  (via drill 0.61)
  Top 0.254: v207.81,178.3 206.79,179.31 196.63,179.31 B15.K1
  Bottom 0.254: v207.81,178.3 210.86,175.25 210.86,171.69 B13.N2
N$64  (via drill 0.61)
  Top 0.254: v261.66,196.58 259.12,196.58 B10.D1 | v227.62,250.94 229.65,250.94 A12.K2 | v225.59,287.52 237.27,287.52 237.78,287.01 239.3,287.01 239.81,286.5 287.56,286.5 288.07,287.01 v295.18,287.01 | v294.17,204.71 270.29,204.71 266.23,200.65 263.18,200.65 262.67,200.14 B10.C1
  Bottom 0.254: v261.66,196.58 261.66,199.12 B10.C1 | v227.62,250.94 225.08,253.48 225.08,280.4 225.59,280.91 v225.59,287.52 | v295.18,287.01 295.18,264.15 295.69,263.64 295.69,216.9 296.2,216.4 296.2,209.79 294.17,207.76 v294.17,204.71
N$65
  Route2 0.254: C11.T2 240.32,95.49 240.32,96 242.35,98.03 C11.S2
N$66  (via drill 0.61)
  Top 0.254: B10.B1 B10.A1 262.67,205.73 265.21,205.73 266.23,204.71 269.28,204.71 269.78,205.22 270.8,205.22 v271.31,205.73 | v226.6,288.53 227.62,289.55 235.24,289.55 236.26,288.53 238.29,288.53 238.8,288.02 240.32,288.02 240.83,287.52 286.55,287.52 287.06,288.02 290.61,288.02 291.63,289.04 v311.44,289.04 | v311.95,206.24 311.95,204.2 310.42,204.2 309.41,203.19 308.9,203.19 307.38,201.66 292.64,201.66 290.1,204.2 273.85,204.2 v273.34,203.7
  Bottom 0.254: v226.6,288.53 226.6,280.91 225.59,279.9 225.59,262.62 227.11,261.1 A12.F2 | v311.44,289.04 311.44,206.74 v311.95,206.24 | v273.34,203.7 v271.31,205.73
N$67  (via drill 0.61)
  Top 0.254: v254.04,29.45 253.53,29.96 219.49,29.96 218.98,30.47 204.25,30.47 v203.24,31.48
  Bottom 0.254: v254.04,29.45 254.04,33.52 255.05,34.53 D10.P2 | v203.24,31.48 203.74,31.99 203.74,41.64 199.17,46.22 199.17,50.28 D14.J2
N$68
  Bottom 0.254: D14.H1 207.81,54.34 203.24,54.34 203.24,55.36 198.66,59.93 198.66,62.98 D14.D2
N$69
  Bottom 0.254: D14.C1 207.81,67.04 207.81,72.63 D14.A1
N$70
  Bottom 0.254: B11.U1 248.96,155.94 247.94,156.96 247.94,192.01 B11.E1
N$71  (via drill 0.61)
  Top 0.254: v142.28,128.51 162.09,128.51 163.1,127.5 C17.F1 | v146.34,175.76 146.85,176.26 186.98,176.26 186.98,177.28 v190.03,177.28
  Bottom 0.254: v142.28,128.51 143.29,129.53 143.29,147.31 146.34,150.36 v146.34,175.76 | v190.03,177.28 191.55,175.76 191.55,171.69 B15.N1
N$72  (via drill 0.61)
  Top 0.254: v245.4,186.93 248.96,186.93 B11.H1
  Bottom 0.254: v245.4,186.93 243.88,185.41 243.88,184.39 244.38,183.88 244.38,176.77 245.4,175.76 245.4,172.2 245.91,171.69 B11.N1
N$73
  Top 0.254: B09.N2 266.74,172.71 282.48,172.71 283.5,171.69 287.06,171.69 B08.N1
N$76  (via drill 0.61)
  Top 0.254: v201.71,103.11 199.68,103.11 199.68,99.56 198.66,98.54 197.65,98.54 196.12,97.02 190.54,97.02 189.52,98.03 C15.S2
  Bottom 0.254: v201.71,103.11 201.2,103.11 199.68,104.64 199.68,112.76 198.66,113.78 C14.L2
N$77  (via drill 0.61)
  Top 0.254: v258.1,185.41 247.43,185.41 246.42,184.39 B11.J1
  Bottom 0.254: v258.1,185.41 258.61,185.92 258.61,189.47 B10.F1
N$78  (via drill 0.61)
  Top 0.254: v173.26,124.45 167.17,124.45 C17.H1 | v236.26,184.9 236.76,185.41 241.34,185.41 v243.37,183.38
  Route2 0.254: v173.26,124.45 174.28,124.45 194.09,144.26 196.12,144.26 202.73,150.86 202.73,153.91 206.28,157.47 206.28,160.52 206.79,161.02 206.79,162.55 207.3,163.06 211.87,163.06 215.94,167.12 215.94,169.66 v214.92,170.68 | v216.44,178.8 220,182.36 221.52,182.36 224.06,184.9 225.59,184.9 v231.18,190.49 | v243.37,183.38 245.4,181.34 246.42,182.36 246.92,182.36 247.94,183.38 247.94,183.88 248.45,184.39 249.97,184.39 253.53,180.84 254.54,181.85 261.15,181.85 261.66,181.34 B10.K1
  Route15 0.254: v231.18,190.49 231.18,189.98 232.7,188.46 233.72,188.46 234.73,187.44 234.73,186.42 v236.26,184.9
  Bottom 0.254: v214.92,170.68 214.92,172.71 215.94,173.72 215.94,178.3 v216.44,178.8
N$79
  Top 0.254: C14.N2 199.17,108.19 200.19,109.21 210.35,109.21 210.86,108.7 C13.N2
N$81  (via drill 0.61)
  Top 0.254: v218.48,135.12 228.64,135.12 230.16,133.59 232.7,133.59 C12.D1
  Bottom 0.254: v218.48,135.12 218.98,134.61 218.98,118.86 215.94,115.81 215.94,113.27 214.41,111.75 C13.M2
N$82  (via drill 0.61)
  Top 0.254: v163.61,118.35 164.12,118.86 171.74,118.86 v172.25,118.35 | v199.68,163.06 200.19,163.56 207.81,163.56 v208.82,164.58 | v239.3,154.93 240.83,156.45 244.38,156.45 v245.91,154.93
  Route2 0.254: v173.77,130.04 188,144.26 189.52,144.26 196.12,150.86 196.12,151.88 v199.68,155.44
  Route15 0.254: v208.82,164.58 211.36,167.12 215.43,163.06 216.95,163.06 220,160.01 223.05,160.01 229.14,153.91 234.22,153.91 235.75,152.39 236.76,152.39 v239.3,154.93
  Bottom 0.254: v163.61,118.35 163.61,119.88 C17.J1 | v172.25,118.35 171.74,118.86 171.74,128 v173.77,130.04 | v199.68,155.44 v199.68,163.06 | v245.91,154.93 245.91,152.39 B11.V1
N$83  (via drill 0.61)
  Top 0.254: v276.39,263.13 283.5,263.13 A08.E2
  Bottom 0.254: v276.39,263.13 276.9,262.62 276.9,248.4 271.82,248.4 A09.L1
N$84
  Top 0.254: A10.D1 259.12,267.2 261.15,269.23 261.66,269.23 A10.C1
N$85  (via drill 0.61)
  Top 0.254: v217.46,226.05 218.98,224.52 219.49,224.52 220,224.02 221.52,224.02 v223.56,226.05 | v226.6,269.74 v223.05,269.74
  Route2 0.254: v196.12,177.28 189.01,170.17 189.01,168.64 B15.P2 | v195.11,191 196.63,192.52 196.63,195.06 197.14,195.57 197.14,198.11 199.68,200.65 199.68,201.66 203.24,205.22 203.24,207.76 206.28,210.81 206.28,212.84 207.81,214.36 209.33,214.36 213.4,218.43 213.4,219.95 v215.43,221.98 | v254.04,270.75 254.54,270.75 255.05,271.26 256.58,271.26 258.1,272.78 A10.B1
  Route15 0.254: v226.6,269.74 228.13,269.74 231.18,272.78 232.19,271.77 247.43,271.77 v251.5,275.83
  Bottom 0.254: v196.12,177.28 196.63,177.79 196.63,183.38 194.09,185.92 194.09,189.98 v195.11,191 | v215.43,221.98 215.94,222.49 215.94,224.52 v217.46,226.05 | v223.56,226.05 223.05,226.56 223.05,234.18 222.03,235.19 222.03,236.21 222.54,236.72 222.54,258.05 222.03,258.56 222.03,264.66 223.05,265.67 v223.05,269.74 | v251.5,275.83 252.51,274.82 256.58,274.82 256.58,273.29 v254.04,270.75 | A10.F1 258.61,261.1 257.59,262.12 257.59,267.7 258.61,268.72 258.61,272.28 A10.B1
N$86  (via drill 0.61)
  Top 0.254: v189.01,178.3 188,179.31 v167.68,179.31 | v167.68,221.48 168.18,220.97 207.3,220.97 208.32,221.98 209.33,221.98 209.84,221.48 209.84,220.97 213.9,220.97 214.41,220.46 236.26,220.46 v236.76,220.97 | v236.76,218.94 v257.59,218.94 | v254.04,176.26 249.46,176.26 246.92,178.8 243.37,178.8 241.84,177.28 240.32,177.28 B11.L2
  Bottom 0.254: v189.01,178.3 189.01,176.77 190.54,175.25 190.54,167.12 189.52,166.1 189.52,162.04 B15.S2 | v167.68,179.31 168.18,179.82 168.18,220.97 v167.68,221.48 | v236.76,220.97 v236.76,218.94 | v257.59,218.94 257.59,191.5 254.04,187.95 v254.04,176.26
N$88
  Bottom 0.254: D17.R2 157.52,30.98 160.06,28.44 D17.S2
N$91
  Top 0.254: B09.R1 271.82,164.07 272.83,163.06 278.93,163.06 280.96,161.02 282.48,161.02 283.5,160.01 286.04,160.01 287.56,161.53 290.1,161.53 B08.S1
N$92  (via drill 0.61)
  Top 0.254: v266.74,174.23 266.74,174.74 267.75,175.76 282.48,175.76 282.99,176.26 v290.1,176.26
  Bottom 0.254: v266.74,174.23 266.74,184.39 265.21,185.92 265.21,189.47 B09.F2 | v290.1,176.26 290.1,180.33 B08.K1
N$93  (via drill 0.61)
  Top 0.254: D09.E1 275.37,60.44 275.88,60.95 280.45,60.95 282.99,63.49 D08.D1 v290.1,63.49
  Bottom 0.254: v290.1,63.49 290.1,66.03 D08.C1
N$94
  Top 0.254: D09.J2 265.72,50.28 266.74,49.26 272.83,49.26 274.86,51.3 277.4,51.3 279.44,53.33 279.44,56.88 280.45,56.88 D08.F2
  Bottom 0.254: D08.E2 283.5,59.93 281.47,57.9 281.47,57.39 D08.F2
N$95
  Top 0.254: D09.L1 271.82,45.2 279.44,45.2 280.45,46.22 286.04,46.22 287.06,47.23 290.1,47.23 D08.K1 290.1,48.25 289.6,48.25 287.56,50.28 D08.J1
N$96
  Top 0.254: D09.S1 275.37,28.94 275.88,29.45 281.98,29.45 283.5,30.98 287.06,30.98 D08.R1 287.56,32.5 288.07,32.5 290.1,34.53 D08.P1
N$97
  Top 0.254: B09.D1 271.82,197.09 272.32,197.6 279.94,197.6 280.45,198.11 285.02,198.11 286.55,199.63 290.1,199.63 B08.C1
N$99  (via drill 0.61)
  Top 0.254: v283.5,19.8 282.99,20.31 266.74,20.31 265.72,19.29 D09.V2
  Bottom 0.254: v283.5,19.8 283.5,21.83 D08.U2 283.5,22.34 283.5,22.85 281.47,24.88 D08.T2
N$100
  Top 0.254: D09.P2 268.77,35.55 269.28,36.06 273.34,36.06 274.86,37.58 280.45,37.58 D08.N2 281.47,38.6 281.98,38.6 284.01,40.63 D08.M2
N$101  (via drill 0.61)
  Top 0.254: 168.69,68.06 v168.18,67.55 166.15,69.58 166.15,71.11 193.08,71.11 193.58,70.6 v195.62,70.6 | v279.94,67.55 279.44,68.06 v198.66,68.06
  Route2 0.254: v195.62,70.6 198.16,68.06 v198.66,68.06
  Bottom 0.254: v168.18,67.55 168.69,68.06 168.69,89.9 167.17,91.43 C17.U1 | v279.94,67.55 280.45,67.04 280.45,64 D08.D2 280.45,62.98 279.44,61.96 279.44,46.72 280.96,45.2 D08.L2 280.96,43.68 280.96,42.15 282.48,40.63 282.48,29.96 283.5,28.94 D08.S2
N$103  (via drill 0.61)
  Top 0.254: D08.B1 287.06,69.08 286.55,68.57 201.71,68.57 v201.2,69.08 | v165.14,69.08 164.63,68.57 v155.99,68.57
  Route15 0.254: v201.2,69.08 195.11,62.98 193.08,65.01 187.49,65.01 186.98,65.52 185.96,65.52 183.42,68.06 172.25,68.06 171.23,69.08 v165.14,69.08
  Bottom 0.254: 288.58,52.82 288.58,39.61 287.56,38.6 D08.N1 | 288.58,52.82 290.1,54.34 D08.H1 | 288.58,52.82 288.58,68.06 287.56,69.08 D08.B1 | v155.99,68.57 155.99,102.6 157.01,103.62 157.01,107.18 C17.N2
N$104
  Top 0.254: C09.N2 265.72,108.19 266.74,109.21 274.86,109.21 275.88,110.22 275.88,115.3 280.45,119.88 280.96,119.88 C08.J2
N$105  (via drill 0.61)
  Top 0.254: v250.99,263.13 252,262.12 273.34,262.12 274.36,263.13 A09.E1
  Bottom 0.254: v250.99,263.13 250.99,274.82 249.97,275.83 A11.A1
N$106  (via drill 0.61)
  Top 0.254: v247.94,273.8 246.42,273.8 A11.B1 | v262.16,273.8 262.67,274.31 266.23,274.31 v266.74,273.8
  Route2 0.254: v247.94,273.8 250.48,273.8 251.5,274.82 261.15,274.82 v262.16,273.8
  Bottom 0.254: v266.74,273.8 266.74,269.23 267.75,268.21 267.75,265.16 266.74,264.15 266.74,262.12 267.75,261.1 267.75,257.54 A09.H2
N$107  (via drill 0.61)
  Top 0.254: v279.44,253.99 273.85,253.99 272.32,255.51 270.8,255.51 270.29,255 266.23,255 265.72,254.5 A09.J2
  Bottom 0.254: v279.44,253.99 279.44,252.46 283.5,248.4 283.5,244.84 A08.M2
N$108  (via drill 0.61)
  Top 0.254: v160.56,108.19 162.09,106.67 167.68,106.67 v168.69,107.68 | v174.28,99.05 v168.69,99.05 | v174.79,94.48 175.3,93.97 178.34,93.97 179.87,92.44 v180.88,92.44 | v183.42,77.71 196.63,77.71 198.16,76.19 v212.89,76.19
  Route2 0.254: v215.94,70.09 215.94,70.6 230.16,84.82 234.73,84.82 236.76,86.86 241.84,86.86 250.99,96 250.99,118.35 252.51,119.88 C10.J2
  Bottom 0.254: v160.56,108.19 160.56,110.73 C17.M2 | v168.69,107.68 169.2,107.18 169.2,99.56 v168.69,99.05 | v174.28,99.05 174.79,98.54 v174.79,94.48 | v180.88,92.44 181.39,91.94 181.39,90.41 183.42,88.38 v183.42,77.71 | v212.89,76.19 214.41,74.66 215.94,74.66 v215.94,70.09
N$109
  Top 0.254: C17.V1 170.72,88.89 172.25,87.36 250.99,87.36 252,88.38 C10.V2
N$111  (via drill 0.61)
  Top 0.254: v153.45,103.11 153.96,102.6 155.48,102.6 156.5,101.59 C17.R2 | v256.58,221.98 256.58,223.51 267.24,223.51 v267.75,223
  Route2 0.254: v153.45,103.11 151.93,104.64 155.48,108.19 155.48,108.7 166.15,119.37 166.66,119.37 167.17,119.88 167.17,121.91 168.18,122.92 168.18,125.97 196.63,154.42 196.63,155.44 197.65,156.45 199.17,156.45 217.46,174.74 218.98,174.74 220,175.76 221.02,175.76 233.72,188.46 234.22,188.46 234.73,188.96 234.73,194.04 248.96,208.27 248.96,212.84 250.99,214.87 250.99,215.89 256.58,221.48 v256.58,221.98
  Bottom 0.254: v267.75,223 267.75,225.03 A09.U2
N$112  (via drill 0.61)
  Top 0.254: v275.88,151.88 273.34,154.42 269.28,154.42 268.77,154.93 B09.U2 | v275.88,185.92 277.4,187.44 282.48,187.44 282.99,187.95 282.99,189.98 287.06,189.98 B08.F1
  Bottom 0.254: v275.88,151.88 276.39,152.39 276.39,185.41 v275.88,185.92
N$113  (via drill 0.61)
  Top 0.254: v281.98,181.34 275.88,181.34 275.37,180.84 B09.K1
  Bottom 0.254: v281.98,181.34 282.48,181.85 282.48,186.42 280.96,187.95 280.96,189.47 B08.F2
N$114  (via drill 0.61)
  Route15 0.254: v258.61,233.16 258.1,233.67 251.5,233.67 249.46,235.7 247.43,233.67 246.42,233.67 244.89,232.14 243.37,232.14 A11.S2
  Bottom 0.254: v258.61,233.16 260.64,231.13 260.64,230.11 263.69,227.06 263.69,224.52 265.21,223 A09.V2
N$115
  Top 0.254: C17.P2 161.07,105.14 162.09,106.16 174.28,106.16 174.79,106.67 181.9,106.67 182.92,107.68 185.46,107.68 C15.N2
N$116  (via drill 0.61)
  Top 0.254: v200.19,121.4 199.68,121.91 196.63,121.91 192.57,117.84 189.52,117.84 C15.K2
  Bottom 0.254: v200.19,121.4 200.19,109.72 202.73,107.18 202.73,106.67 210.35,99.05 213.9,99.05 C13.S2
N$117
  Bottom 0.254: 228.64,39.61 229.65,40.63 229.65,41.14 D12.M2 | 228.64,39.61 227.62,38.6 D12.N2 | 228.64,39.61 228.64,64 225.59,67.04 225.59,82.79 228.13,85.33 228.13,114.8 227.62,115.3 227.62,117.34 230.16,119.88 230.16,123.43 C12.H2
N$118  (via drill 0.61)
  Top 0.254: D12.L2 227.11,45.2 229.14,47.23 229.65,47.23 D12.K2
  Route2 0.254: v253.02,76.7 253.02,75.68 250.99,73.65 250.99,64.5 241.34,54.85 239.81,54.85 234.22,49.26 231.68,49.26 230.67,48.25 D12.K2
  Route15 0.254: v242.86,115.3 242.86,113.27 244.89,111.24 245.91,111.24 247.43,109.72 247.43,97.52 250.48,94.48 250.48,93.97 255.05,89.4 255.05,86.35 257.08,84.32 257.08,82.79 255.56,81.27 253.53,83.3 v253.02,83.3
  Bottom 0.254: v242.86,115.3 242.86,116.83 C11.K2 | v253.02,83.3 253.53,82.79 253.53,77.2 v253.02,76.7
N$119  (via drill 0.61)
  Top 0.254: v185.46,122.92 185.96,122.42 192.06,122.42 v193.08,123.43 | v198.16,118.35 198.66,118.86 208.82,118.86 v210.35,117.34
  Route15 0.254: v193.08,123.43 v198.16,118.35
  Bottom 0.254: v185.46,122.92 185.46,126.48 C15.F2 | v210.35,117.34 209.84,116.83 209.84,106.67 211.36,105.14 213.9,105.14 C13.P2
N$123
  Top 0.254: AB19.AF2 132.12,261.1 133.13,262.12 135.67,262.12 140.24,266.69 A18.D2
  Bottom 0.254: A18.J2 144.31,254.5 143.29,255.51 143.29,265.16 144.31,266.18 A18.D2
N$124  (via drill 0.61)
  Top 0.254: v248.96,260.08 250.48,258.56 258.61,258.56 v260.13,257.04
  Bottom 0.254: v248.96,260.08 247.94,261.1 247.94,268.21 248.96,269.23 A11.C1 | v260.13,257.04 260.64,256.53 260.64,235.7 262.16,234.18 262.16,232.14 A10.S1
N$125  (via drill 0.61)
  Top 0.254: v261.15,233.67 290.1,233.67 290.1,237.73 A08.P1
  Bottom 0.254: v261.15,233.67 260.13,234.68 260.13,239.76 259.12,240.78 A10.N1
N$126
  Top 0.254: AB19.AH2 135.67,257.54 137.2,259.07 140.24,259.07 144.31,263.13 147.36,263.13 A18.E2
  Bottom 0.254: A18.K2 147.86,251.45 148.88,252.46 148.88,262.62 148.37,263.13 A18.E2
N$127  (via drill 0.61)
  Top 0.254: v145.32,242.81 137.7,242.81 137.2,242.3 132.62,242.3 132.12,241.8 AB19.AN2
  Bottom 0.254: B18.J2 144.31,184.9 143.29,185.92 143.29,195.06 144.31,196.08 B18.D2 144.82,197.6 144.82,198.62 145.83,199.63 145.83,204.2 144.82,205.22 144.82,218.43 146.34,219.95 146.34,241.8 v145.32,242.81
N$128  (via drill 0.61)
  Top 0.254: v290.1,241.8 288.58,241.8 288.07,241.29 A08.N1 | v238.29,285.48 v289.09,285.48
  Bottom 0.254: v290.1,241.8 288.58,243.32 288.58,257.04 288.07,257.54 288.07,258.56 289.09,259.58 v289.09,285.48 | v238.29,285.48 238.29,268.21 239.3,267.2 A11.D2
N$129
  Top 0.254: C09.U2 268.77,91.43 269.78,90.41 279.44,90.41 280.45,89.4 C08.V2
N$130  (via drill 0.61)
  Top 0.254: v148.88,236.72 136.69,236.72 135.67,237.73 AB19.AP2
  Bottom 0.254: B18.K2 148.37,181.34 148.88,181.85 148.88,192.01 147.86,193.03 B18.E2 148.37,194.04 148.37,198.11 149.39,199.12 149.39,203.7 149.9,204.2 149.9,207.76 149.39,208.27 149.39,236.21 v148.88,236.72
N$131
  Bottom 0.254: 117.89,255.51 118.91,254.5 A20.J2 | 117.89,255.51 117.89,265.16 118.91,266.18 A20.D2 | 117.89,255.51 117.89,246.37 122.46,246.37 123.99,244.84 123.99,234.18 125,233.16 125,230.62 127.54,230.62 131.61,226.56 131.61,223 AB19.AV2
N$132  (via drill 0.61)
  Top 0.254: v285.02,265.16 255.56,265.16 255.05,264.66 250.99,264.66 249.97,263.64 A11.E1 | v286.04,251.45 290.1,251.45 A08.K1
  Bottom 0.254: v285.02,265.16 286.04,264.15 v286.04,251.45
N$133  (via drill 0.61)
  Top 0.254: v136.18,247.38 134.15,249.42 127.54,249.42 126.53,250.43 122.97,250.43 A20.K2
  Bottom 0.254: A20.K2 122.46,251.45 123.48,252.46 123.48,262.62 122.97,263.13 A20.E2 | v136.18,247.38 136.18,237.22 133.64,234.68 133.64,205.22 133.13,204.71 133.13,198.62 132.12,197.6 AB19.BD2
N$134
  Top 0.254: AB19.BH2 134.66,186.93 130.59,186.93 129.58,185.92 120.43,185.92 119.42,184.9 B20.J2
  Bottom 0.254: B20.J2 118.91,184.9 117.89,185.92 117.89,195.06 118.91,196.08 B20.D2
N$135
  Top 0.254: B20.K2 122.97,181.34 123.99,182.36 129.58,182.36 131.1,183.88 AB19.BJ2
  Bottom 0.254: B20.E2 122.46,193.03 123.48,192.01 123.48,186.42 122.97,185.92 122.97,181.34 B20.K2
N$136  (via drill 0.61)
  Top 0.254: v131.61,169.15 131.1,169.66 v107.22,169.66 | v104.18,207.76 103.16,208.78 102.65,208.78 v101.13,210.3 | v103.67,236.72 v101.64,238.75
  Bottom 0.254: A21.D2 103.16,266.18 103.16,263.64 104.68,262.12 104.68,259.58 104.18,259.07 104.18,255 103.67,254.5 A21.J2 102.65,253.48 102.65,249.92 101.64,248.91 v101.64,238.75 | v131.61,169.15 131.61,170.68 AB19.BN2 | v107.22,169.66 107.73,170.17 107.73,202.17 104.18,205.73 v104.18,207.76 | v101.13,210.3 101.64,210.81 101.64,217.92 102.14,218.43 102.14,218.94 104.68,221.48 104.68,235.7 v103.67,236.72
N$137  (via drill 0.61)
  Top 0.254: v248.96,261.61 246.42,261.61 246.42,266.18 A11.D1 | v250.48,254.5 v248.45,252.46
  Bottom 0.254: v248.96,261.61 250.48,260.08 v250.48,254.5 | v248.45,252.46 247.94,251.96 247.94,241.8 250.48,239.26 250.48,225.03 252.51,223 A10.V2
N$138  (via drill 0.61)
  Top 0.254: v272.83,224.02 257.08,224.02 256.07,225.03 A10.U2
  Bottom 0.254: v272.83,224.02 273.34,224.52 273.34,230.11 274.36,231.13 A09.S1
N$139
  Top 0.254: A10.T2 253.02,229.1 255.05,231.13 255.56,231.13 A10.S2
N$140  (via drill 0.61)
  Top 0.254: v105.19,166.61 129.07,166.61 129.58,167.12 134.15,167.12 134.66,167.63 AB19.BP2 | v103.16,209.79 v100.62,212.33 | v99.6,221.98 99.6,224.02 108.24,224.02 112.81,228.59 115.86,228.59 120.43,233.16 120.43,236.21 112.3,236.21 v109.76,238.75
  Bottom 0.254: A21.E2 105.7,263.13 105.7,258.56 105.19,258.05 105.19,256.02 105.7,255.51 105.7,251.96 106.21,251.45 A21.K2 106.21,250.43 106.21,247.38 107.73,245.86 107.73,240.78 v109.76,238.75 | v105.19,166.61 105.19,198.62 104.68,199.12 104.68,204.2 103.16,205.73 v103.16,209.79 | v100.62,212.33 99.6,213.35 v99.6,221.98
N$142
  Top 0.254: C09.R1 271.82,102.1 272.83,103.11 276.9,103.11 278.42,104.64 283.5,104.64 C08.P2
N$146
  Top 0.254: C09.D1 271.82,134.1 272.32,134.61 289.09,134.61 291.12,132.58 291.12,130.54 C08.E1
N$147  (via drill 0.61)
  Top 0.254: v265.72,122.92 266.23,122.42 282.99,122.42 286.04,119.37 286.55,119.37 287.06,118.86 287.06,114.8 C08.L1
  Bottom 0.254: v265.72,122.92 265.72,126.48 C09.F2
N$148  (via drill 0.61)
  Top 0.254: v274.86,102.1 276.9,102.1 277.91,103.11 281.98,103.11 286.55,98.54 290.1,98.54 C08.S1 | v272.32,117.34 274.36,117.34 C09.K1
  Bottom 0.254: v274.86,102.1 272.83,104.13 272.83,116.83 v272.32,117.34
N$150
  Top 0.254: D16.S2 176.82,28.44 181.9,28.44 D16.S1
N$151
  Bottom 0.254: D16.V2 173.26,19.8 174.28,20.82 174.28,29.96 173.26,30.98 D16.R2
N$153
  Bottom 0.254: A10.J2 252.51,254.5 252.51,259.58 A10.F2
N$155  (via drill 0.61)
  Top 0.254: v203.24,115.3 203.74,115.81 205.78,115.81 206.28,115.3 209.84,115.3 210.35,115.81 v213.9,115.81 | v213.9,113.27 214.41,112.76 218.48,112.76 221.02,115.3 225.59,115.3 226.1,115.81 227.62,115.81 228.13,115.3 230.16,115.3 v230.67,115.81 | v248.96,114.29 250.48,112.76 v256.07,112.76
  Route2 0.254: v230.67,115.81 236.26,115.81 243.37,108.7 v248.96,114.29 | v256.07,112.76 256.58,112.76 258.1,114.29 C10.L1
  Route15 0.254: v201.71,121.4 v199.68,123.43
  Bottom 0.254: v199.68,123.43 199.68,128 201.2,129.53 C14.E2 | v201.71,121.4 203.24,119.88 v203.24,115.3 | v213.9,115.81 v213.9,113.27
N$161  (via drill 0.61)
  Top 0.254: v243.88,249.42 v246.92,252.46
  Route15 0.254: v261.66,240.78 258.61,237.73 250.48,245.86 245.4,245.86 244.89,246.37 244.89,248.4 v243.88,249.42 | v246.92,252.46 248.45,253.99 247.43,255 247.43,256.02 246.42,257.04 246.42,259.58 A11.F1
  Bottom 0.254: v261.66,240.78 263.18,240.78 264.7,239.26 264.7,237.73 267.75,237.73 A09.P2
N$162
  Top 0.254: A11.H1 248.96,257.54 247.43,259.07 243.37,259.07 236.26,266.18 233.72,266.18 A12.D1
  Bottom 0.254: A12.D1 233.21,267.2 233.21,272.28 A12.B1
N$185  (via drill 0.61)
  Top 0.254: v213.9,134.61 212.89,135.62 208.82,135.62 208.32,136.13 C14.C1 | v226.1,129.02 226.6,128.51 231.68,128.51 232.7,129.53 v233.72,129.53 | v246.42,131.56 246.92,132.07 254.54,132.07 v256.07,133.59