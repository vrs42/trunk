# EAGLE board tc08 (EAGLE 4.11), part 8 of 10
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
N$185  (via drill 0.61) (continued)
  Route2 0.254: v233.72,129.53 235.75,131.56 238.8,131.56 239.3,132.07 245.91,132.07 v246.42,131.56
  Route15 0.254: v213.9,134.61 216.44,132.07 221.02,132.07 222.03,131.05 223.56,131.05 225.59,129.02 v226.1,129.02 | v256.07,133.59 256.58,133.59 257.08,133.08 257.59,133.08 257.59,132.07 258.1,131.56 260.64,131.56 261.66,130.54 C10.E1
N$193  (via drill 0.61)
  Top 0.254: v212.89,103.62 213.4,103.11 215.94,103.11 218.98,106.16 226.6,106.16 v227.11,105.65 | v229.65,100.57 230.16,100.06 231.18,100.06 231.68,99.56 235.24,99.56 235.75,100.06 v240.83,100.06 | v248.96,101.08 249.97,100.06 260.64,100.06 261.66,99.05 C10.S1
  Route2 0.254: v227.11,105.65 228.13,104.64 228.13,102.1 v229.65,100.57 | v240.83,100.06 240.83,100.57 242.35,102.1 244.38,102.1 245.4,103.11 246.92,103.11 v248.96,101.08
  Route15 0.254: v212.89,103.62 v204.76,111.75
  Bottom 0.254: v204.76,111.75 206.28,113.27 206.28,114.8 205.78,115.3 205.78,118.86 204.76,119.88 C14.J1
PAR  (via drill 0.61)
  Top 0.254: v291.63,239.76 295.18,239.76 296.71,241.29 v297.22,241.29 | v298.74,290.06 298.23,289.55 291.12,289.55 290.1,288.53 286.55,288.53 286.04,288.02 241.34,288.02 240.83,288.53 239.3,288.53 238.8,289.04 236.76,289.04 235.75,290.06 227.62,290.06 227.11,290.56 222.54,290.56 v222.03,290.06 | v161.58,264.66 161.07,265.16 159.55,265.16 v157.52,263.13 | v129.58,236.72 129.07,236.21 123.99,236.21 120.94,233.16 120.94,231.13 119.42,231.13 115.35,227.06 v112.81,227.06 | v103.67,217.92 101.13,215.38 v79.28,215.38 | v59.47,229.1 55.92,229.1 A25.T1
  Route2 0.254: v288.07,237.73 290.1,239.76 v291.63,239.76 | v157.52,263.13 141.77,247.38 141.77,246.88 138.72,243.83 136.69,243.83 v129.58,236.72 | v79.28,215.38 74.2,215.38 59.98,229.6 v59.47,229.1
  Route15 0.254: v216.95,276.85 215.94,276.85 214.92,277.86 197.14,277.86 192.57,282.44 191.04,282.44 v181.9,273.29 | v170.22,275.83 v164.12,269.74 | v112.81,227.06 111.8,227.06 107.22,222.49 107.22,221.48 v103.67,217.92
  Bottom 0.254: v288.07,237.73 288.58,237.22 288.58,234.18 289.09,233.67 289.09,227.06 290.1,226.05 A08.U1 | v297.22,241.29 298.23,242.3 298.23,266.18 298.74,266.69 v298.74,290.06 | v222.03,290.06 216.95,290.06 v216.95,276.85 | v181.9,273.29 180.88,274.31 170.22,274.31 v170.22,275.83 | v164.12,269.74 161.58,267.2 v161.58,264.66
PAR\  (via drill 0.61)
  Top 0.254: v365.29,181.34 365.29,179.82 361.73,176.26 359.19,176.26 359.19,168.14 357.67,166.61 357.16,166.61 356.65,167.12 354.62,167.12 349.03,172.71 346.49,172.71 344.97,174.23 B04.M1 | v364.78,221.48 364.27,220.97 339.38,220.97 336.33,224.02 294.68,224.02 293.15,225.54 v292.64,225.54 | v261.66,267.7 262.16,268.21 265.72,268.21 266.23,268.72 267.24,268.72 v268.77,267.2 | v269.78,273.8 270.29,274.31 276.9,274.31 278.42,275.83 v280.96,275.83 | v294.17,231.64 291.12,231.64 A08.S1
  Route15 0.254: v261.66,267.7 256.58,272.78 255.05,272.78 253.02,274.82 251.5,274.82 244.89,268.21 242.35,268.21 240.83,269.74 236.76,265.67 236.76,264.15 A12.E1 | v280.96,275.83 285.02,271.77 286.55,271.77 v293.66,264.66
  Bottom 0.254: v365.29,181.34 365.29,207.76 364.27,208.78 364.27,220.97 v364.78,221.48 | v292.64,225.54 290.61,227.57 290.61,231.13 A08.S1 | v268.77,267.2 269.78,268.21 v269.78,273.8 | v293.66,264.66 295.18,263.13 295.18,232.65 v294.17,231.64
PC+ES
  Bottom 0.254: A11.H2 242.35,257.54 241.84,258.05 241.84,261.61 239.81,263.64 237.78,263.64 237.78,268.21 236.76,269.23 A12.C1
PC+ES\
  Bottom 0.254: B11.R2 239.3,165.09 238.29,166.1 238.29,203.7 239.81,205.22 239.81,219.95 238.29,221.48 238.29,252.46 239.3,253.48 A11.J2
PWR_CLR\  (via drill 0.61)
  Top 0.254: C05.K1 328.2,117.34 325.66,117.34 318.04,109.72 315.5,109.72 315.5,107.18 314.49,106.16 310.93,106.16 309.92,105.14 C06.P2 308.9,104.64 307.88,103.62 303.82,103.62 303.31,103.11 v285.02,103.11 | v244.89,106.67 213.9,106.67 210.35,103.11 206.28,103.11 205.27,102.1 C14.R1 | v244.89,73.14 248.96,73.14 D11.A1 249.97,73.14 v252,73.14 | v285.02,87.87 284.52,87.36 v253.53,87.36 | 235.24,246.37 236.26,246.37 236.76,245.86 250.48,245.86 252,244.34 255.05,244.34 A10.M2 | 235.24,246.37 232.7,246.37 232.19,245.86 88.94,245.86 87.92,244.84 A23.M1 | 235.24,246.37 v235.24,247.38 | v262.16,156.96 262.67,156.96 263.18,156.45 269.28,156.45 270.8,154.93 271.82,154.93 273.34,156.45 275.88,156.45 276.9,155.44 283.5,155.44 B08.U2 | v262.16,169.66 263.69,171.18 263.69,171.69 265.21,173.22 v265.72,173.22 | v262.67,191.5 262.16,192.01 v256.58,192.01 | v254.04,225.54 254.04,226.05 255.05,227.06 258.1,227.06 v258.61,226.56 | v330.74,75.17 383.07,75.17 v387.13,79.24 | v388.66,279.39 386.62,281.42 369.35,281.42 368.84,280.91 295.18,280.91 289.6,286.5 288.58,286.5 288.07,285.99 239.3,285.99 238.8,286.5 v236.76,286.5
  Route15 0.254: v263.69,175.25 v265.72,173.22
  Bottom 0.254: v244.89,106.67 244.89,98.03 243.37,96.51 243.37,92.44 C11.U2 243.37,91.43 243.37,88.38 244.89,86.86 v244.89,73.14 | v285.02,103.11 285.53,102.6 285.53,88.38 v285.02,87.87 | v253.53,87.36 252,85.84 v252,73.14 | v235.24,247.38 235.24,274.82 236.26,275.83 A12.A1 236.76,276.85 v236.76,286.5 | 257.08,245.86 257.08,251.45 256.58,251.96 256.58,256.02 256.07,256.53 A10.H2 | 257.08,245.86 256.07,244.84 A10.M2 | v262.16,156.96 260.64,158.48 260.64,169.15 261.15,169.66 v262.16,169.66 | v263.69,175.25 263.18,175.76 263.18,191 v262.67,191.5 | v256.58,192.01 257.08,192.52 257.08,217.92 254.54,220.46 254.54,224.52 254.04,225.03 v254.04,225.54 | v258.61,226.56 257.08,228.08 257.08,245.86 | v330.74,75.17 330.74,91.94 329.73,92.95 329.73,94.48 327.19,97.02 327.19,105.65 330.24,108.7 330.24,113.27 329.22,114.29 329.22,116.32 328.71,116.83 C05.K1 | v387.13,79.24 388.15,80.25 388.15,98.54 389.67,100.06 389.67,107.18 389.16,107.68 389.16,141.21 388.66,141.72 388.66,143.75 389.67,144.77 389.67,151.37 388.66,152.39 388.66,180.33 389.67,181.34 389.67,184.39 388.15,185.92 388.15,200.65 388.66,201.16 388.66,231.13 389.67,232.14 389.67,244.84 390.18,245.35 390.18,251.96 388.66,253.48 v388.66,279.39
RD+WD  (via drill 0.61)
  Top 0.254: v236.76,211.32 237.27,210.81 249.46,210.81 249.97,210.3 253.53,210.3 254.54,211.32 | 254.54,211.32 255.56,212.33 256.58,212.33 258.61,214.36 v258.61,216.9 | v227.11,85.84 227.11,84.32 220.51,77.71 220.51,75.68 217.97,75.68 217.46,75.17 211.87,75.17 211.36,75.68 179.87,75.68 179.36,75.17 172.25,75.17 171.74,75.68 164.12,75.68 163.61,75.17 157.52,75.17 157.01,75.68 v136.69,75.68 | v136.69,185.41 137.2,185.92 171.74,185.92 174.28,188.46 196.63,188.46 v197.14,187.95 | v198.66,201.16 198.66,201.66 218.48,201.66 218.98,202.17 222.03,202.17 223.05,201.16 228.64,201.16 v229.65,202.17 | v280.96,173.72 281.47,173.22 282.99,173.22 283.5,172.71 v287.06,172.71 | v294.68,174.74 v289.6,169.66 | v294.17,185.41 276.9,185.41 276.39,184.9 272.83,184.9 269.28,188.46 267.24,188.46 v266.74,187.95 | v266.23,209.79 265.21,210.81 264.2,210.81 263.18,209.79 256.07,209.79 254.54,211.32
  Route2 0.254: v233.72,206.24 233.72,206.74 236.76,209.79 v236.76,211.32 | v258.61,216.9 258.61,217.41 259.12,217.92 259.12,218.94 v265.21,225.03 | v230.16,88.38 229.65,88.38 v227.11,85.84
  Bottom 0.254: 230.16,202.17 233.72,205.73 v233.72,206.24 | 230.16,202.17 228.64,200.65 228.64,197.09 227.62,197.09 B12.D2 | v265.21,225.03 264.2,226.05 264.2,227.57 263.69,228.08 263.69,230.62 266.74,233.67 273.34,233.67 273.34,234.18 274.36,235.19 274.36,237.73 A09.P1 | v230.16,88.38 231.18,89.4 231.18,96 232.19,97.02 232.19,100.57 232.7,101.08 C12.R1 | v136.69,185.41 v136.69,75.68 | v197.14,187.95 197.14,198.11 198.66,199.63 v198.66,201.16 | 230.16,202.17 v229.65,202.17 | v280.96,173.72 280.96,171.69 B08.N2 | v287.06,172.71 288.58,172.71 288.58,170.68 v289.6,169.66 | v294.68,174.74 295.18,175.25 295.18,184.39 v294.17,185.41 | v266.74,187.95 269.78,191 269.78,202.17 266.23,205.73 v266.23,209.79
RD_EN
  Bottom 0.254: C11.N2 239.81,108.7 241.34,110.22 241.34,112.26 245.91,116.83 245.91,119.88 C11.J1
RD_EN_LPB_00-02  (via drill 0.61)
  Top 0.254: v275.88,93.46 268.77,93.46 | 268.77,93.46 267.75,93.46 266.74,92.44 263.69,92.44 262.67,93.46 255.05,93.46 254.04,92.44 250.99,92.44 249.97,93.46 245.4,93.46 244.89,93.97 235.24,93.97 234.73,93.46 216.95,93.46 215.94,94.48 212.38,94.48 211.87,94.98 C13.T2 | D09.D1 v275.37,63.49 | v252,123.94 250.48,122.42 245.91,122.42 245.4,121.91 242.86,121.91 242.35,121.4 241.34,121.4 v240.32,122.42 | v240.32,116.32 244.38,112.26 v245.4,112.26 | v245.91,109.72 246.42,109.21 254.54,109.21 256.58,107.18 256.58,105.65 257.08,105.65 v262.16,100.57 | 268.77,93.46 v268.77,93.97
  Route2 0.254: v252,123.94 v254.54,126.48 | v262.16,100.57 263.69,100.57 269.28,94.98 268.77,94.48 v268.77,93.97
  Bottom 0.254: 273.34,34.02 271.82,32.5 D09.R1 | 273.34,34.02 273.34,46.22 274.36,47.23 D09.K1 | 273.34,34.02 270.29,37.07 270.29,61.96 271.31,62.98 D09.D1 | v275.88,93.46 276.39,92.95 276.39,64.5 v275.37,63.49 | v254.54,126.48 254.04,126.99 254.04,131.05 252.51,132.58 C10.D2 | v240.32,122.42 241.34,121.4 241.34,119.37 240.32,118.35 v240.32,116.32 | v245.4,112.26 245.91,111.75 v245.91,109.72
RD_EN_LPB_03-05  (via drill 0.61)
  Top 0.254: C13.R2 211.87,101.59 212.38,102.1 215.94,102.1 216.95,103.11 238.29,103.11 238.8,103.62 242.35,103.62 242.86,103.11 247.43,103.11 248.45,102.1 252,102.1 C10.R2 | v266.74,48.25 265.72,49.26 263.69,49.26 v261.66,51.3
  Route2 0.254: v257.59,58.41 257.59,60.44 254.54,63.49 257.08,66.03 257.08,73.65 257.59,74.16 257.59,83.81 259.62,85.84 259.62,87.36 260.13,87.87 260.13,89.9 v257.59,92.44
  Route15 0.254: v261.66,51.3 v259.62,53.33 | v257.59,92.44 257.59,93.97 257.08,94.48 257.08,99.05 256.07,100.06 254.04,100.06 253.02,101.08 C10.R2
  Bottom 0.254: 266.74,36.56 266.74,24.37 268.26,22.85 D09.U2 | 266.74,36.56 265.72,37.58 D09.N2 | 266.74,36.56 v266.74,48.25 267.24,48.76 267.24,52.31 268.26,53.33 D09.H2 | v259.62,53.33 260.13,53.84 260.13,58.41 v257.59,58.41
RDD_00  (via drill 0.61)
  Top 0.254: v274.36,62.47 270.29,58.41 266.74,58.41 265.72,57.39 D09.F2 | 107.22,230.11 107.22,230.62 107.73,230.62 109.76,232.65 v111.29,232.65 | 107.22,230.11 v107.22,229.1 | v111.29,260.08 116.88,260.08 117.89,259.07 133.13,259.07 135.67,261.61 136.18,261.61 139.74,265.16 149.39,265.16 152.44,262.12 168.18,262.12 169.2,261.1 171.23,261.1 171.74,261.61 181.9,261.61 184.95,258.56 196.12,258.56 197.14,257.54 198.66,257.54 v199.68,256.53 | v206.79,235.19 207.3,234.68 208.82,234.68 209.84,235.7 209.84,236.21 221.02,236.21 222.54,234.68 v224.06,234.68 | v238.8,215.38 239.81,214.36 252,214.36 v252.51,214.87 | v265.72,76.7 263.69,78.73 257.59,78.73 257.08,78.22 239.81,78.22 v239.3,78.73 | v211.36,84.32 210.86,84.82 203.74,84.82 202.73,85.84 182.92,85.84 v182.41,85.33 | v178.85,91.94 177.33,93.46 175.3,93.46 v174.79,92.95 | v165.64,76.7 v174.79,85.84 | v158.53,62.47 158.02,61.96 152.44,61.96 151.93,61.46 148.88,61.46 148.37,61.96 129.58,61.96 126.53,65.01 121.45,65.01 118.91,67.55 113.83,67.55 113.32,68.06 79.28,68.06 v78.78,67.55 | v65.57,187.44 63.54,189.47 63.54,192.01 69.12,192.01 70.65,193.54 v72.17,193.54 | v74.71,210.3 75.22,210.81 v79.28,210.81 | v82.33,235.7 82.84,236.21 91.98,236.21 96.05,232.14 98.08,232.14 99.1,233.16 102.65,233.16 105.7,230.11 107.22,230.11
  Route2 0.254: v224.06,228.08 225.59,228.08 230.67,223 231.18,223 231.68,222.49 231.68,220.97 237.78,214.87 238.29,215.38 v238.8,215.38 | v239.3,78.73 235.24,78.73 233.72,77.2 232.19,77.2 v230.16,75.17
  Route15 0.254: v199.68,250.43 202.73,247.38 v203.24,247.38 | v252,205.73 260.13,197.6 260.13,187.95 260.64,187.44 260.64,185.41 261.15,184.9 261.15,183.88 266.74,178.3 266.74,175.76 267.75,174.74 B09.M2 | v274.86,69.58 274.86,70.6 272.83,72.63 271.31,72.63 267.24,76.7 v265.72,76.7 | v226.6,75.68 217.46,84.82 211.87,84.82 v211.36,84.32
  Bottom 0.254: v274.36,62.47 274.36,66.03 D09.C1 274.86,67.04 v274.86,69.58 | v107.22,229.1 107.22,226.56 106.72,226.05 A21.U2 | v111.29,232.65 v111.29,260.08 | v199.68,256.53 v199.68,250.43 | v203.24,247.38 203.24,244.84 206.79,241.29 v206.79,235.19 | v224.06,234.68 v224.06,228.08 | v252.51,214.87 252,214.36 v252,205.73 | v230.16,75.17 226.6,75.17 v226.6,75.68 | v182.41,85.33 181.9,85.84 181.9,88.89 v178.85,91.94 | v174.79,85.84 v174.79,92.95 | v165.64,76.7 162.09,73.14 162.09,66.03 v158.53,62.47 | v78.78,67.55 76.24,67.55 76.24,82.79 71.66,87.36 67.09,87.36 67.09,184.39 65.57,185.92 v65.57,187.44 | v72.17,193.54 72.68,194.04 72.68,208.27 v74.71,210.3 | v79.28,210.81 80.3,211.82 80.3,223 79.28,224.02 79.28,238.75 80.3,239.76 82.33,239.76 v82.33,235.7
RDD_01  (via drill 0.61)
  Top 0.254: v271.31,47.74 270.8,47.74 v268.77,45.71 268.26,46.22 259.12,46.22 v258.61,46.72 | v242.86,149.85 131.1,149.85 129.58,151.37 129.07,151.37 126.53,153.91 124.5,153.91 122.97,155.44 B20.U2 | v244.89,166.1 245.4,166.61 273.34,166.61 B09.P1 | v240.83,61.96 237.78,58.92 233.72,58.92 v233.21,59.42 | v227.62,53.84 222.54,53.84 222.03,53.33 222.03,52.31 215.94,52.31 v214.92,51.3 | v209.33,51.3 207.81,49.77 206.28,49.77 205.78,49.26 163.61,49.26 161.58,47.23 161.58,46.22 159.55,46.22 158.02,47.74 155.99,47.74 154.47,49.26 135.67,49.26 v134.15,50.79 | v133.13,121.91 132.62,122.42 118.4,122.42 115.35,125.46 115.35,132.07 v117.38,132.07
  Route2 0.254: v227.62,53.84 v233.21,59.42 | v214.92,51.3 213.4,51.3 211.36,53.33 v209.33,51.3
  Route15 0.254: v258.61,46.72 253.02,52.31 246.92,52.31 245.91,53.33 245.91,54.85 v245.4,55.36
  Bottom 0.254: v268.77,45.71 268.77,41.64 D09.M2 | v271.31,47.74 271.31,50.28 D09.J1 | v242.86,149.85 244.38,151.37 244.38,156.45 243.88,156.96 243.88,160.52 244.89,161.53 v244.89,166.1 | v245.4,55.36 240.83,59.93 v240.83,61.96 | v134.15,50.79 133.64,51.3 133.64,96.51 133.13,97.02 133.13,102.6 132.62,103.11 131.61,103.11 131.61,105.14 133.13,106.67 v133.13,121.91 | v117.38,132.07 117.89,132.58 117.89,142.23 122.46,146.8 122.46,154.93 B20.U2
RDD_02  (via drill 0.61)
  Top 0.254: v113.83,191 113.83,188.46 90.97,188.46 87.92,185.41 v87.41,185.41 | v85.89,137.66 82.84,134.61 v59.98,134.61 | v59.98,42.66 63.03,39.61 v99.6,39.61 | v196.12,20.31 199.68,23.86 v201.71,23.86 | v202.73,37.58 204.76,39.61 205.78,39.61 208.32,37.07 209.33,37.07 209.84,37.58 v209.84,39.1 | v261.15,25.39 D09.T2 | v271.31,34.53 274.36,34.53 D09.P1 | v256.07,213.35 255.56,212.84 246.42,212.84 245.91,213.35 242.35,213.35 v241.84,212.84 | v221.02,221.98 218.98,224.02 212.89,224.02 211.36,225.54 v210.86,225.54 | v204.76,232.65 204.25,233.16 194.6,233.16 194.09,232.65 194.09,231.64 192.06,231.64 v191.55,232.14 | v189.52,234.68 188,234.68 187.49,235.19 187.49,236.21 v177.84,236.21 | v177.84,252.97 176.31,254.5 v175.8,254.5 | v169.71,271.77 145.83,271.77 145.32,271.26 143.29,271.26 142.78,271.77 v130.59,271.77
  Route2 0.254: v248.45,17.77 248.96,17.77 252,20.82 252.51,20.82 254.04,22.34 254.04,22.85 255.05,23.86 259.62,23.86 v261.15,25.39 | v265.72,28.94 v271.31,34.53 | v191.55,232.14 189.52,234.18 v189.52,234.68
  Route15 0.254: v121.96,221.98 121.96,217.92 106.72,202.68 v109.76,199.63 | v213.9,19.8 v211.87,21.83 | v265.72,198.11 265.72,201.16 268.26,203.7 259.62,212.33 257.08,212.33 v256.07,213.35 | v241.84,212.84 238.29,212.84 235.24,215.89 235.24,216.4 233.72,217.92 232.7,217.92 232.19,218.43 228.64,218.43 227.11,219.95 223.05,219.95 v221.02,221.98 | v210.86,225.54 207.81,228.59 207.81,229.6 v204.76,232.65 | v129.58,247.89 127.04,245.35 127.04,240.78 125,238.75 124.5,238.75 123.48,237.73 123.48,236.21 119.42,232.14 120.94,230.62 120.94,227.06 121.96,226.05 A20.U2
  Bottom 0.254: v121.96,221.98 121.96,225.03 A20.U2 | v109.76,199.63 114.34,195.06 114.34,191.5 v113.83,191 | v87.41,185.41 85.89,183.88 v85.89,137.66 | v59.98,134.61 60.49,134.1 60.49,43.17 v59.98,42.66 | v99.6,39.61 114.84,39.61 114.84,3.04 115.35,2.53 115.35,2.02 115.86,1.51 189.52,1.51 189.52,19.29 191.55,21.32 194.09,21.32 195.11,20.31 v196.12,20.31 | v201.71,23.86 203.24,25.39 203.24,29.96 202.22,30.98 202.22,33.01 203.24,34.02 203.24,37.07 v202.73,37.58 | v209.84,39.1 207.81,39.1 207.81,37.58 209.84,35.55 209.84,34.02 209.33,33.52 209.33,29.45 209.84,28.94 209.84,27.93 209.33,27.42 209.33,24.37 v211.87,21.83 | v213.9,19.8 214.92,18.78 214.92,16.24 218.48,12.69 218.48,9.13 226.1,1.51 248.45,1.51 v248.45,17.77 | v265.72,28.94 265.72,25.9 D09.T2 | v265.72,198.11 266.74,197.09 268.77,197.09 269.28,196.58 269.28,194.55 268.77,194.04 B09.E2 | v177.84,252.97 v177.84,236.21 | v175.8,254.5 171.74,258.56 171.74,263.13 169.71,265.16 v169.71,271.77 | v130.59,271.77 128.05,271.77 128.05,271.26 127.04,270.24 127.04,254.5 130.08,251.45 130.08,248.4 v129.58,247.89
RDMK
  Bottom 0.254: CD18.AS2 147.36,99.05 146.34,100.06 146.34,143.75 147.36,144.77 147.36,154.93 B18.U2
READ_ALL\  (via drill 0.61)
  Top 0.254: v301.79,50.28 303.82,52.31 v316.52,52.31 | v315.5,64 317.54,66.03 317.54,68.06 312.96,68.06 v312.46,67.55 | v309.92,70.09 305.85,74.16 v305.34,74.16 | v305.34,82.79 304.84,83.3 v292.14,83.3 | v284.01,86.35 v271.82,86.35
  Route2 0.254: v312.46,67.55 v309.92,70.09 | v292.14,83.3 288.58,83.3 285.02,86.86 284.52,86.35 v284.01,86.35
  Route15 0.254: v271.82,86.35 250.99,107.18 250.99,109.72 249.97,110.73 C11.M1
  Bottom 0.254: v301.79,50.28 301.79,43.68 300.77,42.66 300.77,39.1 300.26,38.6 D07.N1 | v316.52,52.31 317.54,53.33 317.54,55.87 317.03,56.38 317.03,59.42 317.54,59.93 317.54,61.96 v315.5,64 | v305.34,74.16 v305.34,82.79
READ_DATA  (via drill 0.61)
  Top 0.254: v320.58,39.61 313.98,39.61 304.33,49.26 295.18,49.26 294.17,50.28 D07.J2 | v320.58,10.15 320.08,10.66 275.88,10.66 274.86,9.64 254.54,9.64 v254.04,9.13 | v250.99,26.4 250.48,26.91 v210.35,26.91 v206.28,26.91 | v200.7,14.72 200.19,14.21 187.49,14.21 186.47,13.2 135.16,13.2 134.15,14.21 132.12,14.21 131.1,15.23 116.88,15.23 116.37,15.74 95.03,15.74 94.02,16.75 62.01,16.75 v46.26,32.5 | v28.99,292.6 54.39,292.6 55.92,291.07 60.49,291.07 61.5,290.06 66.58,290.06 67.09,289.55 98.08,289.55 98.59,290.06 108.75,290.06 111.29,292.6 117.38,292.6 117.89,292.09 136.69,292.09 139.23,294.63 163.1,294.63 165.14,292.6 195.11,292.6 196.12,293.61 208.32,293.61 208.82,294.12 v210.35,294.12 | v240.32,282.94 241.34,281.93 252.51,281.93 v253.02,282.44 | v254.04,255 254.04,252.97 257.08,252.97 v258.61,251.45
  Route2 0.254: v212.89,95.49 212.89,99.56 225.08,111.75 225.08,114.8 229.14,118.86 229.65,118.86 230.16,119.37 231.68,117.84 234.73,117.84 235.75,118.86 237.27,118.86 237.78,119.37 240.83,119.37 244.38,122.92 246.92,122.92 247.43,123.43 248.96,123.43 C11.H1
  Route15 0.254: v211.87,85.84 v214.41,88.38
  Bottom 0.254: v320.58,10.15 v320.58,39.61 | v254.04,9.13 250.99,12.18 v250.99,26.4 | v206.28,26.91 206.79,26.4 206.79,24.88 204.25,22.34 204.25,20.31 200.7,16.75 v200.7,14.72 | v46.26,32.5 32.04,46.72 32.04,107.18 31.53,107.68 31.53,242.81 29.5,244.84 29.5,245.86 28.99,246.37 v28.99,292.6 | v210.35,294.12 213.4,294.12 213.4,293.1 213.9,292.6 240.32,292.6 v240.32,282.94 | v253.02,282.44 257.08,278.37 257.08,269.23 256.58,268.72 256.58,266.18 255.05,264.66 254.04,264.66 254.04,262.62 255.05,261.61 255.05,258.56 254.04,257.54 v254.04,255 | v258.61,251.45 258.61,248.4 A10.L1 | v212.89,95.49 212.89,89.9 v214.41,88.38 | v211.87,85.84 210.86,86.86 209.33,86.86 209.33,83.81 209.84,83.3 209.84,60.95 212.38,58.41 212.38,35.55 209.84,33.01 209.84,29.96 210.35,29.45 v210.35,26.91
READ_DATA\  (via drill 0.61)
  Top 0.254: v301.79,74.16 302.8,75.17 v317.03,75.17 | v317.54,176.26 v309.92,176.26 | 285.02,178.8 284.01,178.8 282.99,177.79 281.47,177.79 B08.L2 | v309.41,178.8 285.02,178.8 | v227.62,185.41 234.22,185.41 235.75,183.88 239.3,183.88 B11.J2 | v226.6,187.95 222.54,187.95 222.03,188.46 222.03,194.04 228.64,194.04 229.65,195.06 236.26,195.06 239.3,198.11 240.83,198.11 243.88,195.06 v285.02,195.06 | 285.02,178.8 v285.02,178.3
  Bottom 0.254: v301.79,74.16 301.79,52.82 300.26,51.3 D07.J1 | v317.03,75.17 316.52,75.68 316.52,90.41 317.54,91.43 v317.54,176.26 | v309.92,176.26 309.41,176.77 v309.41,178.8 | v227.62,185.41 226.6,186.42 v226.6,187.95 | v285.02,195.06 286.04,194.04 286.04,184.39 285.02,183.38 285.02,182.36 285.53,181.85 285.53,178.8 v285.02,178.3
RSTA\  (via drill 0.61)
  Top 0.254: B03.P1 356.65,168.64 356.65,171.18 355.13,172.71 353.1,172.71 351.57,174.23 B03.M2 350.56,174.74 v348.52,174.74 | v348.52,141.21 347,141.21 345.98,140.2 341.92,140.2 C04.B1 | B03.J1 354.11,184.9 354.11,188.96 352.08,188.96 351.06,189.98 348.02,189.98 B03.F2
  Bottom 0.254: B03.C1 357.16,199.63 357.16,196.08 358.68,194.55 358.68,171.69 357.16,170.17 357.16,168.64 B03.P1 | v348.52,141.21 349.03,141.72 349.03,174.74 | 349.03,174.74 349.03,186.93 347.51,188.46 347.51,189.98 B03.F2 | v348.52,174.74 349.03,174.74
RSTB\  (via drill 0.61)
  Top 0.254: B04.C1 343.95,199.63 341.41,199.63 335.32,193.54 335.32,191 B04.F2 | v330.74,174.23 337.86,174.23 B04.M2
  Route15 0.254: v339.89,168.14 341.41,166.61 342.43,166.61 350.05,158.99 350.05,157.98 351.06,156.96 352.08,157.98 352.08,163.06 347.51,167.63 344.97,167.63 B04.P1
  Bottom 0.254: B04.F2 335.32,189.98 338.87,189.98 338.87,188.96 341.41,186.42 341.41,184.9 B04.J1 341.41,183.38 339.89,181.85 339.89,176.77 338.36,175.25 B04.M2 338.36,174.23 338.36,170.68 339.38,169.66 339.38,168.64 v339.89,168.14 | v330.74,174.23 330.74,141.21 327.19,137.66 327.19,135.62 325.66,134.1 C05.D1
SE\  (via drill 0.61)
  Top 0.254: v277.91,283.45 277.4,283.96 260.13,283.96 v259.62,283.45 | v252.51,293.61 252,294.12 241.84,294.12 239.81,296.15 215.94,296.15 215.94,290.06 214.41,288.53 161.07,288.53 160.06,289.55 159.04,289.55 158.53,290.06 147.86,290.06 146.34,288.53 144.31,288.53 v143.8,289.04 | v135.67,188.96 118.91,188.96 v113.32,183.38 | v108.24,72.12 107.22,71.11 v89.44,71.11 | v88.94,19.29 88.94,17.77 106.72,17.77 107.73,16.75 120.94,16.75 121.45,16.24 132.12,16.24 133.13,15.23 135.16,15.23 136.18,14.21 185.46,14.21 186.47,15.23 198.66,15.23 199.68,16.24 204.25,16.24 v204.76,16.75 | v209.33,12.18 222.03,12.18 222.54,12.69 229.14,12.69 229.65,13.2 v232.19,13.2 | v243.88,11.67 244.38,12.18 256.07,12.18 257.08,11.16 v260.13,11.16 | v291.12,25.39 293.66,27.93 v294.68,27.93 | v302.8,43.68 302.3,44.18 300.77,44.18 D07.L1
  Route2 0.254: v276.39,266.18 277.4,265.16 277.4,262.62 276.9,262.12 276.9,260.59 275.37,259.07 275.37,257.54 A09.H1 | v294.68,27.93 294.68,28.94 300.26,34.53 v300.77,34.53
  Bottom 0.254: v276.39,266.18 275.88,266.69 275.88,272.28 276.9,273.29 276.9,282.44 v277.91,283.45 | v259.62,283.45 259.12,283.96 259.12,290.06 254.54,294.63 252.51,294.63 v252.51,293.61 | v143.8,289.04 143.29,288.53 143.29,274.31 142.78,273.8 142.78,223 137.2,217.41 137.2,204.2 136.18,203.19 136.18,195.06 136.69,194.55 136.69,192.01 135.67,191 v135.67,188.96 | v113.32,183.38 111.29,181.34 111.29,102.1 114.34,99.05 114.34,78.22 v108.24,72.12 | v89.44,71.11 88.94,70.6 v88.94,19.29 | v209.33,12.18 v204.76,16.75 | v232.19,13.2 229.14,13.2 229.14,10.66 237.27,2.53 239.3,2.53 239.81,3.04 239.81,7.61 v243.88,11.67 | v260.13,11.16 262.16,11.16 267.24,6.08 280.96,6.08 280.96,7.61 281.47,8.12 284.01,8.12 284.01,5.58 287.56,2.02 291.12,2.02 291.12,20.82 292.14,21.83 292.14,23.86 291.12,24.88 v291.12,25.39 | v300.77,34.53 301.28,35.04 301.28,42.15 v302.8,43.68
SEARCH  (via drill 0.61)
  Top 0.254: v273.34,102.1 275.37,100.06 v281.98,100.06
  Route15 0.254: v269.78,107.68 266.74,110.73 266.74,111.24 265.21,112.76 264.2,112.76 257.08,119.88 257.08,120.38 248.96,128.51 247.94,128.51 244.89,131.56 244.89,134.1 242.86,134.1 241.84,135.12 240.32,133.59 C11.D2 | v281.98,100.06 283.5,100.06 287.06,103.62 287.56,103.11 288.07,103.11 292.14,99.05 292.14,94.48 v297.22,89.4 | v297.22,77.71 297.22,75.17 298.23,74.16 298.23,71.11 293.15,66.03 295.18,64 295.18,62.47 296.71,60.95 D07.E2
  Bottom 0.254: v269.78,107.68 270.29,107.68 270.29,105.14 v273.34,102.1 | v297.22,89.4 297.72,88.89 297.72,78.22 v297.22,77.71
SEARCH\  (via drill 0.61)
  Top 0.254: B11.K2 243.37,181.34 243.88,181.85 280.96,181.85 281.47,182.36 285.02,182.36 285.53,181.85 320.58,181.85 321.6,180.84 B05.K2
  Route2 0.254: v245.91,92.44 243.37,94.98 248.45,100.06 249.46,100.06 249.97,100.57 249.97,103.11 250.48,103.62 250.48,128.51 v252,130.04 | v237.27,147.31 234.22,150.36 234.73,150.86 234.73,157.47 237.78,160.52 237.78,165.6 238.29,166.1 238.29,167.63 241.34,170.68 241.34,175.76 242.86,177.28 242.86,180.33 B11.K2
  Route15 0.254: v302.8,57.9 301.79,56.88 301.79,56.38 293.66,48.25 292.14,48.25 288.07,52.31 280.45,52.31 273.34,59.42 273.34,64 262.67,74.66 259.62,74.66 252,82.28 252,86.35 v245.91,92.44 | v252,130.04 248.45,133.59 248.45,135.12 239.3,144.26 239.3,145.28 v237.27,147.31
  Bottom 0.254: v302.8,57.9 302.8,59.93 D07.E1
SEL  (via drill 0.61)
  Top 0.254: v65.06,231.13 59.98,231.13 59.47,231.64 A25.S1 | v100.62,216.9 v79.28,216.9 | v118.91,218.94 v111.29,218.94 | v119.92,225.54 121.45,227.06 127.04,227.06 129.58,229.6 130.59,229.6 131.1,230.11 133.13,230.11 137.2,226.05 v137.7,226.05 | v185.46,215.38 185.96,215.89 197.14,215.89 197.65,215.38 206.79,215.38 v208.32,216.9
  Route2 0.254: v79.28,216.9 v65.06,231.13 | v208.32,216.9 212.38,220.97 212.38,225.54 220,233.16 227.62,233.16 228.64,234.18 228.64,234.68 229.14,235.19 230.16,235.19 234.22,239.26 234.73,239.26 240.32,244.84 241.34,244.84 242.35,245.86 245.4,245.86 245.91,246.37 254.04,246.37 254.54,246.88 255.56,246.88 257.59,248.91 263.69,248.91 270.29,255.51 272.32,255.51 274.86,252.97 280.45,258.56 282.48,258.56 283.5,257.54 A08.H2
  Route15 0.254: v106.21,222.49 v100.62,216.9 | v139.74,224.52 147.36,216.9 159.04,216.9 163.1,220.97 166.66,220.97 167.17,220.46 177.33,220.46 182.41,215.38 v185.46,215.38
  Bottom 0.254: v106.21,222.49 108.75,219.95 111.29,219.95 v111.29,218.94 | v118.91,218.94 120.43,220.46 120.43,225.03 v119.92,225.54 | v137.7,226.05 139.74,226.05 v139.74,224.52
SEL\  (via drill 0.61)
  Top 0.254: v332.78,185.92 342.94,185.92 343.95,186.93 B04.H1 | v332.27,251.96 331.76,252.46 286.04,252.46 285.02,253.48 281.47,253.48 A08.J2 280.45,253.48 279.44,252.46 v270.29,252.46
  Bottom 0.254: v332.78,185.92 333.28,186.42 333.28,211.82 332.78,212.33 332.78,251.45 v332.27,251.96 | v270.29,252.46 270.29,250.43 268.26,248.4 268.26,246.88 266.74,246.88 265.72,245.86 265.72,241.8 A09.N2
SH_DTB
  Bottom 0.254: 263.69,191 263.69,192.01 262.67,193.03 B10.E1 261.66,194.04 260.64,195.06 260.64,223 257.59,226.05 257.59,226.56 252.51,231.64 252.51,234.18 A10.R2 | 263.69,191 263.69,178.8 264.7,177.79 B09.L2 264.7,176.77 264.7,172.71 263.69,171.69 263.69,143.24 266.74,140.2 | 263.69,191 265.21,192.52 265.21,196.08 B09.D2 | 266.74,112.76 266.74,104.13 267.24,103.62 267.24,100.06 268.26,99.05 C09.S2 | 266.74,112.76 265.72,113.78 C09.L2 264.7,114.8 264.7,115.81 263.69,116.83 263.69,127.5 265.21,129.02 265.21,132.58 C09.D2 265.21,134.1 266.74,135.62 266.74,140.2 | 268.77,112.76 269.78,111.75 269.78,110.22 271.31,108.7 C09.N1 | 266.74,112.76 268.77,112.76 | 266.74,140.2 266.74,155.94 267.24,156.45 267.24,160.52 B09.S2 | B09.B1 271.31,202.17 270.29,201.16 270.29,172.71 271.31,171.69 B09.N1 271.31,170.68 271.31,167.12 272.83,165.6 272.83,139.18 | 272.83,139.18 275.88,139.18 | 272.83,139.18 271.82,139.18 C09.B1 271.31,139.18 270.29,138.16 270.29,114.29 268.77,112.76 | 275.88,139.18 275.88,125.97 274.86,124.96 274.86,124.45 C09.H1 | 275.88,139.18 275.88,143.75 274.86,144.77 274.86,152.39 275.88,153.4 275.88,181.85 274.86,182.87 274.86,186.42 B09.H1
SH_EN  (via drill 0.61)
  Top 0.254: v234.22,242.81 235.24,241.8 239.3,241.8 A11.N2 | v264.7,145.28 262.67,143.24 C10.A1
  Route15 0.254: 227.62,252.46 231.68,256.53 231.68,258.05 230.67,259.07 230.67,263.13 A12.E2 | 227.62,252.46 228.64,251.45 228.64,248.4 v234.22,242.81 | v259.12,116.32 261.66,113.78 261.66,111.75 C10.M1 | v218.48,252.46 227.62,252.46 | v223.05,209.28 223.05,206.74 223.56,206.24 223.56,204.2 230.67,197.09 230.67,195.06 237.78,187.95 237.78,183.38 242.35,178.8 242.35,176.77 244.38,174.74 244.38,169.15 261.15,152.39 262.67,152.39 v264.7,150.36
  Bottom 0.254: C10.A1 261.66,142.23 261.66,139.18 260.13,137.66 260.13,128.51 259.12,127.5 C10.F1 258.61,126.48 258.61,122.92 257.59,121.91 257.59,119.37 258.1,118.86 258.1,117.34 v259.12,116.32 | v218.48,252.46 218.98,251.96 218.98,222.49 221.02,220.46 223.05,220.46 223.05,216.9 222.54,216.4 222.54,209.79 v223.05,209.28 | v264.7,145.28 v264.7,150.36
SH_EN\  (via drill 0.61)
  Route2 0.254: v246.42,238.75 249.46,241.8 257.08,234.18 257.08,231.13 256.58,230.62 256.58,229.6 250.48,223.51 248.45,223.51 247.43,222.49 247.43,220.46 239.81,212.84 238.29,212.84 237.78,213.35 237.78,213.86 233.72,217.92 233.21,217.92 229.14,221.98 227.62,221.98 A12.V2 226.6,221.98 222.54,217.92 v220.51,217.92
  Route15 0.254: v246.42,238.75 244.89,240.27 244.89,242.3 243.37,243.83 A11.M2 | v234.22,162.55 236.26,164.58 237.27,164.58 238.8,163.06 239.81,163.06 241.34,161.53 241.34,160.52 244.89,156.96 245.4,156.96 254.04,148.32 254.04,142.23 259.12,137.15 261.66,137.15 C10.C1 | v234.22,175.25 236.76,177.79 232.19,182.36 232.19,187.95 227.62,192.52 227.62,194.04 225.59,196.08 225.59,201.16 223.05,203.7 223.05,205.22 v222.54,205.73
  Bottom 0.254: C10.C1 261.66,136.13 260.64,135.12 260.64,128 260.13,127.5 260.13,122.42 259.12,121.4 C10.J1 258.61,119.88 258.61,118.35 260.13,116.83 260.13,110.73 261.15,109.72 261.15,105.65 261.66,105.14 C10.P1 | v234.22,162.55 234.73,163.06 234.73,174.74 v234.22,175.25 | v222.54,205.73 222.03,206.24 222.03,217.92 222.54,218.43 222.54,219.44 222.03,219.95 220.51,219.95 v220.51,217.92
SH_ST  (via drill 0.61)
  Top 0.254: v154.98,144.26 155.99,145.28 164.12,145.28 166.15,143.24 C17.A1
  Bottom 0.254: v154.98,144.26 155.48,143.75 155.48,112.76 154.47,111.75 CD18.AM1
SH_ST-B  (via drill 0.61)
  Top 0.254: v155.48,103.62 155.99,103.11 174.79,103.11 175.8,104.13 C16.P2
  Bottom 0.254: v155.48,103.62 155.48,72.12 154.98,71.62 154.98,67.55 154.47,67.04 CD18.BC1
SHIFT_CK  (via drill 0.61)
  Top 0.254: v139.74,116.83 140.75,115.81 v154.47,115.81 | v157.01,118.35 157.52,118.86 161.58,118.86 163.1,117.34 166.15,117.34 C17.K1
  Route2 0.254: v154.47,115.81 v157.01,118.35
  Bottom 0.254: v139.74,116.83 139.74,53.33 142.78,50.28 142.78,42.66 143.29,42.15 143.29,33.52 144.31,32.5 CD18.BR2
SINGLE_UNIT  (via drill 0.61)
  Top 0.254: v106.72,152.39 108.24,150.86 111.8,150.86 v113.32,152.39 | v137.7,168.64 138.72,169.66 142.78,169.66 v144.31,168.14 | v145.32,193.03 145.32,195.06 150.4,195.06 v150.91,194.55 | v185.96,211.82 186.98,212.84 v195.62,212.84 | v259.12,200.14 260.13,201.16 265.72,201.16 266.74,202.17 v266.74,203.7 | v273.34,209.28 275.37,211.32 v278.42,211.32 | v297.72,210.81 v290.61,210.81
  Route2 0.254: v113.32,152.39 118.4,157.47 120.43,157.47 124.5,161.53 126.02,161.53 128.05,163.56 132.62,163.56 v137.7,168.64 | v167.17,196.58 167.68,196.08 170.72,199.12 171.74,199.12 175.8,203.19 177.33,203.19 179.87,205.73 v180.38,205.73 | v246.42,185.92 246.42,186.42 254.54,194.55 256.07,194.55 257.08,195.57 257.08,198.11 v259.12,200.14 | v266.74,203.7 268.26,203.7 270.29,205.73 270.29,206.24 v273.34,209.28
  Route15 0.254: v150.91,194.55 153.45,192.01 161.58,192.01 166.66,197.09 v167.17,196.58 | v195.62,212.84 207.3,212.84 211.36,208.78 213.4,208.78 214.92,210.3 223.56,210.3 230.67,203.19 230.67,201.66 243.37,188.96 244.89,188.96 246.42,187.44 v246.42,185.92 | v278.42,211.32 280.96,213.86 284.52,210.3 290.1,210.3 v290.61,210.81 | v297.72,229.6 299.76,231.64 299.76,232.65 298.74,233.67 298.74,235.7 298.23,236.21 292.14,236.21 291.63,236.72 289.6,236.72 289.09,237.22 289.09,241.8 285.02,245.86 282.99,245.86 280.96,243.83 279.94,244.84 279.94,246.37 276.9,249.42 276.9,249.92 276.39,250.43 275.37,250.43 A09.K1
  Bottom 0.254: v106.72,152.39 106.72,154.93 B21.U2 | v144.31,168.14 143.29,169.15 143.29,180.33 145.83,182.87 145.83,192.52 v145.32,193.03 | v180.38,205.73 181.39,205.73 181.39,207.25 182.92,208.78 185.96,208.78 v185.96,211.82 | v297.72,210.81 298.23,211.32 298.23,229.1 v297.72,229.6
SKP_RQ\  (via drill 0.61)
  Top 0.254: v307.88,214.87 307.38,214.36 295.69,214.36 v294.68,215.38 | v282.99,220.97 v286.04,220.97 | v268.26,230.11 263.69,230.11 263.18,229.6 260.13,229.6 259.62,230.11 v255.56,230.11 | v246.92,232.65 246.42,233.16 241.34,233.16 239.81,231.64 237.27,231.64 A12.S1
  Route2 0.254: v255.56,230.11 254.54,230.11 249.46,235.19 v246.92,232.65
  Route15 0.254: v307.88,214.87 312.96,209.79 312.96,208.78 314.49,207.25 314.49,205.22 318.04,201.66 319.06,201.66 320.58,200.14 320.58,199.12 325.66,194.04 325.66,190.49 B05.F1 | v294.68,215.38 293.66,215.38 v290.1,218.94 | v279.94,231.64 278.93,231.64 v275.37,235.19
  Bottom 0.254: v290.1,218.94 289.09,218.94 287.06,220.97 v286.04,220.97 | v282.99,220.97 282.48,221.48 282.48,229.1 v279.94,231.64 | v275.37,235.19 273.85,233.67 273.85,233.16 270.8,230.11 v268.26,230.11
SP_DY\  (via drill 0.61)
  Top 0.254: v200.19,88.89 201.2,89.9 203.74,89.9 204.25,90.41 v209.33,90.41
  Route2 0.254: v201.71,106.67 201.71,110.73 C14.M2
  Bottom 0.254: v200.19,88.89 200.19,88.38 197.14,85.33 197.14,62.98 197.65,62.47 197.65,58.92 198.66,57.9 D14.F2 | v209.33,90.41 209.33,94.98 203.24,101.08 203.24,105.14 v201.71,106.67
ST_BLK_MK  (via drill 0.61)
  Top 0.254: v36.61,249.42 44.74,249.42 45.76,250.43 A26.K1 | v35.09,119.37 47.79,106.67 137.2,106.67 142.28,101.59 CD18.AR2 144.82,102.1 147.36,102.1 151.42,106.16 160.06,106.16 v160.56,106.67 | v210.86,130.04 213.9,130.04 C13.E2 | v192.06,118.86 188,118.86 186.98,117.84 v185.46,117.84 | v179.36,116.32 178.85,115.81 v161.07,115.81
  Route2 0.254: v210.86,130.04 210.35,130.04 202.73,122.42 196.12,122.42 192.57,118.86 v192.06,118.86 | v185.46,117.84 183.42,115.81 179.87,115.81 v179.36,116.32
  Bottom 0.254: v36.61,249.42 35.09,249.42 v35.09,119.37 | v161.07,115.81 161.58,115.3 161.58,107.68 v160.56,106.67
ST_BLK_MK\  (via drill 0.61)
  Top 0.254: v209.84,161.53 210.35,161.02 212.89,161.02 213.9,160.01 224.57,160.01 227.62,163.06 232.19,163.06 232.7,163.56 v236.76,163.56 | v237.27,246.88 237.78,246.37 v263.69,246.37 270.29,246.37 271.82,244.84 274.36,244.84 A09.M1
  Bottom 0.254: v209.84,161.53 209.84,129.53 210.35,129.02 210.35,128 210.86,127.5 C13.F2 | v236.76,163.56 237.78,164.58 237.78,246.37 v237.27,246.88 | v263.69,246.37 263.69,261.1 264.2,261.61 264.2,265.67 264.7,266.18 A09.D2
ST_CK  (via drill 0.61)
  Top 0.254: CD18.BR1 151.42,31.99 152.94,33.52 155.48,33.52 156.5,34.53 160.06,34.53 D17.P2 | D17.N2 157.52,38.6 159.55,40.63 160.06,40.63 D17.M2 161.07,41.64 162.09,42.66 170.22,42.66 v170.72,42.15 | v222.54,118.35 222.03,118.86 219.49,118.86 217.97,120.38 C13.J1 | v200.19,65.01 197.65,65.01 196.63,64 193.58,64 192.57,65.01 184.95,65.01 183.93,64 180.88,64 179.87,65.01 v172.25,65.01 | A10.P1 261.66,238.75 257.08,238.75 256.07,239.76 121.45,239.76 120.94,239.26 117.89,239.26 117.38,239.76 52.36,239.76 51.85,239.26 47.79,239.26 46.77,238.24 A26.P1 45.76,238.24 42.71,238.24 41.18,239.76 39.15,239.76 35.6,236.21 35.09,236.21 35.09,231.13 v27.47,223.51 | v145.83,29.45 143.29,26.91 127.04,26.91 122.97,30.98 121.96,30.98 v121.45,31.48 | v119.42,29.45 118.91,29.96 85.38,29.96 v84.87,29.45 | v82.84,153.4 82.84,156.96 70.14,156.96 61.5,165.6 v58.96,165.6 | v49.82,209.28 48.8,210.3 29.5,210.3 v27.47,212.33
  Route2 0.254: v222.54,118.35 222.54,117.84 222.03,117.34 222.03,114.8 224.57,112.26 204.25,91.94 204.25,91.43 v201.71,88.89
  Bottom 0.254: v201.71,88.89 200.19,87.36 v200.19,65.01 | v172.25,65.01 170.22,62.98 170.22,42.66 v170.72,42.15 | D17.P2 160.56,35.55 160.56,40.63 D17.M2 | v145.83,29.45 145.83,31.48 150.4,31.48 CD18.BR1 | v119.42,29.45 v121.45,31.48 | v84.87,29.45 82.84,29.45 v82.84,153.4 | v58.96,165.6 54.39,170.17 54.39,202.17 49.82,206.74 v49.82,209.28 | v27.47,212.33 v27.47,223.51
ST_CK\  (via drill 0.61)
  Top 0.254: v177.84,113.27 178.34,112.76 186.47,112.76 190.03,116.32 v191.55,116.32 | v196.12,113.78 197.14,114.8 197.14,115.3 197.65,115.81 202.22,115.81 202.73,116.32 v206.79,116.32 | v206.79,121.4 207.3,121.91 213.9,121.91 217.97,117.84 220,117.84 C13.K1
  Route2 0.254: v191.55,116.32 192.57,116.32 195.62,113.27 v196.12,113.78
  Bottom 0.254: v177.84,113.27 177.84,117.84 174.79,120.89 174.79,128.51 175.8,129.53 C16.E2 | v206.79,116.32 v206.79,121.4
ST_CK_0P  (via drill 0.61)
  Top 0.254: v240.32,98.54 236.76,98.54 C12.S1
  Route15 0.254: v241.34,108.7 v229.14,120.89 | v225.59,130.54 223.05,133.08 222.03,133.08 219.49,135.62 219.49,137.66 217.97,139.18 C13.B1 | v227.62,180.84 v230.16,183.38 | v226.6,154.93 222.54,150.86 v221.02,152.39
  Bottom 0.254: v240.32,98.54 241.34,98.54 241.34,99.05 241.84,99.56 241.84,103.62 241.34,104.13 v241.34,108.7 | v229.14,120.89 228.13,120.89 228.13,121.4 225.08,124.45 225.08,130.04 v225.59,130.54 | v230.16,183.38 230.16,186.42 B12.H2 | v227.62,180.84 227.62,179.31 228.64,178.3 228.64,156.96 v226.6,154.93 | v221.02,152.39 216.95,148.32 216.95,140.2 C13.B1
ST_CK_0P\  (via drill 0.61)
  Top 0.254: v127.04,42.15 127.54,42.66 154.98,42.66 156.5,44.18 D17.L2 | v127.04,128.51 127.04,134.61 158.53,134.61 158.53,133.08 160.56,133.08 v161.07,133.59 | v167.17,139.69 167.68,139.18 171.23,139.18 172.25,138.16 175.8,138.16 v176.82,139.18 | v200.19,133.59 200.7,134.1 v203.24,134.1
  Route2 0.254: v161.07,133.59 v167.17,139.69 | v203.24,134.1 207.3,138.16 211.87,138.16 213.9,140.2 215.94,140.2 216.95,141.21 218.48,141.21 220,142.74 C13.A1
  Route15 0.254: v176.82,139.18 180.38,142.74 181.9,141.21 188,141.21 197.14,132.07 199.68,132.07 200.7,133.08 v200.19,133.59
  Bottom 0.254: v127.04,42.15 127.04,73.65 128.56,75.17 129.58,75.17 129.58,88.89 127.04,91.43 v127.04,128.51
ST_DATA  (via drill 0.61)
  Top 0.254: v171.23,202.17 171.23,204.2 236.26,204.2 v236.76,203.7 | v211.36,124.45 213.9,124.45 C13.H2 | v206.28,129.53 204.25,131.56 198.16,131.56 v197.65,131.05 | v195.11,151.37 194.6,150.86 176.31,150.86 v175.8,151.37
  Route15 0.254: v206.28,129.53 v211.36,124.45
  Bottom 0.254: 173.77,148.83 170.22,152.39 170.22,179.82 171.74,181.34 171.74,183.38 170.72,184.39 170.72,201.66 v171.23,202.17 | 173.77,148.83 177.84,144.77 177.84,142.23 174.79,139.18 174.79,129.53 174.28,129.02 174.28,122.42 173.26,121.4 C16.J2 | v236.76,203.7 236.76,205.73 B12.A1 | v197.65,131.05 195.62,133.08 195.62,134.61 196.63,135.62 196.63,148.83 195.11,150.36 v195.11,151.37 | v175.8,151.37 173.77,149.34 173.77,148.83
ST_FINAL  (via drill 0.61)
  Top 0.254: v279.44,230.11 269.78,230.11 268.77,231.13 A09.S2 | v279.94,242.81 282.99,245.86 299.25,245.86 v299.76,245.35 | v294.17,296.15 293.66,295.64 245.91,295.64 245.4,295.14 242.86,295.14 240.83,297.17 214.92,297.17 207.81,290.06 162.6,290.06 161.58,291.07 160.56,291.07 160.06,291.58 141.26,291.58 139.23,289.55 113.32,289.55 111.29,287.52 101.13,287.52 100.11,286.5 66.08,286.5 65.57,287.01 64.55,287.01 64.04,287.52 58.96,287.52 57.95,288.53 v44.23,288.53 | v40.68,241.29 A26.N1 | v145.32,103.11 145.32,106.67 153.45,106.67 155.99,109.21 196.12,109.21 v196.63,108.7 | v197.14,112.26 197.65,112.76 211.87,112.76 213.4,114.29 215.94,114.29 | 215.94,114.29 C13.L1 | v236.76,157.47 236.26,156.96 219.49,156.96 217.46,154.93 v216.44,154.93 | 215.94,114.29 v215.94,117.34 | v145.83,144.77 145.32,145.28 121.45,145.28 119.42,143.24 114.34,143.24 111.8,145.78 v78.27,145.78 | v66.58,186.42 62.01,186.42 v52.87,195.57 | v49.82,198.62 46.77,201.66 v43.72,201.66
  Route2 0.254: v49.82,198.62 v52.87,195.57
  Bottom 0.254: v279.44,230.11 278.93,230.62 278.93,241.8 v279.94,242.81 | v299.76,245.35 301.28,245.35 301.28,289.04 v294.17,296.15 | v44.23,288.53 43.72,288.02 43.72,274.82 44.23,274.31 44.23,264.15 41.18,261.1 41.18,241.8 v40.68,241.29 | v196.63,108.7 197.14,109.21 v197.14,112.26 | CD18.BL2 144.82,45.2 146.34,46.72 146.34,99.05 145.83,99.56 145.83,102.6 v145.32,103.11 145.83,103.62 v145.83,144.77 | v236.76,157.47 236.76,160.01 240.32,160.01 241.34,158.99 241.34,154.42 241.84,153.91 241.84,148.83 244.38,146.29 244.38,139.18 245.91,137.66 245.91,134.1 C11.D1 | v216.44,154.93 215.94,154.42 v215.94,117.34 | v78.27,145.78 73.19,150.86 73.19,154.42 70.14,157.47 70.14,174.74 69.12,175.76 69.12,179.31 69.63,179.82 69.63,183.38 v66.58,186.42 | v43.72,201.66 44.23,202.17 44.23,239.76 43.22,240.78 A26.N1
ST_FINAL\  (via drill 0.61)
  Top 0.254: C13.M1 221.02,111.24 227.62,111.24 229.14,112.76 238.29,112.76 239.81,111.24 242.35,111.24 C11.M2 | v168.18,92.95 169.71,91.43 174.79,91.43 175.8,90.41 203.24,90.41 204.25,91.43 205.27,91.43 207.3,93.46 214.92,93.46 216.44,91.94 v217.46,91.94 | v167.68,126.99 C16.F2
  Route15 0.254: v217.46,91.94 217.46,92.44 221.02,96 v218.98,98.03
  Bottom 0.254: v167.68,126.99 168.18,126.48 168.18,116.32 165.64,113.78 165.64,112.26 165.14,111.75 165.14,97.52 167.17,95.49 167.17,93.97 v168.18,92.95 | v218.98,98.03 218.98,106.16 220.51,107.68 220.51,110.73 C13.M1
ST_IDLE  (via drill 0.61)
  Top 0.254: v42.71,74.16 48.3,68.57 116.88,68.57 117.38,68.06 136.69,68.06 141.26,63.49 CD18.BD2 | v182.41,76.7 v195.11,76.7 | v181.39,57.39 181.39,55.87 v143.29,55.87
  Route2 0.254: v200.19,94.98 206.79,101.59 206.79,105.65 209.84,108.7 209.84,109.72 212.89,112.76 212.89,116.32 213.4,116.83 213.9,116.83 C13.K2
  Bottom 0.254: v42.71,74.16 41.69,75.17 41.69,207.76 41.18,208.27 41.18,223 41.69,223.51 41.69,229.6 42.71,230.62 42.71,234.18 A26.R1 | v200.19,94.98 199.68,94.98 199.68,93.97 196.12,90.41 196.12,77.71 v195.11,76.7 | v182.41,76.7 181.39,75.68 v181.39,57.39 | v143.29,55.87 143.29,59.42 144.31,60.44 144.31,62.98 CD18.BD2
ST_IDLE\  (via drill 0.61)
  Top 0.254: v224.06,169.66 v213.9,169.66 | v224.57,236.72 263.18,236.72 267.75,241.29 A09.N1
  Bottom 0.254: v213.9,169.66 212.38,168.14 212.38,115.81 211.36,114.8 C13.L2 | v224.06,169.66 223.56,170.17 223.56,187.95 225.08,189.47 225.08,236.21 v224.57,236.72 | A09.E2 268.77,263.13 268.77,259.07 272.83,255 272.83,252.97 270.8,250.94 270.8,249.42 270.29,248.91 270.29,242.81 271.31,241.8 A09.N1
ST_REV_CK  (via drill 0.61)
  Top 0.254: v223.56,32.5 223.05,33.01 171.74,33.01 169.2,30.47 160.06,30.47 159.04,29.45 154.98,29.45 154.47,28.94 CD18.BS1 | D12.H2 229.65,54.34 227.62,56.38 227.11,56.38 D12.F2 | v44.74,145.28 72.17,145.28 73.7,146.8 112.3,146.8 115.35,143.75 118.91,143.75 120.94,145.78 165.64,145.78 167.17,144.26 167.68,144.26 v168.18,143.75 | v169.71,136.64 171.23,135.12 211.87,135.12 213.4,133.59 216.95,133.59 C13.D1 | v234.22,160.52 234.73,160.01 237.27,160.01 238.29,161.02 241.34,161.02 242.35,160.01 247.94,160.01 248.96,161.02 B11.S1 | v233.21,146.29 232.19,145.28 218.48,145.28 v217.97,145.78 | v151.42,85.33 v158.02,85.33 | v159.55,134.1 160.06,134.61 164.63,134.61 165.64,133.59 v167.17,133.59
  Bottom 0.254: v223.56,32.5 224.57,33.52 224.57,53.84 227.11,56.38 D12.F2 | C11.A1 249.97,143.24 249.97,153.4 250.48,153.91 250.48,160.01 249.46,161.02 B11.S1 | v44.74,145.28 44.74,240.27 44.23,240.78 44.23,245.86 43.22,246.88 A26.L1 | v168.18,143.75 169.71,142.23 v169.71,136.64 169.71,136.13 v167.17,133.59 | v234.22,160.52 234.73,160.01 234.73,148.32 233.21,146.8 v233.21,146.29 | v217.97,145.78 218.98,144.77 218.98,137.15 217.46,135.62 217.46,134.1 C13.D1 | v151.42,85.33 151.42,72.63 152.44,71.62 152.44,53.33 155.48,50.28 155.48,29.96 154.47,28.94 CD18.BS1 | v158.02,85.33 159.04,86.35 159.04,133.59 v159.55,134.1
SWTM  (via drill 0.61)
  Top 0.254: C12.P2 230.67,105.14 231.68,106.16 243.88,106.16 244.38,105.65 247.94,105.65 249.97,107.68 252,107.68 C10.N2 | v228.64,116.32 225.59,116.32 225.08,115.81 218.98,115.81 215.43,119.37 195.11,119.37 193.08,117.34 192.57,117.34 192.57,114.8 C15.L1 191.55,113.78 190.54,112.76 187.49,112.76 186.47,111.75 v185.46,111.75 | v292.14,152.39 288.07,152.39 B08.V1 | v294.17,168.14 295.69,169.66 v298.23,169.66 308.9,169.66 v309.41,170.17 | v37.12,208.27 88.94,208.27 92.49,204.71 113.32,204.71 | 113.32,204.71 240.32,204.71 242.35,202.68 245.4,202.68 B11.B1 | v294.68,188.46 294.17,188.96 291.12,188.96 288.07,192.01 278.42,192.01 275.88,194.55 242.86,194.55 v242.35,195.06 | v182.92,114.29 177.84,119.37 v114.34,119.37 | 113.32,204.71 v113.32,203.19
  Route2 0.254: v182.92,114.29 v185.46,111.75
  Bottom 0.254: v228.64,116.32 228.64,105.65 229.14,105.14 C12.P2 | v292.14,152.39 292.14,166.1 v294.17,168.14 | v309.41,170.17 309.41,168.64 B06.P2 | v37.12,208.27 37.12,220.97 36.61,221.48 A26.V2 | v298.23,169.66 298.23,176.77 295.69,179.31 295.69,186.93 294.68,187.95 v294.68,188.46 | v242.35,195.06 245.91,198.62 245.91,202.17 B11.B1 | v114.34,119.37 114.84,119.88 114.84,169.66 114.34,170.17 114.34,171.18 115.35,172.2 115.35,199.12 113.32,201.16 v113.32,203.19
SWTM\  (via drill 0.61)
  Top 0.254: v261.15,125.46 272.32,125.46 273.34,126.48 v273.34,126.99 | C10.L2 v256.07,114.29
  Route2 0.254: v256.07,114.29 257.08,115.3 257.08,116.32 v259.62,118.86 | v273.34,126.99 273.85,126.99 275.88,129.02 275.88,132.07 289.09,145.28 290.61,145.28 296.71,151.37 296.71,151.88 297.22,152.39 298.23,152.39 298.74,151.88 298.74,150.86 301.28,150.86 301.28,156.96 304.84,160.52 304.84,162.55 306.36,164.07 B06.R2
  Bottom 0.254: v259.62,118.86 260.64,119.88 260.64,124.96 v261.15,125.46
SYNC  (via drill 0.61)
  Top 0.254: v223.56,43.68 223.05,43.17 160.06,43.17 156.5,39.61 145.83,39.61 144.82,38.6 CD18.BN2 | v223.05,188.96 248.96,188.96 253.53,193.54 255.05,193.54 B10.E2
  Bottom 0.254: v223.56,43.68 224.06,44.18 224.06,132.58 223.05,133.59 v223.05,188.96 | B10.D2 253.02,196.08 255.05,194.04 255.05,193.54 B10.E2
SYNC-P\  (via drill 0.61)
  Top 0.254: 228.64,179.31 v252,179.31 | 228.64,179.31 219.49,179.31 218.98,179.82 215.43,179.82 214.92,180.33 B13.K2 | v228.64,193.03 v223.56,193.03 | 228.64,179.31 v228.64,179.82
  Bottom 0.254: v252,179.31 252,183.38 B10.J2 | v223.56,193.03 223.56,203.19 B13.A1 | v228.64,179.82 v228.64,193.03
SYNC_EN  (via drill 0.61)
  Top 0.254: v151.42,53.33 152.94,53.33 153.45,53.84 CD18.BH1 | v141.26,56.38 140.75,55.87 129.07,55.87 126.53,58.41 102.14,58.41 v101.64,57.9 | v101.64,110.73 103.67,112.76 141.77,112.76 144.31,110.22 146.34,110.22 146.85,109.72 150.4,109.72 v151.42,110.73 | v166.15,120.38 167.68,121.91 176.31,121.91 v176.82,121.4 | v233.72,173.72 234.22,173.22 235.24,173.22 235.75,172.71 241.34,172.71 v242.35,171.69
  Route2 0.254: v151.42,110.73 159.55,118.86 162.6,118.86 163.1,119.37 165.14,119.37 v166.15,120.38 | v176.82,121.4 177.84,121.4 181.39,124.96 181.39,126.48 184.95,130.04 185.96,130.04 198.16,142.23 198.66,142.23 199.17,142.74 199.17,143.75 220.51,165.09 221.52,165.09 224.57,168.14 227.11,168.14 228.64,169.66 229.65,169.66 v233.72,173.72
  Bottom 0.254: v151.42,53.33 148.88,50.79 148.88,46.22 145.83,43.17 143.29,43.17 143.29,54.34 v141.26,56.38 | v101.64,110.73 v101.64,57.9 | v242.35,171.69 242.35,173.72 B11.M2
T3  (via drill 0.61)
  Top 0.254: v169.2,33.52 232.19,33.52 233.21,34.53 236.26,34.53 D12.P1 236.26,35.55 235.75,35.55 233.72,37.58 D12.N1
  Bottom 0.254: v169.2,33.52 169.2,96 167.17,98.03 C17.S1
T_00\  (via drill 0.61)
  Top 0.254: B23.V2 78.27,151.37 78.78,150.86 88.94,150.86 89.95,151.88 B22.V2 | v73.19,221.48 72.68,220.97 66.58,220.97 65.57,221.98 A24.V2 | v74.2,191 74.2,188.46 v72.17,188.46
  Bottom 0.254: v73.19,221.48 73.7,220.97 73.7,218.43 75.73,216.4 75.73,209.28 73.19,206.74 73.19,192.01 v74.2,191 | v72.17,188.46 72.68,187.95 72.68,159.5 77.25,154.93 77.25,152.39 B23.V2
T_01\  (via drill 0.61)
  Top 0.254: v67.09,235.7 67.6,236.21 80.3,236.21 84.36,232.14 86.9,232.14 A23.S1 | v70.14,176.26 78.78,176.26 80.3,174.74 B23.M2
  Bottom 0.254: A24.M2 68.11,243.83 67.6,243.32 67.6,239.76 67.09,239.26 v67.09,235.7 67.09,234.68 63.54,231.13 63.54,202.17 67.09,198.62 67.09,197.6 70.14,194.55 v70.14,176.26
T_02\  (via drill 0.61)
  Top 0.254: v67.09,258.56 76.24,258.56 77.25,257.54 80.3,257.54 A23.H2 | v93.51,177.79 88.43,172.71 79.28,172.71 78.27,171.69 B23.N2 | v97.57,249.42 v86.4,249.42
  Bottom 0.254: v67.09,258.56 67.09,248.91 66.58,248.4 66.58,242.81 65.57,241.8 A24.N2 | v93.51,177.79 98.08,182.36 98.08,248.91 v97.57,249.42 | v86.4,249.42 85.89,249.92 85.89,254.5 83.86,256.53 81.32,256.53 A23.H2
T_03\  (via drill 0.61)
  Top 0.254: v80.3,195.57 80.3,198.11 79.28,198.11 v75.22,202.17
  Bottom 0.254: 72.68,238.75 68.62,238.75 A24.P2 | 72.68,238.75 72.68,245.86 77.76,250.94 77.76,253.48 A23.J2 | v80.3,195.57 79.79,195.06 79.79,169.66 80.81,168.64 B23.P2 | v75.22,202.17 75.73,202.68 75.73,204.71 76.74,205.73 76.74,219.95 72.68,224.02 72.68,238.75
T_04\  (via drill 0.61)
  Top 0.254: v74.2,235.19 72.68,233.67 66.58,233.67 65.57,234.68 A24.R2
  Bottom 0.254: 76.24,237.22 77.25,238.24 77.25,240.78 A23.N2 | 76.24,237.22 v74.2,235.19 | 76.24,237.22 76.24,221.48 77.25,220.46 77.25,205.22 76.24,204.2 76.24,170.68 76.74,170.17 76.74,165.6 77.25,165.09 B23.R2
T_05\  (via drill 0.61)
  Top 0.254: v80.3,234.68 78.78,233.16 69.63,233.16 68.62,232.14 A24.S2
  Bottom 0.254: A23.P2 80.3,237.73 v80.3,234.68 79.79,234.18 79.79,224.52 80.81,223.51 80.81,209.28 79.79,208.27 79.79,205.22 79.28,204.71 79.28,169.15 79.79,168.64 79.79,162.55 80.3,162.04 B23.S2
T_06\
  Top 0.254: A24.T2 65.57,228.08 66.08,227.57 70.14,227.57 70.65,227.06 78.78,227.06 80.3,225.54 A23.U2
  Bottom 0.254: B23.T2 76.24,160.01 76.24,169.66 73.19,172.71 73.19,191 70.65,193.54 70.65,195.06 69.63,196.08 69.63,200.65 64.04,206.24 64.04,218.94 66.58,221.48 66.58,227.06 65.57,228.08 A24.T2
T_07\  (via drill 0.61)
  Top 0.254: A24.U2 68.62,225.03 70.14,223.51 76.24,223.51 77.25,222.49 A23.V2 | v88.94,209.28 v79.28,209.28
  Bottom 0.254: v88.94,209.28 88.94,199.12 88.43,198.62 88.43,196.58 82.84,191 82.84,157.47 81.32,155.94 B23.U2 | v79.28,209.28 77.76,210.81 77.76,221.48 A23.V2
T_FWD\  (via drill 0.61)
  Top 0.254: v86.4,211.82 83.86,214.36 v82.84,214.36 | v79.28,262.12 69.63,262.12 68.62,263.13 A24.E2
  Bottom 0.254: v86.4,211.82 85.89,211.32 85.89,205.73 85.38,205.22 85.38,195.57 81.82,192.01 81.82,187.95 81.32,187.44 B23.H2 | v82.84,214.36 82.84,231.13 85.38,233.67 85.38,238.75 85.89,239.26 85.89,246.37 87.41,247.89 87.41,250.43 A23.K1 86.9,251.45 86.9,254.5 v79.28,262.12
T_GO\  (via drill 0.61)
  Top 0.254: v62.52,195.06 76.24,195.06 77.25,196.08 B23.D2 | A23.D1 83.86,267.2 83.35,267.7 78.78,267.7 78.27,268.21 74.2,268.21 73.19,269.23 68.62,269.23 A24.C2