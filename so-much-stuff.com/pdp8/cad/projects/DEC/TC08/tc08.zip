# EAGLE board tc08 (EAGLE 4.11), part 10 of 10
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
WC\  (via drill 0.61) (continued)
  Top 0.254: v237.27,49.26 223.56,49.26 v223.05,49.77 220.51,49.77 218.98,48.25 215.94,48.25 214.92,49.26 211.87,49.26 v211.36,48.76 | v207.81,210.3 207.3,209.79 184.95,209.79 v184.44,210.3 | v184.44,229.6 183.93,230.11 168.18,230.11 167.68,229.6 164.63,229.6 164.12,230.11 v148.37,230.11 | v147.86,211.32 147.36,210.81 v142.28,210.81 | v139.74,198.62 139.23,198.11 136.18,198.11 v132.62,194.55 | v132.12,185.92 131.61,185.41 122.97,185.41 119.92,182.36 v110.78,182.36 | v109.26,143.24 104.18,138.16 v96.05,138.16 | v111.29,19.8 111.8,20.31 121.96,20.31 124.5,17.77 135.67,17.77 137.7,15.74 183.93,15.74 184.95,16.75 197.14,16.75 198.16,17.77 200.19,17.77 v200.7,18.28
  Route2 0.254: v222.54,89.4 224.57,91.43 224.57,92.44 226.6,94.48 C12.T2
  Route15 0.254: v226.6,192.01 220.51,198.11 220,198.11 v207.81,210.3
  Bottom 0.254: D11.U1 248.96,22.85 245.4,22.85 245.4,23.86 244.38,24.88 244.38,26.91 244.89,27.42 244.89,39.1 243.37,40.63 D11.M2 242.35,41.64 242.35,44.18 v237.27,49.26 | v222.54,89.4 223.05,88.89 223.05,54.34 222.03,53.33 222.03,50.79 v223.05,49.77 | v226.6,192.01 226.6,190.49 B12.F2 | v184.44,229.6 v184.44,210.3 | v148.37,230.11 148.88,229.6 148.88,212.33 v147.86,211.32 | v142.28,210.81 139.74,208.27 v139.74,198.62 | v132.62,194.55 133.13,194.04 133.13,186.93 v132.12,185.92 | v110.78,182.36 110.78,144.77 v109.26,143.24 | v96.05,138.16 95.54,137.66 95.54,86.86 98.08,84.32 98.08,33.01 v111.29,19.8 | v200.7,18.28 203.74,21.32 203.74,27.93 206.79,30.98 206.79,42.66 207.81,43.68 207.81,45.2 v211.36,48.76
WR_EN  (via drill 0.61)
  Top 0.254: A20.R2 118.4,235.19 112.3,235.19 111.29,236.21 104.68,236.21 103.67,235.19 A21.R2 102.65,235.19 101.13,236.72 42.71,236.72 v41.69,237.73 | C14.U1 208.32,91.43 209.84,91.43 210.86,90.41 v225.08,90.41 253.53,90.41 255.05,91.94 C10.U2 | v259.62,61.96 262.67,61.96 263.18,61.46 266.74,61.46 267.75,60.44 D09.E2 | v108.24,163.56 116.88,163.56 118.4,165.09 B20.R2 | v113.32,95.49 114.84,93.97 149.39,93.97 149.9,93.46 162.09,93.46 165.14,90.41 170.72,90.41 171.23,90.92 174.28,90.92 175.8,89.4 v177.84,89.4 | v180.88,85.84 181.39,86.35 203.74,86.35 v204.25,85.84 | v206.79,88.38 207.3,88.89 v208.82,88.89
  Bottom 0.254: v41.69,237.73 41.69,258.56 42.71,259.58 A26.F1 | B20.R2 118.91,165.6 117.38,167.12 117.38,231.64 118.91,233.16 118.91,234.18 A20.R2 | D09.N1 271.82,38.6 272.83,39.61 272.83,51.8 274.36,53.33 D09.H1 274.36,54.34 273.34,55.36 273.34,64 269.78,67.55 | 268.26,56.38 269.78,54.85 269.78,29.96 268.77,28.94 D09.S2 | 268.26,56.38 268.26,59.93 D09.E2 268.77,60.95 269.78,61.96 269.78,67.55 | 268.26,56.38 266.74,54.85 266.74,50.28 265.72,49.26 265.72,45.71 265.21,45.2 D09.L2 | 269.78,67.55 271.31,69.08 D09.B1 | v225.08,90.41 224.57,90.92 224.57,131.56 226.1,133.08 C12.D2 | C15.A1 195.11,142.23 194.09,141.21 194.09,113.78 195.11,112.76 195.11,111.75 C15.M1 195.62,110.73 195.62,107.18 196.63,107.18 199.17,104.64 199.17,104.13 206.28,97.02 206.28,93.46 207.3,92.44 C14.U1 208.32,91.43 208.32,89.4 v208.82,88.89 | C10.H2 256.07,123.43 257.08,122.42 257.08,115.81 257.59,115.3 257.59,96.51 256.07,94.98 256.07,92.44 C10.U2 256.07,91.43 256.07,85.33 257.59,83.81 257.59,74.16 257.08,73.65 257.08,68.06 257.59,67.55 257.59,61.96 v259.62,61.96 | v108.24,163.56 108.24,100.57 v113.32,95.49 | v177.84,89.4 177.84,88.38 179.87,86.35 180.88,86.35 v180.88,85.84 | v204.25,85.84 v206.79,88.38
WR_EN\  (via drill 0.61)
  Top 0.254: v225.59,100.06 213.9,100.06 213.4,99.56 208.82,99.56 208.32,99.05 C14.S1 | 222.54,125.46 194.6,125.46 194.09,124.96 190.54,124.96 189.52,123.94 C15.H2 188.5,123.94 v186.47,123.94 | 222.54,125.46 226.6,121.4 C12.J2 | 222.54,125.46 236.76,125.46 237.27,124.96 241.34,124.96 242.35,123.94 C11.H2
  Route2 0.254: v248.96,151.37 254.04,146.29 252,144.26 252,143.24 v244.89,136.13
  Bottom 0.254: v225.59,100.06 225.08,100.57 225.08,118.35 226.6,119.88 C12.J2 | v186.47,123.94 186.98,124.45 186.98,132.58 186.47,133.08 C15.D2 | v248.96,151.37 247.43,152.9 247.43,188.46 246.42,189.47 B11.F1 | v244.89,136.13 244.89,125.97 243.37,124.45 C11.H2
WRITE_ALL  (via drill 0.61)
  Top 0.254: v235.24,177.79 236.76,176.26 247.43,176.26 248.96,174.74 B11.M1 | v272.83,21.83 271.82,20.82 261.15,20.82 v259.62,22.34 | v195.62,37.58 193.58,39.61 190.54,39.61 v189.52,38.6 | v180.88,47.23 180.38,46.72 177.33,46.72 176.82,46.22 166.15,46.22 v164.12,48.25 | v152.44,81.27 151.42,82.28 137.2,82.28 135.16,84.32 v132.62,84.32 | v126.02,98.03 123.99,100.06 v111.8,100.06 | v110.27,135.62 110.27,138.16 119.92,138.16 120.94,139.18 v122.97,139.18 | v131.61,141.72 132.12,141.21 143.8,141.21 v144.82,142.23
  Route2 0.254: v234.73,181.34 234.73,181.85 247.94,195.06 247.94,200.65 251.5,204.2 252,204.2 253.02,205.22 253.02,205.73 258.1,210.81 258.1,211.82 258.61,212.33 259.12,212.33 263.69,216.9 266.23,216.9 270.29,220.97 272.83,220.97 278.93,227.06 281.47,227.06 284.52,230.11 284.52,231.13 A08.S2 | v272.83,21.83 273.34,22.34 273.34,23.36 273.85,23.86 274.36,23.86 280.96,30.47 281.98,30.47 284.52,33.01 287.56,33.01 288.07,33.52 291.12,33.52 296.71,39.1 296.71,40.63 D07.M2 | v259.62,22.34 254.04,16.75 250.99,16.75 v245.4,11.16 | v131.61,92.44 v126.02,98.03 | v122.97,139.18 126.02,136.13 v131.61,141.72 | v144.82,142.23 164.12,161.53 164.63,161.53 165.14,162.04 165.14,163.56 167.17,165.6 169.2,165.6 173.26,169.66 173.77,169.66 182.41,178.3 182.41,178.8 182.92,179.31 184.95,179.31 203.74,198.11 214.92,198.11 218.98,202.17 223.05,202.17 v229.65,208.78
  Route15 0.254: v216.95,21.83 208.82,29.96 203.24,29.96 v195.62,37.58 | v161.58,61.46 v153.96,69.08
  Bottom 0.254: v235.24,177.79 234.73,178.3 v234.73,181.34 234.73,187.44 233.72,188.46 233.72,189.47 B12.F1 233.21,190.49 233.21,192.52 230.67,195.06 230.67,197.6 234.73,201.66 234.73,207.25 232.19,207.25 230.67,208.78 v229.65,208.78 | v245.4,11.16 240.32,6.08 240.32,2.53 239.81,2.02 226.6,2.02 218.98,9.64 218.98,19.8 v216.95,21.83 | v189.52,38.6 184.95,43.17 182.92,43.17 182.92,45.2 v180.88,47.23 | v164.12,48.25 161.58,50.79 161.58,55.36 160.06,56.88 160.06,57.9 161.58,59.42 v161.58,61.46 | v153.96,69.08 152.94,70.09 152.94,72.12 152.44,72.63 v152.44,81.27 | v132.62,84.32 133.13,84.82 133.13,90.92 v131.61,92.44 | v111.8,100.06 110.78,101.08 110.78,135.12 v110.27,135.62
WRITE_DATA  (via drill 0.61)
  Top 0.254: B11.R1 245.4,165.09 241.84,165.09 239.3,167.63 237.27,167.63 B12.P1 | v298.74,146.29 274.86,146.29 273.34,147.82 249.46,147.82 248.96,147.31 v244.89,147.31 | B12.B1 233.72,202.17 234.22,201.66 v247.43,201.66 262.67,201.66 262.67,202.68 v264.7,204.71
  Route2 0.254: v268.77,227.06 265.21,230.62 265.21,234.18 A09.R2
  Bottom 0.254: v298.74,146.29 298.74,136.13 295.69,133.08 295.69,88.89 294.68,87.87 294.68,74.66 295.18,74.16 295.18,62.98 293.66,61.46 293.66,57.9 D07.F2 | v244.89,147.31 244.89,156.96 244.38,157.47 244.38,160.01 245.91,161.53 245.91,164.07 B11.R1 245.91,165.09 245.91,166.61 244.89,167.63 244.89,174.23 243.88,175.25 243.88,177.28 241.34,179.82 241.34,187.95 243.37,189.98 243.37,191 244.38,191 247.43,194.04 v247.43,201.66 | v268.77,227.06 269.78,226.05 269.78,223.51 266.74,220.46 263.69,220.46 263.69,207.76 264.7,206.74 v264.7,204.71
WRITE_DATA\  (via drill 0.61)
  Top 0.254: v303.82,120.38 305.34,121.91 308.9,121.91 v309.41,121.4
  Route2 0.254: v300.26,59.93 300.26,60.44 301.79,61.96 301.79,62.98 304.84,66.03 304.84,71.11 v311.95,78.22
  Route15 0.254: v311.95,84.82 311.95,86.35 310.93,87.36 310.93,112.76 303.82,119.88 v303.82,120.38 | v309.41,121.4 312.46,124.45 311.44,125.46 311.44,138.16 298.74,150.86 298.74,151.88 298.23,152.39 297.22,152.39 289.09,160.52 289.09,161.02 287.06,163.06 286.55,163.06 286.04,163.56 286.04,168.64 v284.52,170.17
  Bottom 0.254: v300.26,59.93 300.26,57.9 D07.F1 | v311.95,78.22 v311.95,84.82 | v284.52,170.17 284.52,173.72 B08.M2
WRITE_OK  (via drill 0.61)
  Top 0.254: v159.04,140.7 v161.58,138.16 | 160.56,173.22 v159.04,171.69 | 160.56,173.22 175.3,173.22 178.85,169.66 189.52,169.66 191.55,167.63 191.55,165.09 B15.R1 | v98.59,178.3 101.13,175.76 118.91,175.76 121.45,173.22 160.56,173.22 | v250.48,211.32 244.38,211.32 v243.37,212.33 | v236.76,223 236.26,223.51 229.65,223.51 v229.14,223 | v226.6,218.94 224.57,216.9 223.05,216.9 221.52,215.38 221.52,209.28 v218.48,209.28 | v214.92,208.78 178.85,208.78 178.34,208.27 172.25,208.27 170.72,209.79 v165.64,209.79
  Route2 0.254: v241.34,225.54 239.3,225.54 v236.76,223
  Bottom 0.254: v161.58,138.16 162.09,137.66 162.09,133.08 161.58,132.58 161.58,125.46 160.56,124.45 C17.H2 | v159.04,171.69 159.04,171.18 | 159.04,171.18 v159.04,140.7 | v98.59,178.3 98.59,254.5 92.49,260.59 92.49,264.66 90.97,266.18 A22.D2 | v250.48,211.32 250.48,204.71 249.97,204.2 249.97,200.14 B11.C1 | v243.37,212.33 242.86,212.84 242.86,223.51 241.34,225.03 v241.34,225.54 | v229.14,223 228.64,222.49 228.64,220.97 v226.6,218.94 | v218.48,209.28 217.46,208.27 214.92,208.27 v214.92,208.78 | v165.64,209.79 162.09,206.24 162.09,174.23 159.04,171.18
WRITE_OK+UTS  (via drill 0.61)
  Top 0.254: v171.23,147.31 171.74,147.82 234.73,147.82 v235.24,147.31
  Bottom 0.254: v171.23,147.31 169.2,147.31 162.09,140.2 162.09,139.18 162.6,138.67 162.6,136.64 165.14,134.1 165.14,132.07 167.17,132.07 168.69,130.54 168.69,115.81 167.68,114.8 167.68,112.26 167.17,111.75 C17.M1 | v235.24,147.31 235.24,176.26 236.26,177.28 236.26,180.33 B12.K1 236.26,181.34 235.24,182.36 235.24,187.95 234.73,188.46 234.73,195.06 233.72,196.08 B12.D1
WRITE_OK\  (via drill 0.61)
  Top 0.254: v166.66,210.81 167.68,211.82 167.68,217.41 v166.66,217.41 | v165.14,272.78 166.66,274.31 215.43,274.31 v215.94,273.8 | v214.92,294.12 v214.92,290.56 | v251.5,282.94 v243.88,282.94
  Route15 0.254: v157.52,124.45 160.56,127.5 155.99,132.07 155.99,145.28 v162.09,151.37 | v165.14,171.69 165.14,173.22 v161.07,177.28 | v163.1,205.73 v161.07,203.7 | v253.53,275.83 254.54,274.82 259.62,274.82 v266.74,267.7
  Bottom 0.254: v157.52,124.45 157.52,121.4 C17.J2 | v162.09,151.37 163.1,150.36 168.18,150.36 168.18,162.55 165.14,165.6 v165.14,171.69 | v161.07,177.28 161.58,177.79 161.58,203.19 v161.07,203.7 | v163.1,205.73 166.66,209.28 v166.66,210.81 | v166.66,217.41 166.66,219.95 166.15,220.46 166.15,224.02 165.14,225.03 165.14,233.16 165.64,233.67 165.64,237.22 165.14,237.73 165.14,239.76 165.64,240.27 165.64,243.32 165.14,243.83 165.14,245.86 165.64,246.37 165.64,249.92 165.14,250.43 v165.14,272.78 | v215.94,273.8 215.94,289.55 v214.92,290.56 | v214.92,294.12 243.88,294.12 v243.88,282.94 | v251.5,282.94 252,282.44 252,277.36 v253.53,275.83 | v266.74,267.7 265.72,268.72 263.69,268.72 263.69,262.12 262.16,260.59 262.16,260.08 260.13,258.05 259.12,258.05 259.12,254.5 A10.J1
WRTM  (via drill 0.61)
  Top 0.254: C12.N2 227.11,108.19 231.18,108.19 232.7,109.72 244.38,109.72 247.94,113.27 247.94,115.3 250.48,115.3 252.51,117.34 255.05,117.34 C10.K2 | v286.04,49.77 286.04,51.8 286.55,52.31 288.07,52.31 289.09,51.3 290.1,51.3 291.63,52.82 295.18,52.82 296.2,53.84 D07.H2 | v279.44,13.7 278.93,14.21 266.74,14.21 266.23,13.7 241.34,13.7 v240.83,13.2 | v239.3,16.75 v215.94,16.75 | v238.8,209.28 v245.4,209.28 | v205.78,144.26 209.33,144.26 v210.86,142.74
  Route2 0.254: v210.35,85.84 216.44,91.94 216.44,92.44 216.95,92.95 217.97,92.95 222.03,97.02 222.03,99.05 v227.11,104.13 | v238.8,209.28 238.8,207.76 237.78,206.74 237.78,204.71 236.26,204.71 235.75,204.2 235.75,202.68 231.18,198.11 229.65,198.11 228.64,197.09 228.64,195.57 225.59,192.52 225.59,189.47 215.43,179.31 215.43,177.79 206.28,168.64 204.76,168.64 v202.22,166.1 | v214.41,139.18 214.41,138.67 212.89,137.15 212.89,130.54 210.86,128.51 210.35,128.51 v206.28,124.45
  Route15 0.254: v245.4,209.28 247.94,206.74 248.96,206.74 B11.A1 | v202.22,166.1 202.22,164.58 200.7,163.06 200.7,162.55 199.68,161.53 v205.78,155.44 | v214.41,139.18 v210.86,142.74 | v206.28,124.45 206.28,123.43 209.84,119.88 209.84,119.37 211.36,117.84 211.36,116.83 213.9,114.29 214.41,114.29 216.95,111.75 216.95,110.73 222.03,105.65 222.03,104.64 222.54,104.13 223.56,104.13 226.6,107.18 C12.N2
  Bottom 0.254: v286.04,49.77 285.53,49.26 285.53,27.42 285.02,26.91 279.94,26.91 279.94,26.4 279.44,25.9 v279.44,13.7 | v240.83,13.2 239.3,14.72 v239.3,16.75 | v215.94,16.75 215.94,29.96 212.89,33.01 212.89,74.66 210.35,77.2 v210.35,85.84 | v227.11,104.13 226.1,105.14 226.1,107.68 C12.N2 | v205.78,155.44 206.28,154.93 206.28,144.77 v205.78,144.26
WRTM+FR03  (via drill 0.61)
  Top 0.254: v229.14,89.4 227.11,89.4 C12.V2 | v230.67,109.21 232.19,110.73 235.75,110.73 C12.M1 | v284.52,191 284.01,191.5 276.39,191.5 275.88,192.01 266.74,192.01 264.7,194.04 263.18,194.04 263.18,192.52 263.69,192.01 263.69,190.49 v261.66,190.49 | v231.68,202.17 230.67,203.19 229.14,203.19 228.64,202.68 228.64,202.17 228.13,201.66 223.56,201.66 v222.03,203.19 | v212.38,209.79 211.87,209.28 183.42,209.28 v182.92,209.79 | v177.84,202.17 176.82,201.16 v172.25,201.16 | v171.74,197.6 171.23,198.11 154.47,198.11 v153.96,197.6 | v148.37,158.99 146.85,157.47 110.78,157.47 110.27,156.96 v106.72,156.96 | v105.19,87.36 105.7,86.86 125,86.86 125.51,86.35 126.53,86.35 134.15,78.73 134.15,77.2 156.5,77.2 v157.01,76.7 | v155.48,57.9 155.99,58.41 186.98,58.41 187.49,57.9 190.54,57.9 191.55,58.92 217.97,58.92 v218.98,59.93
  Route2 0.254: v261.66,190.49 259.62,192.52 258.61,192.52 257.08,191 255.56,191 v254.54,189.98 | v221.02,83.81 221.52,83.81 226.1,88.38 C12.V2
  Route15 0.254: v252,187.44 251.5,187.44 237.78,201.16 232.7,201.16 v231.68,202.17
  Bottom 0.254: v229.14,89.4 228.64,89.9 228.64,101.08 231.18,103.62 231.18,108.7 v230.67,109.21 | v284.52,191 285.53,189.98 285.53,185.92 284.52,184.9 284.52,181.34 B08.K2 | v252,187.44 v254.54,189.98 | v222.03,203.19 218.98,203.19 218.98,203.7 214.92,207.76 212.38,207.76 v212.38,209.79 | v182.92,209.79 177.84,204.71 v177.84,202.17 | v172.25,201.16 171.74,200.65 v171.74,197.6 | v153.96,197.6 151.93,195.57 151.93,191.5 152.44,191 152.44,183.38 149.9,180.84 149.9,178.8 149.39,178.3 149.39,160.01 v148.37,158.99 | v106.72,156.96 105.19,156.96 v105.19,87.36 | v157.01,76.7 158.53,75.17 158.53,67.04 155.48,64 v155.48,57.9 | v218.98,59.93 219.49,60.44 219.49,76.19 221.52,78.22 221.52,83.3 v221.02,83.81
WRTM\  (via drill 0.61)
  Top 0.254: v310.42,55.87 309.92,55.36 304.84,55.36 303.82,54.34 D07.H1 | v310.42,61.96 299.25,61.96 298.23,62.98 v296.71,62.98 | v290.61,68.57 289.09,70.09 289.09,72.63 v287.06,72.63 | v265.21,143.75 v267.75,146.29
  Route2 0.254: v296.71,62.98 296.2,62.98 v290.61,68.57 | v267.75,153.4 266.74,154.42 266.74,155.94 273.85,163.06 273.85,164.58 278.93,169.66 278.93,172.2 279.44,172.71 279.44,180.84 279.94,181.34 280.45,181.34 282.48,183.38 282.48,184.39 284.01,185.92 284.01,186.42 B08.H2 | v273.85,133.59 273.85,132.07 268.77,126.99 268.77,126.48 266.74,124.45 266.74,119.88 259.62,112.76 257.59,112.76 256.07,111.24 C10.M2
  Route15 0.254: v280.96,77.71 v275.37,83.3 | v271.82,92.44 257.59,106.67 257.59,109.21 256.07,110.73 C10.M2 | v265.21,143.75 265.21,142.23 v273.85,133.59
  Bottom 0.254: v310.42,55.87 310.93,56.38 310.93,61.46 v310.42,61.96 | v287.06,72.63 284.52,75.17 280.96,75.17 v280.96,77.71 | v275.37,83.3 274.36,84.32 274.36,86.35 272.83,87.87 272.83,91.43 v271.82,92.44 | v267.75,146.29 v267.75,153.4
XOR_TO_LPB  (via drill 0.61)
  Top 0.254: v234.73,75.68 249.97,75.68 v250.48,76.19 | C10.S2 255.05,98.03 255.05,95.49 253.02,95.49 C10.T2
  Bottom 0.254: 254.04,125.46 253.02,126.48 C10.F2 | 254.04,125.46 255.56,125.46 255.56,129.53 C10.E2 | v234.73,75.68 232.19,73.14 232.19,50.79 231.68,50.28 231.68,36.56 230.67,35.55 D12.P2 | v250.48,76.19 250.99,76.7 250.99,90.41 252.51,91.94 252.51,94.48 C10.T2 | 254.04,125.46 254.04,100.57 255.56,99.05 C10.S2
XSA_DY  (via drill 0.61)
  Top 0.254: v155.99,150.86 156.5,150.36 196.63,150.36 v197.14,150.86 | v282.48,281.42 281.98,281.93 276.39,281.93 275.37,280.91 260.13,280.91 v259.62,281.42 | v255.56,267.2 254.54,268.21 250.99,268.21 v249.97,267.2 | v244.38,272.78 242.86,274.31 231.68,274.31 v231.18,273.8 | v230.16,265.16 220,265.16 219.49,265.67 218.48,265.67 217.97,265.16 v214.41,265.16 | v212.38,244.84 210.35,242.81 204.25,242.81 v203.24,241.8
  Route2 0.254: v255.56,267.2 v258.61,264.15
  Bottom 0.254: v155.99,150.86 155.99,117.84 158.53,115.3 158.53,97.02 157.52,96 C17.T2 | v197.14,150.86 197.14,173.22 198.16,174.23 198.16,176.77 B14.L2 199.17,177.79 200.19,178.8 200.19,189.47 203.24,192.52 203.24,197.09 204.25,198.11 204.25,201.66 204.76,202.17 B14.B1 205.27,203.19 206.28,204.2 206.28,229.1 203.24,232.14 v203.24,241.8 | v282.48,281.42 282.48,272.28 281.98,271.77 281.98,267.7 281.47,267.2 A08.D2 | v259.62,281.42 260.13,280.91 260.13,265.67 v258.61,264.15 | v249.97,267.2 250.48,267.7 250.48,270.75 249.46,271.77 244.38,271.77 v244.38,272.78 | v231.18,273.8 231.68,273.29 231.68,266.69 v230.16,265.16 | v214.41,265.16 212.89,265.16 212.89,245.35 v212.38,244.84
XSAD  (via drill 0.61)
  Top 0.254: v269.28,247.38 267.24,249.42 245.4,249.42 244.38,248.4 240.83,248.4 240.32,247.89 A11.L2
  Bottom 0.254: v269.28,247.38 269.78,246.88 269.78,240.78 271.31,239.26 271.31,235.7 A09.R1
XSAD\  (via drill 0.61)
  Top 0.254: v171.23,50.28 170.22,51.3 v165.64,51.3 | v157.01,67.55 155.48,67.55 154.98,68.06 v142.28,68.06 | v140.75,87.36 129.07,87.36 v128.56,87.87 | v122.97,125.46 123.48,124.96 127.04,124.96 133.64,131.56 144.31,131.56 v144.82,131.05 | v191.04,217.41 191.55,216.9 197.14,216.9 197.65,217.41 v205.27,217.41
  Route2 0.254: v144.82,131.05 149.39,135.62 149.39,141.21 152.44,144.26 152.44,145.28 v160.06,152.9 | v164.12,181.34 165.14,181.34 166.15,182.36 167.68,182.36 174.79,189.47 174.79,190.49 176.31,192.01 177.33,192.01 190.54,205.22 190.54,207.25 v191.04,207.76 | v205.27,217.41 205.27,218.94 210.86,224.52 211.36,224.52 211.87,225.03 211.87,226.05 223.56,237.73 227.62,237.73 229.65,239.76 234.22,239.76 241.34,246.88 241.34,249.42 242.35,250.43 A11.K2
  Route15 0.254: v208.82,44.69 208.32,44.69 v205.78,47.23 | v199.17,54.34 197.14,54.34 v194.6,56.88 | v176.82,31.99 v174.28,34.53 | v162.6,60.44 162.6,61.96 v157.01,67.55
  Bottom 0.254: v208.82,44.69 210.86,44.69 D13.L2 | v205.78,47.23 199.17,53.84 v199.17,54.34 | v194.6,56.88 193.58,55.87 193.58,30.98 189.52,26.91 178.85,26.91 178.85,29.96 v176.82,31.99 | v174.28,34.53 170.72,34.53 170.72,40.63 171.74,41.64 171.74,49.77 v171.23,50.28 | v165.64,51.3 162.09,54.85 162.09,59.93 v162.6,60.44 | v142.28,68.06 142.78,68.57 142.78,73.65 140.75,75.68 v140.75,87.36 | v128.56,87.87 123.99,92.44 123.48,92.44 123.48,124.96 v122.97,125.46 | v160.06,152.9 161.58,154.42 161.58,172.71 165.14,176.26 165.14,179.31 164.12,180.33 v164.12,181.34 | v191.04,207.76 v191.04,217.41
XSTA  (via drill 0.61)
  Top 0.254: D13.N2 211.36,38.6 213.4,40.63 213.9,40.63 D13.M2 214.92,41.14 216.44,41.14 218.48,39.1 222.03,39.1 222.54,39.61 243.88,39.61 245.4,38.09 D11.N1 246.42,38.6 247.43,39.61 258.1,39.61 261.15,42.66 276.9,42.66 v277.4,42.15 | C04.E1 343.95,130.54 339.89,130.54 338.36,132.07 295.69,132.07 294.68,133.08 294.17,133.08 C07.D2 | v276.9,112.76 288.58,112.76 289.6,113.78 293.15,113.78 C07.L2
  Bottom 0.254: C07.H1 303.31,124.45 303.31,128 301.28,130.04 301.28,138.16 300.26,139.18 C07.B1 300.26,140.2 300.26,149.34 298.74,150.86 298.74,163.56 | B07.D2 293.15,196.08 293.15,192.01 292.14,191 292.14,178.8 293.15,177.79 B07.L2 293.66,176.77 293.66,173.22 295.69,171.18 295.69,162.55 296.2,162.04 B07.S2 | 298.74,163.56 297.22,162.04 B07.S2 | 298.74,163.56 298.74,165.6 300.26,167.12 300.26,170.68 B07.N1 299.76,171.69 298.74,172.71 298.74,173.72 | 298.74,173.72 298.74,201.16 299.76,202.17 B07.B1 | 298.74,173.72 301.79,176.77 301.79,181.34 303.31,182.87 303.31,186.42 B07.H1 | D13.P2 213.9,35.55 213.9,40.63 D13.M2 | C07.L2 293.66,114.8 293.66,118.35 295.18,119.88 295.18,129.53 293.66,131.05 293.66,132.58 C07.D2 293.66,134.1 293.66,137.66 295.18,139.18 295.18,159.5 296.71,161.02 B07.S2 | v277.4,42.15 277.4,51.3 277.91,51.8 277.91,96 277.4,96.51 277.4,112.26 v276.9,112.76
XSTA\  (via drill 0.61)
  Top 0.254: 209.84,49.26 210.86,50.28 D13.J2 | 209.84,49.26 209.84,47.74 213.9,47.74 D13.K2 | D14.L2 199.17,45.2 199.17,47.23 201.2,47.23 D14.K2 202.22,48.25 205.78,48.25 206.79,49.26 209.84,49.26 | v180.88,40.63 177.33,40.63 176.82,41.14 D16.M2 | v184.44,40.63 186.47,42.66 197.65,42.66 v198.16,42.15 | v326.68,129.53 327.7,128.51 335.82,128.51 336.33,128 340.4,128 340.9,127.5 C04.F1 | 301.79,163.56 281.98,163.56 281.47,164.07 B08.R2 | 301.79,163.56 v321.6,163.56 | v246.42,80.25 v262.16,80.25 | v261.66,89.9 v259.12,92.44 | v264.7,98.03 266.23,99.56 267.75,99.56 268.26,100.06 269.28,100.06 v269.78,99.56 | v270.29,103.11 273.85,106.67 v273.85,108.19 | v288.58,124.45 289.6,125.46 295.18,125.46 298.23,128.51 v301.28,128.51 | v301.79,164.07 301.79,163.56
  Route2 0.254: v180.88,40.63 182.41,39.1 182.92,39.61 183.42,39.61 v184.44,40.63 | v243.37,69.58 234.22,60.44 232.7,60.44 227.62,55.36 219.49,55.36 216.44,52.31 214.92,53.84 D13.H2 | v259.12,92.44 v264.7,98.03 | v273.85,108.19 277.91,112.26 277.91,113.27 286.04,121.4 286.04,121.91 v288.58,124.45
  Route15 0.254: v301.28,128.51 301.28,132.07 301.79,132.58 301.79,133.59 v302.8,134.61
  Bottom 0.254: D13.K2 213.9,48.25 213.9,53.33 D13.H2 | D16.N2 173.77,38.09 175.8,40.12 175.8,40.63 D16.M2 | v198.16,42.15 198.66,42.66 198.66,43.68 D14.L2 | v326.68,129.53 324.14,132.07 324.14,143.75 321.09,146.8 321.09,163.06 v321.6,163.56 | v243.37,69.58 245.4,71.62 246.42,71.62 v246.42,80.25 | v262.16,80.25 263.18,81.27 263.18,86.86 261.66,88.38 v261.66,89.9 | v269.78,99.56 270.29,100.06 v270.29,103.11 | v302.8,134.61 301.79,135.62 v301.79,164.07

## Text on the board
Top: 1 | A
Bottom: A
tPlace: 28 | 27 | 26 | 25 | 24 | 23 | 22 | 21 | 20 | 19 | 18 | 17 | 16 | 15 | 14 | 13 | 12 | 11 | 10 | 9 | 8 | 7 | 6 | 5 | 4 | 3 | 2 | 1 | Rip Up NC | Fix G821 connections | Fold in ECOs. | A | B | C | D
bPlace: A | B | C | D | 11 | 28 | 27 | 26 | 25 | 24 | 23 | 22 | 21 | 20 | 19 | 18 | 17 | 16 | 15 | 14 | 13 | 12 | 10 | 9 | 8 | 7 | 6 | 5 | 4 | 3 | 2 | 1