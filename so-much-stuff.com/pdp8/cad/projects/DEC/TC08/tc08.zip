# EAGLE board tc08 (EAGLE 4.11), part 4 of 10
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
EF  (via drill 0.61)
  Top 0.254: v54.39,279.9 54.9,279.39 84.36,279.39 84.87,279.9 124.5,279.9 126.02,281.42 142.28,281.42 142.78,281.93 145.83,281.93 146.34,281.42 172.76,281.42 173.26,280.91 198.16,280.91 198.66,281.42 223.05,281.42 224.06,282.44 v232.19,282.44 | A11.J1 245.4,253.99 243.88,252.46 240.32,252.46 236.26,248.4 233.72,248.4 A12.L1
  Bottom 0.254: v54.39,279.9 54.39,242.81 55.41,241.8 A25.N1 | v232.19,282.44 232.19,262.12 233.21,261.1 A12.F1 233.21,259.58 233.21,256.53 234.73,255 234.73,249.42 233.72,248.4 A12.L1
EF\  (via drill 0.61)
  Top 0.254: v335.82,231.64 335.32,232.14 333.79,232.14 333.28,232.65 333.28,236.72 339.38,236.72 v339.89,237.22 | v337.86,292.6 337.35,292.09 v304.33,292.09 | v266.74,260.59 v269.78,260.59 | v265.72,257.04 264.7,256.02 263.18,256.02 262.67,255.51 257.59,255.51 256.07,253.99 v255.56,253.99
  Route2 0.254: v255.56,253.99 255.56,253.48 253.02,250.94 249.97,250.94 A11.K1
  Route15 0.254: v334.81,225.54 344.97,215.38 344.97,206.74 B04.A1 | v339.89,237.22 341.41,238.75 v338.87,241.29
  Bottom 0.254: v334.81,225.54 336.33,227.06 336.33,231.13 v335.82,231.64 | v338.87,241.29 339.38,241.8 339.38,268.72 339.89,269.23 339.89,270.75 339.38,271.26 339.38,291.07 v337.86,292.6 | v304.33,292.09 299.25,297.17 275.88,297.17 275.88,274.31 272.83,271.26 272.83,264.15 269.78,261.1 v269.78,260.59 | v266.74,260.59 266.74,259.58 265.72,258.56 v265.72,257.04
END  (via drill 0.61)
  Top 0.254: v69.12,221.98 68.62,221.98 67.09,223.51 57.44,223.51 53.88,227.06 50.84,227.06 50.84,232.14 51.85,233.16 61,233.16 61,235.7 60.49,236.21 56.42,236.21 55.92,235.7 A25.R1 | v74.71,218.94 75.73,217.92 100.11,217.92 v101.13,218.94 | v221.52,288.53 223.56,286.5 v229.65,286.5 | v228.13,281.42 v233.21,281.42
  Route2 0.254: v69.12,221.98 73.19,217.92 74.2,218.94 v74.71,218.94 | v101.13,218.94 109.76,218.94 110.78,219.95 114.34,219.95 117.89,223.51 123.48,223.51 134.15,234.18 v134.66,234.18 | v203.74,292.09 214.41,281.42 v221.52,288.53 | v233.21,281.42 237.78,281.42 240.32,278.88 240.83,279.39 269.28,279.39 272.83,282.94 276.9,282.94 282.48,277.36 282.48,274.31 285.02,271.77 286.55,271.77 290.1,268.21 289.09,267.2 289.09,265.16 290.1,264.15 A08.E1
  Route15 0.254: v193.58,295.64 194.09,295.64 195.11,294.63 196.12,294.63 v198.66,292.09
  Bottom 0.254: v134.66,234.18 136.69,234.18 136.69,241.8 139.74,244.84 139.74,284.98 142.78,288.02 142.78,289.55 148.88,295.64 v193.58,295.64 | v203.74,292.09 v198.66,292.09 | v229.65,286.5 228.13,284.98 v228.13,281.42
END\  (via drill 0.61)
  Top 0.254: v263.69,244.34 267.75,244.34 A09.M2 | v262.67,259.07 286.55,259.07 287.06,259.58 A08.F1 | v316.01,216.9 315,217.92 294.68,217.92 v294.17,217.41 | v288.07,226.05 287.06,227.06 v275.88,227.06 | v275.88,239.26 275.37,239.76 v269.28,239.76
  Route15 0.254: v339.38,196.08 339.38,196.58 333.79,202.17 333.79,204.2 330.74,207.25 328.2,207.25 325.16,210.3 322.62,210.3 v316.01,216.9
  Bottom 0.254: v263.69,244.34 263.18,244.84 263.18,245.35 262.67,245.86 262.67,249.42 263.18,249.92 263.18,258.56 v262.67,259.07 | v339.38,196.08 339.38,192.52 340.9,191 B04.F1 | v294.17,217.41 293.66,217.92 293.66,219.95 288.07,225.54 v288.07,226.05 | v275.88,227.06 276.39,227.57 276.39,238.75 v275.88,239.26 | v269.28,239.76 268.77,240.27 268.77,243.83 A09.M2
ENI  (via drill 0.61)
  Top 0.254: v263.69,238.75 262.67,239.76 257.08,239.76 256.07,240.78 v254.04,240.78 | v58.46,282.94 v49.82,282.94 | v48.8,280.4 48.3,279.9 v42.71,279.9 | v39.66,279.9 36.1,283.45 v30.52,283.45 | v31.02,296.15 31.53,296.66 120.43,296.66 v121.45,295.64 | v141.77,288.53 142.28,288.02 v157.01,288.02 | v186.98,270.75 187.49,271.26 210.35,271.26 v210.86,270.75 | v234.22,257.04 236.26,257.04 A12.H1
  Route2 0.254: v315.5,150.86 310.42,145.78 309.41,145.78 304.84,141.21 304.84,122.92 300.26,118.35 300.26,114.8 C07.L1 | v210.86,270.75 211.36,270.75 215.43,274.82 222.03,274.82 226.1,270.75 225.59,270.24 225.59,266.18 230.67,261.1 231.68,262.12 232.7,262.12 v233.21,262.62
  Route15 0.254: v315.5,150.86 315.5,151.37 314.49,152.39 314.49,153.4 312.46,155.44 312.46,156.45 311.44,157.47 311.44,175.25 310.93,175.76 310.93,188.46 307.88,191.5 307.88,193.54 306.36,195.06 305.85,195.06 304.33,196.58 304.33,197.09 303.31,198.11 302.8,198.11 301.79,199.12 301.79,204.2 299.76,206.24 299.76,206.74 299.25,207.25 298.23,207.25 281.98,223.51 280.96,223.51 274.36,230.11 273.85,230.11 v268.26,235.7 | v254.04,240.78 252,238.75 250.99,238.75 244.38,245.35 244.38,247.38 238.29,253.48 238.29,255 236.76,256.53 A12.H1
  Bottom 0.254: v268.26,235.7 266.23,235.7 266.23,236.21 265.21,237.22 263.69,237.22 v263.69,238.75 | v58.46,282.94 58.46,281.93 59.98,280.4 59.98,268.72 57.44,266.18 57.44,249.92 55.92,248.4 A25.L1 | v49.82,282.94 48.8,281.93 v48.8,280.4 | v42.71,279.9 v39.66,279.9 | v30.52,283.45 31.02,283.96 v31.02,296.15 | v121.45,295.64 134.15,295.64 141.26,288.53 v141.77,288.53 | v157.01,288.02 157.01,289.55 157.52,290.06 186.98,290.06 v186.98,270.75 | v233.21,262.62 234.73,262.62 234.73,257.54 v234.22,257.04
ENI\  (via drill 0.61)
  Top 0.254: v315.5,121.91 314.49,121.91 314.49,113.78 313.47,112.76 308.9,112.76 308.39,112.26 304.84,112.26 303.82,111.24 C07.M1
  Route2 0.254: v315.5,121.91 312.96,124.45 313.98,125.46 313.98,131.05 321.09,138.16 323.12,138.16 324.14,139.18 324.14,140.7 326.17,142.74 326.17,144.26 327.19,145.28 327.7,145.28 328.2,145.78 328.2,147.82 339.89,159.5 339.89,160.01 340.9,161.02 341.41,161.02 341.92,161.53 341.92,163.56 342.94,164.58 342.94,169.66 343.44,170.17 343.44,171.18 345.98,173.72 345.98,175.76 347.51,177.28 B03.L2
FR_00  (via drill 0.61)
  Top 0.254: v57.44,287.52 57.95,287.01 63.54,287.01 64.04,286.5 65.06,286.5 65.57,285.99 100.62,285.99 101.64,287.01 116.37,287.01 117.89,288.53 140.24,288.53 142.28,290.56 159.04,290.56 159.55,290.06 160.56,290.06 161.58,289.04 209.33,289.04 v209.84,289.55 | v221.02,196.08 222.03,195.06 227.62,195.06 229.14,196.58 v229.65,196.58 | v299.76,162.04 302.8,162.04 B07.S1 | v287.56,169.15 273.34,169.15 v272.32,168.14 | v268.77,164.58 267.24,164.58 266.23,163.56 v243.88,163.56 | v236.76,170.68 234.73,172.71 v231.18,172.71
  Route2 0.254: v268.77,164.58 v272.32,168.14
  Route15 0.254: v213.9,202.68 214.41,202.68 v221.02,196.08 | v299.76,162.04 298.74,162.04 290.1,170.68 289.09,170.68 v287.56,169.15 | v236.76,170.68 v243.88,163.56
  Bottom 0.254: 231.68,172.71 231.68,188.46 230.16,189.98 230.16,193.03 B12.E2 230.16,194.04 230.16,196.08 v229.65,196.58 | 231.68,172.71 231.68,98.03 230.67,97.02 230.67,92.44 C12.U2 | v57.44,287.52 57.44,271.26 56.93,270.75 56.93,262.12 55.92,261.1 A25.F1 | v209.84,289.55 209.84,220.97 210.86,220.97 210.86,216.9 210.35,216.4 210.35,206.24 v213.9,202.68 | 231.68,172.71 v231.18,172.71
FR_00\  (via drill 0.61)
  Top 0.254: 302.8,153.91 302.8,152.39 304.33,152.39 305.34,153.4 308.9,153.4 v309.41,152.9 | 302.8,153.91 302.8,154.93 B07.U1 | v309.92,147.31 310.42,147.82 351.06,147.82 v351.57,147.31 | v351.57,171.69 353.6,171.69 B03.N1 | v248.96,120.38 250.48,121.91 252,121.91 v253.02,122.92 | v284.01,153.4 284.52,153.91 287.06,153.91 289.6,156.45 291.63,156.45 v293.66,154.42 | 302.8,153.91 v299.76,153.91
  Route2 0.254: v248.96,120.38 247.43,118.86 242.35,118.86 240.83,117.34 236.76,117.34 C12.K1 | v253.02,122.92 253.02,123.43 273.85,144.26 275.37,144.26 284.01,152.9 v284.01,153.4 | v293.66,154.42 295.18,154.42 296.71,152.9 298.74,152.9 v299.76,153.91
  Bottom 0.254: C12.P1 235.75,105.14 234.73,106.16 234.73,112.76 235.75,113.78 235.75,116.83 C12.K1 | v309.41,152.9 309.92,152.39 v309.92,147.31 | v351.57,147.31 352.08,147.82 352.08,171.18 v351.57,171.69
FR_01  (via drill 0.61)
  Top 0.254: D07.V2 293.66,18.28 291.12,15.74 281.98,15.74 281.47,16.24 264.7,16.24 264.2,15.74 v236.76,15.74 236.26,15.23 232.19,15.23 231.68,14.72 230.67,14.72 230.16,14.21 227.11,14.21 226.6,13.7 211.87,13.7 v211.36,14.21 | v196.63,134.1 193.08,134.1 192.57,133.59 C15.D1 | 171.74,255.51 253.02,255.51 253.53,256.02 255.05,256.02 255.56,255.51 256.58,255.51 257.08,256.02 261.15,256.02 261.66,256.53 A10.H1 | 171.74,255.51 153.96,255.51 153.45,256.02 149.9,256.02 149.39,255.51 141.26,255.51 140.75,256.02 137.2,256.02 136.69,255.51 121.45,255.51 120.94,256.02 119.92,256.02 119.42,255.51 61,255.51 59.47,257.04 A25.H1 | v195.11,178.3 194.6,178.8 v191.04,178.8 | v171.74,255 171.74,255.51 | v196.12,17.77 195.62,17.26 184.44,17.26 183.42,16.24 138.21,16.24 134.15,20.31 128.56,20.31 v127.04,21.83 | v119.92,123.43 117.89,125.46 v117.89,129.53 | v121.45,150.36 v129.07,150.36 | v130.08,158.48 130.08,160.01 173.77,160.01 174.28,159.5 176.31,159.5 v178.85,162.04
  Route15 0.254: v182.92,189.98 v188.5,184.39 | v179.36,198.62 179.36,199.12 v176.31,202.17
  Bottom 0.254: v236.76,15.74 235.24,17.26 235.24,25.9 233.21,27.93 233.21,30.98 D12.R1 | B07.V2 293.66,151.37 292.64,150.36 292.64,140.7 292.14,140.2 292.14,85.84 293.66,84.32 293.66,72.12 292.14,70.6 292.14,24.88 293.66,23.36 293.66,19.8 D07.V2 | v196.63,134.1 197.14,134.61 197.14,149.34 196.12,150.36 196.12,153.91 196.63,154.42 196.63,172.71 195.62,173.72 B15.M1 195.11,174.74 v195.11,178.3 | v191.04,178.8 190.54,179.31 190.54,182.36 v188.5,184.39 | 181.39,191.5 v182.92,189.98 | 181.39,191.5 181.39,196.58 v179.36,198.62 | v176.31,202.17 174.79,203.7 174.79,205.73 171.23,209.28 171.23,243.32 174.28,246.37 174.28,248.91 173.77,249.42 172.76,249.42 172.76,251.96 171.74,252.97 v171.74,255 | v211.36,14.21 211.36,12.69 201.71,3.04 196.12,3.04 v196.12,17.77 | v127.04,21.83 123.99,24.88 123.99,55.36 120.94,58.41 120.94,59.42 117.89,62.47 117.89,121.91 119.42,123.43 v119.92,123.43 | v117.89,129.53 116.37,131.05 116.37,141.72 121.45,146.8 v121.45,150.36 | v129.07,150.36 129.07,153.91 130.08,154.93 v130.08,158.48 | v178.85,162.04 181.39,164.58 181.39,191.5
FR_01\  (via drill 0.61)
  Top 0.254: v308.9,150.86 305.34,150.86 304.33,151.88 300.77,151.88 B07.V1 | v341.92,198.62 343.44,197.09 347,197.09 B03.D2 | v337.35,197.09 336.33,196.08 336.33,195.57 326.68,195.57 325.16,194.04 322.62,194.04 B05.E2 | v239.81,256.53 239.3,256.53 237.27,258.56 231.68,258.56 230.67,257.54 A12.H2 | v252.51,245.35 253.02,245.86 262.67,245.86 263.18,245.35 v264.7,245.35 | v292.14,223 292.14,220.46 300.77,220.46 v301.28,219.95
  Route2 0.254: v310.42,197.09 310.93,197.09 311.95,198.11 319.57,198.11 323.12,194.55 322.62,194.04 B05.E2
  Route15 0.254: v239.81,256.53 247.43,248.91 248.96,248.91 v252.51,245.35 | v264.7,245.35 265.21,245.35 273.85,236.72 276.9,236.72 279.94,233.67 280.96,233.67 282.48,232.14 282.48,230.11 287.56,225.03 288.58,225.03 289.6,224.02 291.12,224.02 v292.14,223 | v303.31,204.2 304.84,202.68 304.84,202.17 309.92,197.09 v310.42,197.09
  Bottom 0.254: v308.9,150.86 308.39,151.37 308.39,194.55 310.42,194.55 v310.42,197.09 | v341.92,198.62 337.35,198.62 v337.35,197.09 | v301.28,219.95 300.77,219.44 300.77,206.24 302.8,204.2 v303.31,204.2
FR_02  (via drill 0.61)
  Top 0.254: v296.71,8.12 299.25,8.12 300.26,7.1 334.81,7.1 335.32,6.59 v336.84,6.59 | v340.9,41.14 339.38,42.66 v330.24,42.66 | v314.49,79.24 315.5,80.25 315.5,84.82 v314.49,84.82 | v46.26,255.51 49.82,255.51 50.33,255 53.88,255 54.9,253.99 A25.J1 | v47.28,230.62 46.77,230.11 44.74,230.11 44.23,230.62 41.69,230.62 34.07,223 v33.56,223 | v33.06,208.27 32.55,208.78 19.34,208.78 18.32,207.76 5.12,207.76 v2.07,204.71 | v3.08,28.94 11.72,20.31 50.84,20.31 60.49,10.66 v107.22,10.66 | v108.24,21.32 108.75,20.82 v123.48,20.82 | v171.23,21.83 172.25,22.85 174.79,22.85 175.8,23.86 178.85,23.86 v180.88,21.83 | v184.95,21.83 185.96,22.85 187.49,22.85 188.5,23.86 191.55,23.86 195.11,20.31 195.11,19.29 196.63,19.29 197.65,20.31 v201.2,20.31 | v263.18,11.67 v274.36,11.67
  Route2 0.254: v180.88,21.83 182.92,19.8 v184.95,21.83 | v201.2,20.31 206.79,20.31 221.52,5.58 257.08,5.58 v263.18,11.67 | v274.36,11.67 276.9,9.13 278.93,11.16 282.99,11.16 293.66,21.83 296.2,21.83 D07.U2
  Route15 0.254: v330.24,48.76 330.24,49.26 320.58,58.92 320.58,73.14 v314.49,79.24 | v314.49,84.82 311.44,87.87 311.44,117.84 305.85,123.43 305.85,125.46 304.84,126.48 304.84,128 303.31,129.53 C07.E1
  Bottom 0.254: v296.71,8.12 296.71,21.83 D07.U2 | v336.84,6.59 345.48,15.23 345.48,20.82 345.98,21.32 345.98,29.45 342.94,32.5 342.94,39.1 v340.9,41.14 | v330.24,42.66 v330.24,48.76 | v46.26,255.51 44.74,253.99 44.74,249.42 46.77,247.38 46.77,245.86 47.28,245.35 v47.28,230.62 | v33.56,223 33.06,222.49 v33.06,208.27 | v2.07,204.71 1.56,204.2 1.56,30.47 v3.08,28.94 | v107.22,10.66 108.24,11.67 v108.24,21.32 | v123.48,20.82 123.99,20.31 123.99,16.24 128.05,12.18 128.05,10.15 129.58,8.62 158.53,8.62 158.53,9.13 v171.23,21.83
FR_02\  (via drill 0.61)
  Top 0.254: v302.8,133.08 304.33,134.61 308.39,134.61 309.41,133.59 310.42,133.59 312.46,135.62 v312.96,135.62 | v344.97,191 345.98,192.01 349.54,192.01 350.56,193.03 B03.E2
  Route2 0.254: v302.8,133.08 v300.26,130.54 | v312.96,135.62 316.01,138.67 316.52,138.67 317.03,139.18 317.03,140.7 330.24,153.91 330.24,169.15 338.36,177.28 338.87,177.28 339.38,177.79 339.38,179.31 345.98,185.92 345.98,189.98 v344.97,191
  Bottom 0.254: v300.26,130.54 300.26,127.5 C07.F1
FR_03  (via drill 0.61)
  Top 0.254: v294.17,123.94 296.2,123.94 C07.H2 | v291.12,120.89 291.12,118.86 294.17,115.81 v297.72,115.81 | v287.56,92.95 290.1,90.41 293.15,90.41 294.17,91.43 295.18,91.43 296.2,90.41 300.77,90.41 301.79,89.4 301.79,87.87 v302.8,87.87 | v293.66,54.85 294.17,55.36 297.72,55.36 298.23,54.85 298.23,52.31 293.15,52.31 292.14,51.3 292.14,48.25 293.66,48.25 295.69,46.22 295.69,39.1 296.2,39.1 v297.22,38.09 | v300.77,27.42 302.8,25.39 302.8,23.86 300.26,21.32 300.26,19.8 D07.V1 | v59.98,235.19 58.46,233.67 48.8,233.67 48.3,233.16 42.71,233.16 42.2,232.65 41.18,232.65 40.68,233.16 38.64,233.16 v36.61,231.13 | v38.14,197.6 53.38,182.36 66.08,182.36 | 66.08,182.36 101.13,182.36 107.22,176.26 129.58,176.26 v131.1,174.74 | v133.64,166.1 134.15,166.61 151.93,166.61 153.96,164.58 155.48,164.58 156.5,163.56 165.14,163.56 167.68,166.1 174.28,166.1 176.82,163.56 180.38,163.56 181.39,164.58 185.46,164.58 B15.R2 | v300.26,8.62 299.76,9.13 286.55,9.13 v286.04,8.62 | v230.16,23.86 229.65,23.36 229.14,23.36 228.64,22.85 222.54,22.85 v221.52,23.86 | v211.36,42.15 210.86,42.66 201.2,42.66 v200.19,41.64 | v198.66,29.45 196.12,26.91 151.42,26.91 147.86,30.47 v135.16,30.47 | v133.64,45.2 132.62,46.22 v78.78,46.22 | v66.08,178.8 66.08,182.36
  Route2 0.254: v291.12,120.89 v294.17,123.94 | v287.56,92.95 v300.26,105.65 | v302.8,80.25 307.88,75.17 302.8,70.09 302.8,68.57 298.74,64.5 298.74,59.93 v293.66,54.85 | v215.43,38.09 v211.36,42.15
  Route15 0.254: v299.76,35.55 v297.22,38.09 | v275.88,18.78 v286.04,8.62 | v247.43,21.83 245.91,20.31 244.38,20.31 243.88,20.82 240.32,20.82 237.27,23.86 233.72,23.86 232.19,22.34 230.67,23.86 v230.16,23.86
  Bottom 0.254: v297.72,115.81 298.74,114.8 298.74,111.75 301.28,109.21 301.28,106.67 v300.26,105.65 | v302.8,80.25 v302.8,87.87 | v299.76,35.55 299.76,34.02 300.77,33.01 301.28,33.01 301.28,27.93 v300.77,27.42 | v59.98,235.19 60.49,235.7 60.49,249.42 59.47,250.43 A25.K1 | v36.61,231.13 37.12,230.62 37.12,230.11 38.14,229.1 v38.14,197.6 | v131.1,174.74 133.64,172.2 v133.64,166.1 | v300.26,8.62 300.26,18.28 D07.V1 | v275.88,18.78 269.78,12.69 259.12,12.69 259.12,11.16 256.07,8.12 250.99,8.12 250.99,11.16 250.48,11.67 250.48,18.78 v247.43,21.83 | v221.52,23.86 217.97,27.42 216.44,27.42 216.44,30.47 215.94,30.98 215.94,37.58 v215.43,38.09 | v200.19,41.64 200.19,30.98 v198.66,29.45 | v135.16,30.47 133.64,31.99 v133.64,45.2 | v78.78,46.22 63.54,61.46 63.54,142.74 66.58,145.78 66.58,178.3 v66.08,178.8
FR_03\  (via drill 0.61)
  Top 0.254: v296.71,121.4 294.68,121.4 294.17,120.89 C07.J2 | v302.3,125.46 307.88,125.46 v308.9,126.48 | v318.55,144.26 319.57,145.28 325.66,145.28 v326.68,146.29 | v327.7,160.01 332.78,160.01 333.28,160.52 354.62,160.52 | 354.62,160.52 v358.18,160.52 | v358.18,169.66 358.18,173.72 358.68,173.72 358.68,179.31 355.13,179.31 v354.62,179.82 | v267.75,182.87 268.77,183.88 270.29,183.88 270.29,182.87 270.8,182.36 279.44,182.36 280.45,183.38 B08.J2 | v279.94,201.66 v284.52,201.66 | v279.44,218.43 281.98,218.43 283.5,219.95 290.61,219.95 292.14,218.43 304.84,218.43 309.92,223.51 329.73,223.51 v330.24,223 | v330.24,225.03 330.74,224.52 336.84,224.52 337.35,224.02 v391.7,224.02 | v391.2,160.52 365.29,160.52 362.24,157.47 357.67,157.47 354.62,160.52
  Route2 0.254: v309.92,134.61 315,139.69 315,140.2 316.52,141.72 317.03,141.72 317.54,142.23 317.54,143.24 v318.55,144.26 | v267.75,182.87 268.77,183.88 269.78,183.88 270.29,184.39 270.29,184.9 275.37,189.98 275.88,189.98 276.39,190.49 276.39,194.55 282.99,201.16 284.01,201.16 v284.52,201.66
  Route15 0.254: v354.62,179.82 352.59,179.82 351.57,180.84 B03.K2
  Bottom 0.254: v296.71,121.4 299.25,123.94 299.25,124.96 299.76,125.46 v302.3,125.46 | v308.9,126.48 308.39,126.99 308.39,133.08 v309.92,134.61 | v326.68,146.29 327.19,146.8 327.19,159.5 v327.7,160.01 | v358.18,160.52 358.68,161.02 358.68,169.15 v358.18,169.66 | v279.94,201.66 279.44,202.17 v279.44,218.43 | v330.24,223 v330.24,225.03 | v391.7,224.02 392.21,223.51 392.21,201.16 390.69,199.63 390.69,199.12 390.18,198.62 390.18,187.95 391.7,186.42 391.7,170.68 390.69,169.66 390.69,161.02 v391.2,160.52
GND  (via drill 0.61)
  Top 0.635: C01.T1 379,95.49 378.5,96 374.94,96 373.92,97.02 370.88,97.02 369.35,95.49 367.32,95.49 C02.T1 366.3,95.49 365.29,96.51 361.73,96.51 361.22,97.02 358.18,97.02 356.65,95.49 354.62,95.49 C03.T1 353.6,95.49 351.06,95.49 349.54,97.02 346.49,97.02 345.98,96.51 342.94,96.51 341.92,95.49 C04.T1 340.9,95.49 338.36,95.49 336.84,97.02 333.79,97.02 332.27,95.49 326.17,95.49 C05.T1 325.16,94.48 324.65,93.97 320.58,93.97 320.08,93.46 318.04,93.46 317.03,94.48 312.96,94.48 C06.T1 312.46,96 308.39,96 307.38,97.02 304.33,97.02 302.8,95.49 300.77,95.49 C07.T1 299.76,94.48 295.69,94.48 294.68,93.46 292.64,93.46 292.14,93.97 289.09,93.97 288.07,94.98 C08.T1 287.06,95.49 283.5,95.49 281.47,97.52 278.42,97.52 | CD18.AT1 151.42,95.49 152.44,96.51 155.48,96.51 155.99,97.02 159.04,97.02 160.56,95.49 163.1,95.49 C17.T1 164.12,95.49 164.63,96 171.23,96 172.25,97.02 175.3,97.02 176.82,95.49 178.85,95.49 C16.T1 179.87,95.49 180.38,96 183.93,96 184.95,97.02 188,97.02 189.52,95.49 191.55,95.49 C15.T1 192.57,95.49 196.12,95.49 197.65,97.02 199.68,97.02 200.19,96.51 203.24,96.51 204.25,95.49 C14.T1 205.27,95.49 206.28,96.51 209.84,96.51 210.35,97.02 213.4,97.02 214.92,95.49 216.95,95.49 C13.T1 217.97,95.49 222.03,95.49 223.56,97.02 227.62,97.02 228.64,96 232.7,96 C12.T1 233.72,95.49 237.27,95.49 238.8,97.02 241.84,97.02 243.37,95.49 245.4,95.49 C11.T1 246.42,94.48 250.48,94.48 251.5,93.46 253.53,93.46 254.54,94.48 257.59,94.48 258.1,94.98 C10.T1 259.12,94.48 263.18,94.48 264.2,93.46 266.23,93.46 268.26,95.49 270.8,95.49 C09.T1 271.82,95.49 274.36,95.49 276.39,97.52 278.42,97.52
  Top 0.635: CD18.BT1 151.42,24.88 152.44,23.86 162.09,23.86 163.1,24.88 D17.T1 164.12,24.88 165.14,23.86 174.28,23.86 175.3,24.88 178.85,24.88 D16.T1 179.87,24.88 180.88,23.86 186.98,23.86 188,24.88 191.55,24.88 D15.T1 192.57,25.9 196.63,25.9 197.65,26.91 203.74,26.91 204.76,25.9 D14.T1 205.78,24.88 206.79,23.86 212.38,23.86 213.4,24.88 216.95,24.88 D13.T1 224.57,25.39 226.1,23.86 228.13,23.86 229.65,25.39 D12.T1 D11.T2 D11.T1 246.42,24.88 250.48,24.88 251.5,23.86 253.53,23.86 255.05,25.39 D10.T1 259.12,24.88 260.13,23.86 269.28,23.86 270.8,25.39 D09.T1 271.82,24.88 272.83,23.86 289.6,23.86 | 289.6,23.86 288.07,25.39 D08.T1 | 289.6,23.86 298.74,23.86 299.76,24.88 D07.T1 | D04.F1 341.92,56.88 347,56.88 D03.F2 | D03.L2 347.51,45.2 345.48,47.23 344.97,47.23 D04.K1 | D03.R2 347,31.48 341.92,31.48 D04.R1 340.9,31.99 335.32,31.99 D04.R2 334.3,31.48 331.76,28.94 328.71,28.94 D05.S1 | D04.N1 D03.N2 348.02,37.58 353.6,37.58 D03.N1 D02.N2 360.72,37.58 366.3,37.58 D02.N1 | D03.F1 354.62,56.88 359.7,56.88 D02.F2 360.72,57.39 366.3,57.39 D02.F1 | D03.K1 357.67,47.23 359.7,45.2 360.21,45.2 D02.L2 | D02.K1 369.35,47.74 367.83,49.26 361.73,49.26 360.72,50.28 D02.J2 | D02.R2 359.7,31.48 354.62,31.48 D03.R1 | D05.J2 D05.J1 | D06.F1 313.47,56.88 318.04,56.88 D05.F2 319.57,56.88 324.65,56.88 D05.F1 | D05.M1 328.2,41.64 325.66,44.18 D05.L1 324.65,44.18 319.57,44.18 D05.L2 | D06.K2 309.92,47.74 315.5,47.74 D06.K1 | D06.N1 D05.N2 D05.N1 | D05.R2 318.04,31.48 313.47,31.48 D06.R1 312.46,31.48 306.87,31.48 D06.R2 | D06.T1 312.46,24.88 311.95,24.88 309.92,22.85 D06.U2 308.9,21.83 303.82,21.83 D07.U1
  Top 0.635: CD18.BC2 148.37,66.54 149.9,65.01 154.98,65.01 155.99,66.03 160.06,66.03 D17.C2 161.07,66.54 162.6,65.01 170.22,65.01 171.74,66.54 175.8,66.54 D16.C2 176.82,66.54 177.33,66.03 180.38,66.03 181.39,65.01 183.42,65.01 184.44,66.03 188.5,66.03 D15.C2 189.52,66.54 192.57,66.54 194.09,65.01 196.12,65.01 197.65,66.54 201.2,66.54 D14.C2 202.73,66.54 204.25,65.01 212.89,65.01 213.9,66.03 D13.C2 214.92,66.54 217.97,66.54 219.49,65.01 224.06,65.01 225.59,66.54 229.65,66.54 D12.C2 230.67,66.03 231.68,65.01 237.78,65.01 239.3,66.54 242.35,66.54 D11.C2 243.37,66.03 244.38,65.01 251.5,65.01 253.02,66.54 255.05,66.54 D10.C2 256.07,66.03 257.08,65.01 266.23,65.01 267.75,66.54 D09.C2 268.77,66.03 269.78,65.01 278.93,65.01 279.94,66.03 284.01,66.03 D08.C2 284.52,66.03 285.53,65.01 294.68,65.01 296.2,66.54 D07.C2 297.22,66.03 298.23,65.01 307.38,65.01 308.9,66.54 D06.C2 309.92,66.03 315.5,66.03 D06.C1 | D02.C1 369.35,66.54 364.27,66.54 D02.C2 363.26,66.03 357.67,66.03 D03.C1 356.65,66.54 351.57,66.54 D03.C2 350.56,66.03 344.97,66.03 D04.C1 343.95,66.54 338.87,66.54 D04.C2 337.86,66.54 328.71,66.54 D05.C1 327.7,66.54 322.62,66.54 D05.C2 321.6,66.03 319.57,64 319.06,64 D05.D2 D05.D1 | CD18.AC2 148.37,136.64 149.9,138.16 159.04,138.16 160.06,137.15 C17.C2 161.07,136.64 164.12,136.64 165.64,138.16 170.72,138.16 171.74,137.15 175.8,137.15 C16.C2 176.82,136.64 178.34,138.16 188.5,138.16 | 188.5,138.16 196.12,138.16 197.14,137.15 201.2,137.15 C14.C2 202.22,136.64 205.27,136.64 206.79,138.16 208.82,138.16 209.84,137.15 213.9,137.15 C13.C2 214.92,136.64 215.43,137.15 218.48,137.15 219.49,138.16 223.56,138.16 225.08,136.64 229.14,136.64 C12.C2 230.67,136.64 232.19,138.16 242.86,138.16
  Top 0.635: 242.86,138.16 250.48,138.16 251.5,137.15 254.54,137.15 255.05,136.64 C10.C2 256.07,137.15 257.08,138.16 263.18,138.16 264.7,136.64 267.75,136.64 C09.C2 268.77,137.15 272.83,137.15 273.85,138.16 275.88,138.16 276.9,137.15 | 276.9,137.15 282.99,137.15 283.5,136.64 C08.C2 284.52,137.15 288.58,137.15 289.6,138.16 291.63,138.16 293.15,136.64 296.2,136.64 C07.C2 297.22,137.15 301.28,137.15 302.3,138.16 304.33,138.16 305.34,137.15 309.41,137.15 C06.C2 309.92,137.15 313.98,137.15 315,138.16 320.08,138.16 321.6,136.64 C05.C2 322.62,136.13 323.12,135.62 327.19,135.62 328.2,134.61 332.27,134.61 334.3,136.64 337.86,136.64 C04.C2 | B05.F2 319.57,189.47 319.57,185.41 322.11,185.41 323.63,183.88 325.16,183.88 B05.J1 | B05.M2 322.62,173.72 322.62,169.66 323.12,169.66 324.14,168.64 328.2,168.64 B05.P1 | C03.C2 351.57,136.64 352.08,137.15 355.13,137.15 356.14,138.16 362.24,138.16 363.26,137.15 C02.C2 364.27,136.13 367.83,136.13 369.35,134.61 370.37,134.61 371.38,135.62 375.45,135.62 375.96,136.13 C01.C2 | B03.U1 357.16,154.93 356.65,154.93 354.62,152.9 B03.V1 350.56,152.39 349.03,153.91 345.98,153.91 344.97,154.93 B04.U1 344.46,154.93 342.43,152.9 341.92,152.9 B04.V1 337.86,152.39 336.33,153.91 330.24,153.91 329.22,154.93 B05.U1 328.2,155.94 326.17,157.98 B05.T1 325.16,158.48 321.6,158.48 320.08,160.01 315,160.01 313.47,158.48 B06.T1 312.46,158.99 308.39,158.99 307.38,160.01 305.34,160.01 303.82,158.48 300.77,158.48 B07.T1 299.76,158.99 295.69,158.99 294.68,160.01 292.64,160.01 291.12,158.48 288.07,158.48 B08.T1 287.06,158.99 282.99,158.99 281.98,160.01 272.83,160.01 271.82,158.99 B09.T1 270.8,158.48 267.75,158.48 266.23,160.01 264.2,160.01 263.18,158.99 259.12,158.99 B10.T1 258.1,158.48 256.58,160.01 251.5,160.01 250.48,158.99 246.42,158.99 B11.T1 245.4,158.48 242.35,158.48 240.83,160.01 238.8,160.01 237.78,158.99 233.72,158.99 B12.T1 232.7,158.48 231.18,160.01 226.1,160.01 225.08,158.99 217.97,158.99 B13.T1 216.95,158.99 213.4,158.99 212.38,160.01 206.28,160.01 205.27,158.99 B14.T1 204.25,158.99 200.7,158.99 199.68,160.01 193.58,160.01 192.57,158.99 B15.T1 191.55,158.48 189.01,158.48 187.49,160.01 180.88,160.01 179.87,158.99 B16.T1
  Top 0.635: B03.T1 354.11,157.98 356.14,155.94 356.65,155.94 B03.U1 | 368.34,153.91 369.35,154.93 369.86,154.93 B02.U1 | 368.34,153.91 367.32,152.9 B02.V1 | B02.T1 366.81,157.98 368.84,155.94 369.35,155.94 B02.U1 | AB01.BT1 379,158.48 377.99,157.47 374.43,157.47 372.91,155.94 370.37,155.94 B02.U1 | 368.34,153.91 358.68,153.91 357.67,154.93 B03.U1 | AB19.BL2 132.12,177.28 134.15,175.25 134.66,175.25 AB19.BM2 | 133.13,192.01 134.15,193.03 134.66,193.03 AB19.BE2 135.67,194.04 138.21,194.04 144.31,200.14 147.36,200.14 B18.C2 148.37,200.14 149.9,201.66 169.71,201.66 171.74,199.63 175.8,199.63 B16.C2 176.82,200.14 177.33,200.14 177.84,200.65 180.88,200.65 v181.39,201.16 | 133.13,192.01 132.12,191 AB19.BF2 | B22.U1 99.6,155.94 97.57,157.98 B22.T1 96.56,157.98 90.97,157.98 B22.T2 | 91.48,198.11 82.33,198.11 81.32,199.12 B23.C2 | 91.48,198.11 93,199.63 B22.C2 | 104.18,198.11 105.7,199.63 B21.C2 | 91.48,198.11 104.18,198.11 | 104.18,198.11 113.83,198.11 115.86,200.14 121.96,200.14 B20.C2 122.97,199.63 126.53,199.63 128.05,198.11 129.58,198.11 129.58,195.57 133.13,192.01 | A26.U2 40.17,225.03 42.2,223 42.71,223 A26.V1 | A23.T2 A23.T1 86.9,228.59 86.9,226.05 A23.U1 | A22.M2 93,244.34 91.48,242.81 84.36,242.81 83.35,243.83 81.32,243.83 A23.M2 80.3,244.34 79.28,244.34 77.76,242.81 61,242.81 59.47,244.34 A25.M1 58.46,244.34 54.9,244.34 53.38,242.81 v38.14,242.81 | AB19.AT2 132.12,228.08 134.15,226.05 134.66,226.05 AB19.AU2 | A23.C2 81.32,269.23 86.9,269.23 A23.C1 87.92,269.74 93,269.74 A22.C2 94.02,269.23 98.08,269.23 99.1,268.21 104.18,268.21 | 104.18,268.21 105.7,269.74 A21.C2
  Top 0.635: 104.18,268.21 113.83,268.21 114.84,269.23 121.96,269.23 A20.C2 122.97,269.74 126.02,269.74 127.54,268.21 129.58,268.21 130.59,269.23 134.66,269.23 AB19.AC2 135.67,269.74 138.72,269.74 140.24,268.21 142.28,268.21 143.29,269.23 147.36,269.23 A18.C2 148.37,269.74 149.9,268.21 167.68,268.21 169.2,269.74 175.8,269.74 A16.C2 176.82,269.74 177.33,269.23 180.38,269.23 181.39,268.21 183.42,268.21 184.44,269.23 188.5,269.23 A15.C2 189.52,269.74 192.57,269.74 194.09,268.21 196.12,268.21 196.63,268.72 200.7,268.72 201.2,269.23 A14.C2 202.22,269.74 203.74,268.21 231.68,268.21 | A02.U2 363.76,226.05 365.8,228.08 366.3,228.08 A02.T1 367.32,228.08 368.34,227.06 374.43,227.06 375.96,228.59 AB01.AT1 | A03.U2 351.06,226.05 353.1,228.08 353.6,228.08 A03.T1 | A03.R1 354.62,235.19 359.7,235.19 A02.R2 360.72,234.68 366.3,234.68 A02.R1 | A02.N2 A03.N1 353.6,240.78 348.02,240.78 A03.N2 A04.N1 | A02.K1 370.37,250.43 372.4,248.4 372.91,248.4 AB01.AL2 373.42,248.4 373.92,248.4 375.96,250.43 AB01.AK2 | A03.F1 354.62,260.08 359.7,260.08 A02.F2 360.72,260.08 366.3,260.08 A02.F1 | A03.F2 347,260.08 341.92,260.08 A04.F1 340.9,260.08 335.32,260.08 A04.F2 334.3,260.59 328.71,260.59 | A03.R2 347,234.68 341.92,234.68 A04.R1 | AB01.AC2 375.96,269.23 370.37,269.23 A02.C1 369.35,269.74 364.27,269.74 A02.C2 363.26,269.23 357.67,269.23 A03.C1 356.65,269.74 351.57,269.74 A03.C2 350.56,269.23 344.97,269.23 A04.C1 343.95,269.74 338.87,269.74 A04.C2 337.86,269.74 329.22,269.74 A05.C1 | A05.U2 322.62,226.05 324.65,228.08 325.16,228.08 A05.T1 | A05.R1 325.66,235.7 327.7,237.73 328.2,237.73 A05.P1
  Top 0.635: 328.71,260.59 328.71,263.13 A05.E1 | 328.71,260.59 326.17,260.59 A05.F1 | A12.T1 233.72,228.08 234.73,227.06 243.88,227.06 245.4,228.59 A11.T1 246.42,228.08 247.43,227.06 253.53,227.06 255.05,228.59 A10.T1 259.12,228.08 260.13,227.06 266.74,227.06 268.26,228.59 A09.T1 A08.T2 281.47,228.08 287.06,228.08 A08.T1 288.07,228.59 289.6,227.06 298.74,227.06 299.76,228.08 A07.T1 300.26,228.08 300.77,228.08 302.8,226.05 A07.U1 303.82,225.03 308.9,225.03 A06.U2 309.92,226.05 311.95,228.08 312.46,228.08 A06.T1 | A06.F1 313.47,260.08 318.55,260.08 A05.F2 | A06.K2 309.92,250.43 315.5,250.43 A06.K1 316.52,250.43 317.03,250.43 319.06,248.4 A05.L2 | A05.C2 321.6,269.74 316.52,269.74 A06.C1 315.5,269.74 309.92,269.74 A06.C2 308.9,269.74 306.87,269.74 305.34,268.21 298.23,268.21 297.22,269.23 A07.C2 296.2,269.74 294.68,268.21 285.53,268.21 284.52,269.23 A08.C2 283.5,269.74 281.98,268.21 269.78,268.21 268.77,269.23 A09.C2 267.75,270.24 264.2,270.24 262.67,271.77 261.15,271.77 260.64,271.26 257.08,271.26 256.07,270.24 A10.C2 255.05,269.74 254.54,269.23 252.51,269.23 249.97,271.77 247.43,271.77 245.91,270.24 243.37,270.24 A11.C2 242.35,269.74 240.83,268.21 231.68,268.21 | A05.R2 318.55,234.68 313.47,234.68 A06.R1 312.46,234.68 306.87,234.68 A06.R2 | A05.N1 325.16,240.78 319.57,240.78 A05.N2 | AB01.BL2 373.42,178.3 373.92,178.8 374.43,178.8 375.96,180.33 AB01.BK2 | AB01.BC2 376.46,199.63 375.45,198.62 374.43,198.62 373.42,197.6 AB01.BD2 372.4,197.09 369.35,197.09 366.81,199.63 364.27,199.63 B02.C2 363.26,200.65 359.19,200.65 358.18,201.66 356.14,201.66 355.13,200.65 352.08,200.65 351.57,200.14 B03.C2 350.56,200.65 346.49,200.65 345.48,201.66 343.44,201.66 342.43,200.65 339.38,200.65 338.87,200.14 B04.C2 337.86,199.63 329.22,199.63 B05.C1 328.2,199.12 322.62,199.12 B05.C2 322.11,199.12 318.04,199.12 317.03,198.11 315,198.11 314.49,198.62 310.42,198.62 309.92,199.12 B06.C2 308.9,199.63 307.38,198.11 298.23,198.11 297.22,199.12 B07.C2 296.2,200.14 295.69,200.65 292.14,200.65 291.12,201.66 290.1,201.66 289.6,201.16 286.55,201.16 285.53,200.14 284.52,200.14 B08.C2 283.5,199.63 278.42,199.63 v277.91,199.12
  Top 0.635: 254.04,198.11 244.38,198.11 243.37,199.12 B11.C2 242.35,199.12 238.8,199.12 237.78,198.11 231.68,198.11 230.67,199.12 B12.C2 229.65,199.63 223.56,199.63 222.03,198.11 219.49,198.11 218.48,199.12 214.92,199.12 B13.C2 213.9,199.12 212.89,198.11 206.79,198.11 206.28,198.62 202.73,198.62 B14.C2 201.2,199.63 198.16,199.63 196.12,201.66 194.6,201.66 194.09,201.16 190.54,201.16 | 254.04,198.11 B10.C2 | 254.04,198.11 263.18,198.11 264.7,199.63 267.75,199.63 B09.C2 | A16.T1 179.87,228.08 180.88,227.06 186.98,227.06 188,228.08 191.55,228.08 A15.T1 193.58,228.59 195.11,227.06 199.68,227.06 200.19,227.57 203.74,227.57 204.25,228.08 A14.T1 | v278.42,97.02 278.42,97.52 | 276.9,137.15 v276.9,136.13 | 190.54,201.16 189.52,200.14 B15.C2 | 190.54,201.16 190.03,201.66 v189.52,201.66 | 231.68,268.21 230.67,269.23 A12.C2 | 188.5,138.16 188.5,137.15 C15.C2 | 242.86,138.16 242.86,137.15 C11.C2
  Route15 0.635: v189.52,201.66 189.52,202.17 v185.96,205.73 | v277.91,199.12 274.86,202.17 273.34,202.17 271.31,200.14 268.77,200.14 B09.C2
  Bottom 0.635: D11.P1 248.96,34.53 247.94,33.52 247.94,30.47 245.91,28.44 245.91,25.9 D11.T1 | D07.U1 302.8,22.85 300.26,22.85 300.26,24.88 D07.T1 | D04.R2 334.81,32.5 334.81,37.58 D04.N2 334.81,38.6 334.81,43.68 D04.L2 334.81,45.2 334.81,50.28 D04.J2 334.81,51.3 334.81,56.38 D04.F2 | D03.F2 347.51,56.38 347.51,51.3 D03.J2 347.51,50.28 347.51,45.2 D03.L2 347.51,43.68 347.51,38.6 D03.N2 | D04.U2 338.87,22.34 341.41,22.34 341.41,24.88 D04.T1 341.41,25.9 341.41,30.98 D04.R1 341.41,32.5 341.41,37.58 D04.N1 | D02.F2 360.21,56.38 360.21,51.3 D02.J2 360.21,50.28 360.21,45.2 D02.L2 360.21,43.68 360.21,38.6 D02.N2 | D02.U2 364.27,22.34 366.3,24.37 366.3,24.88 D02.T1 366.81,25.9 366.81,30.98 D02.R1 366.81,32.5 366.81,37.58 D02.N1 | D03.U2 351.57,22.34 353.6,24.37 353.6,24.88 D03.T1 354.11,25.9 354.11,30.98 D03.R1 354.11,32.5 354.11,37.58 D03.N1 | D05.F1 D05.D1 D05.B1 | D05.J2 318.55,51.3 318.55,56.38 D05.F2 | D06.R2 306.36,32.5 306.36,37.58 D06.N2 306.36,38.6 306.36,43.68 D06.L2 306.36,45.2 306.36,50.28 D06.J2 306.36,51.3 306.36,56.38 D06.F2 | D05.H1 328.2,53.33 328.2,48.25 D05.K1 328.2,47.23 328.2,41.64 D05.M1 328.2,40.63 328.2,35.55 D05.P1 | D05.U2 322.62,22.34 325.16,22.34 D05.T1 325.16,28.44 | 325.16,28.44 D05.R1 D05.N1 | 325.16,28.44 327.7,28.44 D05.S1 | D06.K1 316.52,47.23 318.55,45.2 D05.L2 318.55,43.68 318.55,38.6 D05.N2 | D06.T1 312.96,25.9 312.96,30.98 D06.R1 312.46,32.5 312.46,37.58 D06.N1 | D05.J1 D05.L1 | D02.A1 369.35,72.63 369.35,67.04 D02.C1 | D04.A1 343.95,72.63 343.95,67.04 D04.C1 | D03.A1 356.65,72.63 356.65,67.04 D03.C1 | D05.E1 328.2,60.95 328.2,66.03 D05.C1 327.7,67.04 327.7,72.63 D05.A1 328.71,73.65 328.71,75.17 329.73,76.19 329.73,87.36 326.68,90.41 326.68,93.46 325.66,94.48 C05.T1
  Bottom 0.635: D06.A1 315.5,72.63 315.5,67.04 D06.C1 316.01,66.03 316.01,65.52 318.04,63.49 D05.D2 | B05.M2 322.62,174.74 322.62,178.3 325.16,180.84 325.16,183.38 B05.J1 325.66,184.39 326.68,185.41 326.68,188.46 327.19,188.96 327.19,192.01 326.68,192.52 326.68,195.06 328.2,196.58 328.2,199.12 B05.C1 | B05.V1 325.16,152.39 325.16,157.98 B05.T1 325.66,158.99 325.66,161.02 327.7,163.06 327.7,167.12 328.2,167.63 B05.P1 | C04.C2 338.36,137.15 338.36,140.2 341.41,143.24 341.41,151.88 B04.V1 341.41,152.9 341.41,157.98 B04.T1 | C02.C2 363.76,137.15 364.27,137.66 364.27,139.69 366.81,142.23 366.81,151.88 B02.V1 | AB19.BL2 131.61,178.3 130.59,179.31 130.59,182.36 130.08,182.87 130.08,186.42 131.61,187.95 131.61,189.98 AB19.BF2 | B22.V1 96.56,152.39 96.56,157.98 B22.T1 | B22.T2 88.94,160.01 88.94,192.01 93.51,196.58 93.51,199.12 B22.C2 | A26.D2 37.12,266.18 38.14,265.16 v38.14,242.81 38.14,230.62 39.66,229.1 39.66,226.05 A26.U2 | A22.M2 93.51,243.83 93.51,241.8 90.46,238.75 90.46,238.24 87.92,238.24 A23.P1 86.9,237.73 86.4,237.22 86.4,233.16 84.36,231.13 84.36,229.1 A23.T1 | A23.U1 86.9,225.03 86.9,224.52 84.87,222.49 A23.V1 84.36,221.48 84.36,206.74 81.82,204.2 81.82,200.65 81.32,200.14 B23.C2 | A23.M2 81.32,244.84 81.32,247.38 82.84,248.91 82.84,252.46 83.86,253.48 A23.J1 83.86,254.5 80.3,254.5 80.3,255 77.76,257.54 77.76,259.58 A23.F2 77.76,261.1 77.76,264.15 79.79,266.18 79.79,268.21 80.81,269.23 A23.C2 | AB19.AS2 134.66,231.13 134.66,226.05 AB19.AU2 | AB19.AT2 131.61,229.1 131.61,234.18 AB19.AR2 131.61,235.7 131.61,237.22 133.64,239.26 133.64,242.3 133.13,242.81 133.13,245.35 133.64,245.86 133.64,249.42 134.66,250.43 AB19.AK2 134.66,251.45 132.12,251.45 132.12,253.48 AB19.AJ2 131.61,254.5 131.61,257.54 133.64,259.58 133.64,262.12 133.13,262.62 133.13,265.16 134.66,266.69 134.66,269.23 AB19.AC2
  Bottom 0.635: A02.T1 366.81,229.1 366.81,234.18 A02.R1 366.81,235.7 366.81,240.78 A02.N1 | A03.T1 354.11,229.1 354.11,234.18 A03.R1 354.11,235.7 354.11,240.78 A03.N1 | AB01.AH2 376.46,256.53 376.46,251.45 AB01.AK2 | A02.F2 360.21,259.58 360.21,254.5 A02.J2 359.7,253.99 357.67,251.96 357.67,251.45 A03.K1 357.67,250.43 359.7,248.4 359.7,247.89 A02.L2 360.21,246.88 360.21,241.8 A02.N2 | A02.K1 369.86,251.45 368.34,252.97 368.34,255 366.81,256.53 366.81,259.58 A02.F1 | A04.R2 334.81,235.7 334.81,240.78 A04.N2 334.81,241.8 334.81,246.88 A04.L2 334.81,248.4 334.81,253.48 A04.J2 334.81,254.5 334.81,259.58 A04.F2 | A03.F2 347.51,259.58 347.51,254.5 A03.J2 347,253.99 344.97,251.96 344.97,251.45 A04.K1 344.97,250.43 347,248.4 347,247.89 A03.L2 347.51,246.88 347.51,241.8 A03.N2 | A04.U2 338.87,225.54 340.9,227.57 340.9,228.08 A04.T1 341.41,229.1 341.41,234.18 A04.R1 341.41,235.7 341.41,240.78 A04.N1 | A02.A1 369.35,275.83 369.35,270.24 A02.C1 | A04.A1 343.95,275.83 343.95,270.24 A04.C1 | A03.A1 356.65,275.83 356.65,270.24 A03.C1 | A05.S1 328.2,232.14 328.2,237.73 A05.P1 328.2,238.75 328.2,243.83 A05.M1 | A05.T1 325.16,229.1 325.16,234.18 A05.R1 325.16,235.7 325.16,240.78 A05.N1 325.16,241.8 325.16,246.88 A05.L1 325.16,248.4 325.16,253.48 A05.J1 325.66,254.5 | A05.A1 328.2,275.83 328.2,275.32 326.17,273.29 A05.B1 325.16,272.28 325.16,267.2 A05.D1 325.16,266.18 325.16,261.1 A05.F1 325.66,259.58 325.66,254.5 | 325.66,254.5 328.2,257.04 A05.H1 328.71,256.53 328.71,251.45 A05.K1 | A05.C1 328.2,269.23 328.2,264.15 A05.E1 | A06.A1 315.5,275.83 315.5,270.24 A06.C1
  Bottom 0.635: A05.C2 321.6,269.74 321.6,269.23 319.57,267.2 A05.D2 319.06,266.18 319.06,261.1 A05.F2 319.06,259.58 319.06,254.5 A05.J2 319.06,253.48 319.06,248.4 A05.L2 319.06,246.88 319.06,241.8 A05.N2 319.06,240.78 319.06,235.7 A05.R2 | A06.R2 306.36,235.7 306.36,240.78 A06.N2 306.36,241.8 306.36,246.88 A06.L2 306.36,248.4 306.36,253.48 A06.J2 306.36,254.5 306.36,259.58 A06.F2 | A06.T1 312.46,229.1 312.46,234.18 A06.R1 312.46,235.7 312.46,240.78 A06.N1 | AB01.BK2 375.96,181.34 375.96,186.93 AB01.BH2 375.96,187.95 375.45,188.46 375.45,192.01 373.42,194.04 373.42,196.08 AB01.BD2 | A14.T1 204.76,228.08 204.76,225.03 202.73,223 202.73,212.33 203.24,211.82 203.24,202.68 201.71,201.16 201.71,200.14 B14.C2 | v278.42,97.02 278.42,125.46 276.9,126.99 v276.9,136.13 | v181.39,201.16 v185.96,205.73
I/O_0_TO_AC\  (via drill 0.61)
  Top 0.254: v375.96,36.56 359.7,36.56 359.19,37.07 356.65,37.07 356.14,36.56 340.4,36.56 338.87,35.04 D04.P2 | v382.56,77.71 383.58,78.73 383.58,86.86 v382.05,86.86 | v374.94,150.86 374.43,150.36 | 374.43,150.36 339.38,150.36 v338.87,150.86 | v338.87,166.61 337.35,166.61 335.32,168.64 332.27,168.64 v325.66,175.25 | v336.84,221.98 338.36,220.46 390.69,220.46 v391.2,220.97 | v391.7,151.37 385.1,151.37 384.59,150.86 383.58,150.86 383.07,150.36 374.43,150.36
  Bottom 0.254: v375.96,36.56 377.48,38.09 377.48,43.17 377.99,43.68 377.99,71.62 382.56,76.19 v382.56,77.71 | v382.05,86.86 377.48,86.86 377.48,133.08 374.94,135.62 v374.94,150.86 | v338.87,150.86 339.38,151.37 339.38,166.1 v338.87,166.61 | v325.66,175.25 325.66,176.77 B05.L1 | v336.84,221.98 336.84,232.65 337.35,233.16 337.35,237.22 337.86,237.73 A04.P2 | v391.2,220.97 391.2,201.16 390.18,200.14 390.18,199.63 389.67,199.12 389.67,187.44 391.2,185.92 391.2,171.18 390.18,170.17 390.18,153.91 391.7,152.39 v391.7,151.37
I/O_1_TO_CA_INH\  (via drill 0.61)
  Top 0.254: v303.82,38.6 305.34,40.12 307.88,40.12 308.9,41.14 D06.M2 | v301.79,24.88 293.66,16.75 293.15,16.75 291.63,15.23 281.47,15.23 280.96,15.74 265.21,15.74 264.7,15.23 237.78,15.23 231.68,9.13 203.74,9.13 202.73,10.15 191.55,10.15 190.54,9.13 126.02,9.13 124.5,10.66 123.48,10.66 122.46,11.67 v116.88,11.67 | v130.59,218.43 131.61,219.44 158.02,219.44 v158.53,218.94 | v159.04,288.02 159.55,287.52 215.43,287.52 216.95,289.04 216.95,295.14 238.8,295.14 240.83,293.1 250.48,293.1 251.5,292.09 256.07,292.09 257.08,293.1 264.2,293.1 265.72,291.58 282.48,291.58 284.01,293.1 294.17,293.1 294.68,293.61 v307.38,293.61 | v316.52,171.18 318.55,171.18 B05.N2 | v304.84,227.57 304.84,230.11 v308.9,230.11
  Route2 0.254: v316.52,171.18 314.49,173.22 314.49,174.23 312.96,175.76 v312.46,175.25
  Route15 0.254: v312.46,175.25 311.44,176.26 311.44,188.96 308.39,192.01 308.39,194.55 307.88,195.06 307.88,197.09 303.31,201.66 302.8,201.66 302.3,202.17 302.3,204.71 301.79,205.22 v301.79,210.3 | v303.31,215.38 303.31,218.94 v303.82,219.44
  Bottom 0.254: v303.82,38.6 301.79,36.56 v301.79,24.88 | v116.88,11.67 116.37,12.18 116.37,53.33 117.89,54.85 117.89,59.93 116.88,60.95 116.88,122.92 119.42,125.46 120.43,125.46 120.43,125.97 127.04,132.58 127.04,188.46 130.59,192.01 v130.59,218.43 | v158.53,218.94 159.04,219.44 v159.04,288.02 | v307.38,293.61 307.38,274.31 307.88,273.8 307.88,269.23 308.39,268.72 308.39,251.96 307.88,251.45 307.88,249.92 309.41,248.4 309.41,244.84 A06.M2 309.41,243.83 308.39,242.81 308.39,230.62 v308.9,230.11 | v301.79,210.3 303.31,211.82 v303.31,215.38 | v303.82,219.44 303.31,219.95 303.31,221.98 302.8,222.49 302.8,223.51 303.31,224.02 304.84,224.02 v304.84,227.57
I/O_ADDR_ACC\  (via drill 0.61)
  Top 0.254: v387.64,21.83 385.61,23.86 352.08,23.86 349.03,26.91 327.7,26.91 327.19,27.42 323.63,27.42 322.62,28.44 D05.S2 | v390.18,52.31 v380.53,52.31 | v381.04,69.58 381.04,71.11 364.78,71.11 v364.27,70.6 | v367.83,87.36 368.84,88.38 368.84,90.92 365.29,90.92 364.27,91.94 C02.U2 | v324.14,257.04 324.14,258.05 323.63,258.05 323.12,258.56 311.95,258.56 311.44,259.07 311.44,265.16 305.34,265.16 v303.82,266.69 | v304.84,270.24 303.31,271.77 288.07,271.77 287.06,270.75 v286.04,270.75 | v285.53,272.78 285.02,272.28 282.48,272.28 281.98,271.77 v279.94,271.77 | v279.94,262.12 277.91,260.08 v274.86,260.08 | v198.16,77.71 198.66,77.2 208.32,77.2 v208.82,77.71 | v239.3,58.92 242.35,61.96 v244.89,61.96
  Route2 0.254: v322.62,236.21 323.63,237.22 v323.63,247.38 | v271.82,250.43 270.8,250.43 268.26,247.89 268.26,246.88 v266.74,245.35 | v266.74,238.75 263.69,235.7 263.69,230.11 259.12,225.54 258.1,225.54 256.58,224.02 255.05,224.02 254.54,223.51 254.54,221.98 253.53,220.97 252,220.97 248.45,217.41 248.45,213.86 244.89,210.3 238.29,210.3 235.24,207.25 235.24,206.24 234.22,205.22 233.21,205.22 230.67,202.68 230.67,201.66 230.16,201.16 229.14,201.16 225.59,197.6 225.59,196.58 222.54,193.54 222.54,191 218.98,187.44 216.95,187.44 208.82,179.31 207.3,179.31 206.79,178.8 206.79,175.76 190.54,159.5 190.54,154.42 175.8,139.69 175.8,138.67 171.74,134.61 171.74,133.59 170.72,132.58 170.72,131.56 166.66,127.5 166.66,125.97 165.14,124.45 v165.14,123.94
  Route15 0.254: v364.27,70.6 v366.3,72.63 | v164.12,111.24 167.17,108.19 167.17,106.67 168.18,105.65 168.18,103.62 178.85,92.95 179.36,92.95 179.87,92.44 179.87,91.94 184.44,87.36 188.5,87.36 v198.16,77.71 | v208.82,77.71 209.84,77.71 212.38,75.17 214.41,75.17 222.03,67.55 222.03,66.54 231.68,56.88 231.68,56.38 v237.27,50.79 | v244.89,61.96 245.4,61.96 249.97,57.39 249.97,55.87 252.51,53.33 254.04,53.33 261.15,46.22 266.74,46.22 273.34,39.61 276.9,39.61 289.6,26.91 296.2,26.91 299.25,23.86 315,23.86 320.58,29.45 321.6,28.44 D05.S2
  Bottom 0.254: v387.64,21.83 390.18,24.37 v390.18,52.31 | v380.53,52.31 380.02,52.82 380.02,55.36 381.04,56.38 v381.04,69.58 | v366.3,72.63 366.81,73.14 366.81,78.22 367.32,78.73 367.32,86.86 v367.83,87.36 | v322.62,236.21 322.62,232.14 A05.S2 | v323.63,247.38 324.14,247.38 v324.14,257.04 | v303.82,266.69 304.33,267.2 304.33,268.72 304.84,269.23 v304.84,270.24 | v286.04,270.75 285.53,271.26 v285.53,272.78 | v279.94,271.77 279.44,271.26 279.44,262.62 v279.94,262.12 | v274.86,260.08 275.88,259.07 275.88,254.5 v271.82,250.43 | v266.74,245.35 v266.74,238.75 | v165.14,123.94 165.14,122.92 167.17,120.89 167.17,119.88 165.14,117.84 165.14,112.76 164.12,111.75 v164.12,111.24 | v237.27,50.79 238.29,51.8 238.29,57.9 v239.3,58.92
I/O_B-BRK  (via drill 0.61)
  Top 0.254: v329.22,25.39 332.78,21.83 v334.3,21.83 | v387.64,16.24 v335.32,16.24 | v391.7,32.5 391.7,48.76 383.58,48.76 383.07,49.26 377.99,49.26 374.94,52.31 368.84,52.31 367.83,53.33 366.81,53.33 366.3,53.84 366.3,55.36 367.32,55.36 368.34,56.38 368.34,58.92 362.75,58.92 v360.72,60.95 | v364.78,78.73 364.78,80.76 367.83,80.76 v368.34,81.27 | v281.98,131.05 279.44,128.51 269.78,128.51 268.26,126.99 v267.75,126.99 | v299.76,41.14 303.31,37.58 304.33,37.58 304.84,38.09 304.84,38.6 305.85,39.61 309.92,39.61 311.44,38.09 311.44,34.53 v313.98,34.53 | v318.55,35.55 321.6,35.55 D05.P2
  Route2 0.254: v360.72,60.95 360.72,61.46 361.73,62.47 361.73,75.68 v364.78,78.73 | v370.88,107.68 370.88,108.19 371.89,109.21 372.91,109.21 374.43,110.73 374.43,115.3 373.42,116.32 374.43,117.34 374.43,118.35 374.94,118.86 374.94,120.38 377.48,122.92 377.48,128 v379,129.53 | v330.24,232.65 330.24,231.13 329.22,230.11 324.65,230.11 320.58,226.05 319.06,226.05 313.98,220.97 311.44,220.97 309.41,218.94 308.39,218.94 303.82,214.36 302.8,214.36 295.18,206.74 295.18,194.55 v294.17,193.54 | v299.76,192.52 301.28,192.52 305.34,188.46 305.34,184.9 304.84,184.39 304.84,179.82 v302.8,177.79 | v303.31,164.58 303.31,164.07 298.74,159.5 298.74,157.98 v297.72,156.96 | v297.72,151.37 297.72,150.86 295.69,148.83 295.69,146.8 292.64,143.75 292.64,142.23 281.98,131.56 v281.98,131.05 | v266.74,114.8 266.74,113.27 263.69,110.22 263.69,108.7 254.04,99.05 253.53,99.05 v252,97.52 | v257.08,88.38 257.08,86.35 255.05,84.32 255.05,74.66 254.04,73.65 254.04,70.6 v255.05,69.58 | v313.98,34.53 315.5,33.01 316.01,33.52 316.52,33.52 v318.55,35.55
  Route15 0.254: v327.7,31.48 324.65,34.53 322.62,34.53 D05.P2 | v368.34,81.27 371.89,84.82 371.38,85.33 371.38,87.36 v370.88,87.87 | v330.24,232.65 325.16,237.73 322.62,237.73 A05.P2 | v294.17,193.54 295.69,192.01 299.25,192.01 v299.76,192.52 | v252,97.52 250.99,96.51 250.99,94.48 v257.08,88.38 | v255.05,69.58 255.56,69.58 258.61,66.54 259.62,66.54 266.74,59.42 266.74,57.9 268.77,55.87 270.29,55.87 273.85,52.31 275.37,52.31 283.5,44.18 285.02,44.18 286.04,43.17 295.69,43.17 296.2,42.66 298.23,42.66 v299.76,41.14
  Bottom 0.254: v327.7,31.48 329.73,29.45 329.73,25.9 v329.22,25.39 | v334.3,21.83 333.79,21.32 333.79,17.77 v335.32,16.24 | v387.64,16.24 389.16,14.72 391.7,14.72 v391.7,32.5 | v370.88,87.87 371.38,88.38 371.38,107.18 v370.88,107.68 | v379,129.53 379.51,130.04 379.51,132.58 C01.D1 | v302.8,177.79 302.3,177.28 302.3,175.25 301.79,174.74 301.79,166.1 v303.31,164.58 | v297.72,156.96 298.23,156.45 298.23,151.88 v297.72,151.37 | v267.75,126.99 266.74,125.97 v266.74,114.8
I/O_B-RUN  (via drill 0.61)
  Top 0.254: v342.94,27.93 339.38,27.93 338.87,28.44 D04.S2 | v342.94,14.21 343.44,13.7 386.62,13.7 388.66,15.74 388.66,26.4 v388.15,26.4 | v391.7,49.77 391.7,56.88 v388.66,56.88 | v347.51,226.56 343.95,230.11 340.4,230.11 338.87,231.64 A04.S2 | v352.59,218.43 354.62,216.4 v358.68,216.4 | v359.19,207.76 377.99,207.76 381.04,204.71 381.04,199.63 379.51,199.63 372.91,193.03 v372.4,193.03 | v372.4,181.34 370.37,179.31 366.3,179.31 365.29,178.3 365.29,176.26 366.3,176.26 369.35,173.22 370.88,173.22 371.89,172.2 371.89,170.17 v380.53,170.17
  Route2 0.254: v386.62,43.17 388.15,44.69 388.15,46.22 v391.7,49.77 | v347.51,226.56 354.11,219.95 v352.59,218.43 | v380.53,170.17 383.07,170.17 385.61,167.63 385.61,163.06 385.1,162.55 385.1,151.37 383.58,149.85 383.58,147.31 v383.07,146.8
  Route15 0.254: v388.15,62.98 388.15,64.5 389.16,65.52 388.66,66.03 388.66,70.6 390.18,72.12 390.18,94.98 388.66,96.51 388.66,136.64 383.07,142.23 C01.A1
  Bottom 0.254: v342.94,14.21 v342.94,27.93 | v388.15,26.4 386.62,27.93 v386.62,43.17 | v388.66,56.88 387.64,57.9 387.64,62.47 v388.15,62.98 | v358.68,216.4 359.7,215.38 359.7,208.27 v359.19,207.76 | v372.4,193.03 371.89,192.52 371.89,181.85 v372.4,181.34 | v383.07,146.8 383.07,143.24 C01.A1
I/O_BAC_00  (via drill 0.61)
  Top 0.254: v377.99,151.37 375.45,153.91 372.4,153.91 369.35,150.86 357.67,150.86 v357.16,151.37 v357.16,153.4 | v379.51,144.26 387.64,144.26 v389.67,142.23 | v382.56,96 380.02,93.46 362.24,93.46 v360.21,91.43 | v358.68,78.22 359.19,77.71 367.83,77.71 v368.34,78.22 | v331.76,283.45 v366.3,283.45 | v321.6,191.5 327.19,191.5 v328.71,189.98
  Route2 0.254: v390.69,108.7 390.69,108.19 390.18,107.68 390.18,103.62 v382.56,96 | v357.16,159.5 357.16,157.98 355.64,156.45 355.64,154.93 v357.16,153.4
  Route15 0.254: v360.21,91.43 v358.18,89.4 | v331.76,250.43 330.24,248.91 330.74,248.4 330.74,246.88 331.76,245.86 331.76,244.34 332.78,243.32 332.78,242.3 v331.25,240.78 | v328.71,189.98 328.71,188.96 330.24,187.44 330.24,184.9 337.86,177.28 339.89,177.28 340.9,176.26 345.48,176.26 355.64,166.1 355.64,161.02 v357.16,159.5
  Bottom 0.254: v357.16,151.37 357.16,143.24 C03.A1 | v377.99,151.37 379.51,149.85 v379.51,144.26 | v389.67,142.23 390.18,141.72 390.18,124.45 391.2,123.43 391.2,109.21 v390.69,108.7 | v358.18,89.4 357.67,88.89 357.67,79.24 v358.68,78.22 | v368.34,78.22 367.32,77.2 367.32,70.09 D02.B1 | v366.3,283.45 366.3,274.31 366.81,273.8 A02.B1 | v331.76,283.45 331.76,257.54 331.25,257.04 331.25,250.94 v331.76,250.43 | v331.25,240.78 331.25,231.64 330.24,230.62 330.24,226.56 331.25,225.54 331.25,205.73 321.09,195.57 321.09,192.01 v321.6,191.5
I/O_BAC_01  (via drill 0.61)
  Top 0.254: v389.16,61.96 372.4,61.96 371.89,62.47 367.83,62.47 367.32,62.98 D02.D1 | v387.13,9.13 382.56,4.56 311.95,4.56 310.93,5.58 299.76,5.58 298.74,4.56 291.12,4.56 290.61,5.07 287.56,5.07 286.55,4.05 249.97,4.05 248.45,5.58 240.32,5.58 239.81,6.08 236.76,6.08 235.75,5.07 199.68,5.07 198.66,6.08 195.62,6.08 194.6,5.07 120.94,5.07 118.91,7.1 113.83,7.1 110.27,3.54 11.72,3.54 10.7,4.56 9.69,4.56 6.64,7.61 v6.13,7.61 | v14.77,287.01 15.28,286.5 55.92,286.5 56.42,285.99 62.52,285.99 63.03,285.48 64.04,285.48 64.55,284.98 101.64,284.98 102.65,285.99 117.38,285.99 118.91,287.52 140.24,287.52 140.75,287.01 155.48,287.01 155.99,286.5 216.95,286.5 217.97,287.52 217.97,294.12 224.57,294.12 225.08,293.61 230.16,293.61 230.67,293.1 238.8,293.1 239.81,292.09 249.46,292.09 250.48,291.07 257.08,291.07 258.1,292.09 263.18,292.09 264.7,290.56 283.5,290.56 285.02,292.09 295.18,292.09 295.69,292.6 299.76,292.6 301.79,290.56 309.41,290.56 309.92,291.07 351.57,291.07 352.08,291.58 v363.26,291.58 | v364.27,146.8 v375.96,146.8 | v384.08,196.08 384.08,199.63 385.1,199.63 385.61,200.14 385.61,209.28 v383.07,209.28
  Route2 0.254: v364.27,146.8 354.11,136.64 354.11,134.1 C03.D1
  Bottom 0.254: v389.16,61.96 389.67,61.46 389.67,53.33 389.16,52.82 389.16,27.93 389.67,27.42 389.67,25.39 386.62,22.34 386.62,9.64 v387.13,9.13 | v6.13,7.61 6.64,8.12 6.64,243.83 3.08,247.38 3.08,275.32 v14.77,287.01 | v363.26,291.58 365.29,289.55 365.29,287.01 | 365.29,287.01 365.29,271.77 366.3,270.75 366.3,267.2 A02.D1 | v375.96,146.8 376.97,147.82 376.97,153.91 377.99,154.93 377.99,161.02 382.56,165.6 384.59,165.6 384.59,195.57 v384.08,196.08 | v383.07,209.28 383.58,209.79 383.58,222.49 377.99,228.08 377.99,245.35 371.89,251.45 371.89,259.07 371.38,259.58 371.38,271.26 370.88,271.77 370.88,274.82 371.38,275.32 371.38,280.91 365.29,287.01
I/O_BAC_02  (via drill 0.61)
  Top 0.254: v353.6,131.56 352.59,132.58 352.59,134.61 363.76,134.61 v364.27,134.1 | v369.35,138.16 v365.8,138.16
  Bottom 0.254: v353.6,131.56 355.13,130.04 355.13,128 354.62,127.5 C03.F1 | v364.27,134.1 365.8,135.62 v365.8,138.16 | 371.38,138.16 v369.35,138.16 | 371.38,138.16 371.38,109.21 371.89,108.7 371.89,87.36 371.38,86.86 371.38,62.98 370.37,61.96 370.37,60.95 D02.E1 | 371.38,138.16 371.38,148.83 371.89,149.34 371.89,167.12 371.38,167.63 371.38,258.05 370.88,258.56 370.88,262.62 370.37,263.13 A02.E1