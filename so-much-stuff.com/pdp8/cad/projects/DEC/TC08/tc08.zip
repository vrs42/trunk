# EAGLE board tc08 (EAGLE 4.11), part 6 of 10
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
IM_01\  (via drill 0.61) (continued)
  Top 0.254: B04.E1 344.97,194.04 345.98,195.06 353.1,195.06 354.11,194.04 356.65,194.04 B03.E1 357.67,194.04 357.67,196.58 v358.18,196.58 | v332.27,63.49 333.79,65.01 335.82,65.01 336.84,64 340.9,64 D04.D1 | v324.14,5.58 323.63,6.08 299.25,6.08 298.23,5.07 291.63,5.07 291.12,5.58 287.06,5.58 286.04,4.56 250.48,4.56 248.96,6.08 240.83,6.08 240.32,6.59 236.26,6.59 235.24,5.58 200.19,5.58 199.17,6.59 195.11,6.59 194.09,5.58 121.45,5.58 119.42,7.61 113.32,7.61 109.76,4.05 12.23,4.05 7.15,9.13 v5.62,9.13 | v2.58,276.34 2.58,288.02 43.22,288.02 44.23,287.01 56.42,287.01 56.93,286.5 63.03,286.5 63.54,285.99 64.55,285.99 65.06,285.48 101.13,285.48 102.14,286.5 116.88,286.5 118.4,288.02 140.75,288.02 141.26,287.52 155.99,287.52 156.5,287.01 215.94,287.01 217.46,288.53 217.46,294.63 238.29,294.63 240.32,292.6 249.97,292.6 250.99,291.58 256.58,291.58 257.59,292.6 263.69,292.6 265.21,291.07 282.99,291.07 284.52,292.6 294.68,292.6 295.18,293.1 301.79,293.1 303.82,291.07 308.9,291.07 309.41,291.58 339.38,291.58 v339.89,292.09 | v358.18,203.19 359.7,201.66 v373.92,201.66 | v374.94,234.68 374.94,236.72 341.92,236.72 v339.89,238.75
  Bottom 0.254: v332.27,63.49 332.27,13.7 v324.14,5.58 | v5.62,9.13 6.13,9.64 6.13,243.32 2.58,246.88 v2.58,276.34 | v339.89,292.09 339.89,271.77 340.9,270.75 340.9,267.2 A04.D1 340.9,266.18 339.89,265.16 v339.89,238.75 | v358.18,196.58 358.68,197.09 358.68,202.68 v358.18,203.19 | v373.92,201.66 371.89,201.66 371.89,216.9 373.42,218.43 373.42,219.95 374.94,221.48 v374.94,234.68
IM_02\
  Top 0.254: B03.K1 356.65,180.84 353.1,180.84 351.57,179.31 349.54,179.31 348.52,180.33 344.97,180.33 B04.K1
  Bottom 0.254: D04.E1 344.46,60.95 343.44,61.96 343.44,65.52 342.94,66.03 342.94,74.66 345.48,77.2 345.48,88.89 342.94,91.43 342.94,176.26 344.46,177.79 344.46,180.33 B04.K1 343.95,181.34 342.94,182.36 342.94,206.74 345.48,209.28 345.48,217.92 342.94,220.46 342.94,257.54 343.44,258.05 343.44,262.62 343.95,263.13 A04.E1
IM_03\  (via drill 0.61)
  Top 0.254: B04.L1 341.92,178.3 345.98,178.3 347,179.31 348.52,179.31 349.54,178.3 353.6,178.3 B03.L1 | v331.25,55.36 338.87,55.36 339.38,54.85 343.44,54.85 343.95,54.34 D04.H1 | v330.74,13.7 329.73,12.69 278.93,12.69 277.91,13.7 267.24,13.7 266.74,13.2 243.37,13.2 v242.86,12.69 | v240.83,16.75 239.81,17.77 237.27,17.77 236.76,17.26 216.95,17.26 216.44,17.77 213.4,17.77 208.32,12.69 205.27,12.69 204.76,12.18 189.52,12.18 188.5,11.16 133.13,11.16 132.12,12.18 125,12.18 123.48,13.7 94.02,13.7 93,14.72 v91.48,14.72 | v91.98,191 93,192.01 v128.05,192.01 | v129.58,210.3 130.08,209.79 149.39,209.79 v153.45,213.86 | v155.99,274.31 156.5,274.82 v244.38,274.82 | v244.89,296.15 245.91,297.17 333.79,297.17 v334.81,296.15 | v357.16,183.88 355.13,185.92 355.13,189.47 359.19,193.54 359.19,199.12 v360.21,199.12 | v356.14,221.98 357.67,223.51 376.97,223.51 v377.48,223 | v374.94,253.48 374.94,255 374.43,255 373.92,255.51 349.54,255.51 348.52,256.53 344.97,256.53 A04.H1
  Route2 0.254: v357.16,183.88 353.6,180.33 353.6,178.3 B03.L1
  Route15 0.254: v360.21,199.12 360.21,199.63 357.16,202.68 357.16,203.7 v354.62,206.24 | v376.46,227.06 376.46,228.59 v379,231.13
  Bottom 0.254: v331.25,55.36 331.76,54.85 331.76,14.72 v330.74,13.7 | v242.86,12.69 240.83,14.72 v240.83,16.75 | v91.48,14.72 91.98,15.23 v91.98,191 | v128.05,192.01 129.58,192.01 129.58,192.52 130.08,193.03 130.08,209.79 v129.58,210.3 | v153.45,213.86 153.96,214.36 153.96,223 155.99,225.03 v155.99,274.31 | v244.38,274.82 244.89,275.32 v244.89,296.15 | v334.81,296.15 346.49,296.15 346.49,262.62 344.97,261.1 344.97,257.54 A04.H1 | v354.62,206.24 355.13,206.74 355.13,208.27 356.65,209.79 356.65,221.48 v356.14,221.98 | v377.48,223 377.48,226.56 376.97,227.06 v376.46,227.06 | v379,231.13 380.53,232.65 380.53,233.67 381.04,234.18 381.04,241.8 378.5,244.34 378.5,245.86 374.94,249.42 v374.94,253.48
IM_04\  (via drill 0.61)
  Top 0.254: v331.76,163.56 335.82,163.56 337.35,165.09 B04.R1 341.92,164.58 344.46,164.58 345.48,163.56 348.52,163.56 349.03,164.07 353.1,164.07 353.6,164.58 B03.R1 | v313.47,262.12 320.58,262.12 324.14,258.56 325.16,258.56 328.2,255.51 335.82,255.51 336.33,255 340.4,255 340.9,254.5 A04.J1 | v313.47,281.93 312.96,281.42 296.2,281.42 v294.17,283.45 | v292.64,281.93 292.14,282.44 275.88,282.44 275.37,282.94 v263.18,282.94 | v209.33,296.15 208.82,295.64 208.32,295.64 207.3,294.63 194.09,294.63 193.08,293.61 166.15,293.61 164.12,295.64 138.21,295.64 135.67,293.1 118.91,293.1 118.4,293.61 110.27,293.61 107.73,291.07 97.57,291.07 97.06,290.56 68.11,290.56 67.6,291.07 62.52,291.07 60.49,293.1 55.92,293.1 54.9,294.12 30.52,294.12 29.5,295.14 v28.99,295.14 | v27.98,198.62 27.98,195.57 28.48,195.57 34.58,189.47 34.58,163.56 48.3,163.56 57.95,153.91 v58.46,153.91 | v61,27.93 61,20.31 105.19,20.31 108.24,17.26 121.45,17.26 121.96,16.75 132.62,16.75 133.64,15.74 135.67,15.74 136.69,14.72 184.95,14.72 185.96,15.74 198.16,15.74 199.17,16.75 202.73,16.75 v203.74,17.77 | v210.35,13.2 228.64,13.2 229.14,13.7 231.18,13.7 231.68,14.21 v233.21,14.21 | v234.22,21.83 234.22,23.36 235.24,23.36 235.75,23.86 238.29,23.86 238.8,23.36 242.35,23.36 242.86,23.86 243.88,23.86 v245.91,21.83 | v281.98,7.1 281.98,10.15 316.01,10.15 318.55,7.61 v335.82,7.61
  Bottom 0.254: 336.33,59.42 333.28,62.47 333.28,143.24 331.25,145.28 331.25,163.06 v331.76,163.56 | 336.33,59.42 339.38,56.38 339.38,52.82 340.9,51.3 D04.J1 | v313.47,262.12 313.98,262.62 313.98,281.42 v313.47,281.93 | v292.64,281.93 v294.17,283.45 | v263.18,282.94 261.66,284.47 261.66,289.55 254.04,297.17 209.33,297.17 v209.33,296.15 | v28.99,295.14 25.44,291.58 25.44,242.81 28.48,239.76 28.48,199.12 v27.98,198.62 | v58.46,153.91 58.46,145.28 61.5,142.23 61.5,28.44 v61,27.93 | v203.74,17.77 210.35,17.77 v210.35,13.2 | v233.21,14.21 234.73,15.74 234.73,21.32 v234.22,21.83 | v245.91,21.83 249.97,17.77 249.97,8.12 252.51,5.58 281.98,5.58 v281.98,7.1 | v335.82,7.61 336.33,8.12 336.33,59.42
IM_05\  (via drill 0.61)
  Top 0.254: v344.46,64.5 344.97,65.01 350.05,65.01 v350.56,64.5 | v343.95,121.91 344.46,122.42 345.48,122.42 v348.52,125.46 | B04.S1 344.97,162.55 345.48,163.06 349.54,163.06 350.05,163.56 351.57,163.56 353.1,162.04 356.65,162.04 B03.S1 | v343.95,247.38 341.92,247.38 A04.L1 | v354.11,226.56 v356.65,229.1 | v363.26,189.98 362.24,188.96 362.24,185.92 368.34,185.92 368.84,185.41 380.53,185.41 v382.05,183.88 | v385.1,108.19 386.62,106.67 386.62,102.1 v383.07,102.1 | v368.34,82.79 358.68,82.79 354.62,78.73 v354.62,76.7
  Route2 0.254: v340.9,59.42 340.9,60.95 v344.46,64.5 | v339.38,88.89 339.38,89.4 341.92,91.94 341.92,92.95 v348.02,99.05 | v341.92,110.73 343.95,112.76 344.97,112.76 345.48,113.27 345.48,115.3 v348.02,117.84 | v348.52,125.46 349.03,125.97 349.03,128 348.52,128.51 348.52,130.54 349.03,131.05 349.03,136.13 345.48,139.69 352.59,146.8 352.59,154.93 355.64,157.98 355.64,160.52 356.65,161.53 B03.S1 | v391.2,154.42 391.2,153.4 390.18,152.39 390.18,148.32 387.64,145.78 387.64,122.92 v385.1,120.38 | v383.07,102.1 369.86,88.89 369.86,87.87 368.84,86.86 368.84,83.3 v368.34,82.79
  Route15 0.254: v339.38,88.89 341.92,86.35 343.95,86.35 v350.56,79.74 353.6,76.7 v354.62,76.7 | v348.02,99.05 346.49,100.57 346.49,105.14 343.44,108.19 343.44,109.21 v341.92,110.73 | v348.02,117.84 v343.95,121.91 | v348.52,238.24 348.52,237.22 v356.65,229.1 | v352.08,210.3 352.08,207.76 352.59,207.25 352.59,200.65 v363.26,189.98 | v391.7,163.06 v383.58,171.18
  Bottom 0.254: v340.9,59.42 339.89,58.41 339.89,55.36 342.94,52.31 342.94,50.28 342.43,49.77 342.43,46.22 341.41,45.2 D04.L1 | v350.56,64.5 352.08,64.5 352.08,65.52 352.59,66.03 352.59,67.55 352.08,68.06 352.08,78.22 v350.56,79.74 | v343.95,247.38 345.98,245.35 345.98,240.78 v348.52,238.24 | v354.11,226.56 353.1,225.54 353.1,223.51 351.57,221.98 351.57,210.81 v352.08,210.3 | v382.05,183.88 384.08,181.85 384.08,171.69 v383.58,171.18 | v391.7,163.06 392.21,162.55 392.21,155.44 v391.2,154.42 | v385.1,120.38 v385.1,108.19
IM_06\  (via drill 0.61)
  Top 0.254: v387.13,45.2 385.61,45.2 385.1,45.71 364.78,45.71 361.73,42.66 350.05,42.66 349.54,42.15 345.48,42.15 344.97,41.64 D04.M1 | v388.66,145.28 332.78,145.28 v332.27,145.78 | v332.27,187.44 337.86,187.44 B04.H2 338.87,187.44 341.41,187.44 342.94,188.96 344.97,188.96 345.98,187.95 348.52,187.95 | 348.52,187.95 350.56,187.95 B03.H2 | 348.52,187.95 v348.52,188.96
  Bottom 0.254: v387.13,45.2 387.13,51.8 386.12,52.82 386.12,84.32 387.64,85.84 387.64,99.05 389.16,100.57 389.16,106.67 388.66,107.18 388.66,140.7 388.15,141.21 388.15,144.77 v388.66,145.28 | v332.27,145.78 331.76,146.29 331.76,162.04 332.78,163.06 332.78,179.31 331.76,180.33 331.76,186.93 v332.27,187.44 | v348.52,188.96 349.03,189.47 349.03,236.21 345.48,239.76 345.48,243.32 344.97,243.83 A04.M1
IM_07\  (via drill 0.61)
  Top 0.254: 345.48,184.39 347,184.39 B03.J2 | 345.48,184.39 343.44,184.39 342.43,185.41 335.82,185.41 335.32,184.9 B04.J2 | 345.48,184.39 v345.48,183.88
  Bottom 0.254: 345.98,183.38 345.98,36.56 344.97,35.55 D04.P1 | v345.48,183.88 345.98,183.38 | 345.98,183.38 345.98,236.72 344.97,237.73 A04.P1
IM_08\  (via drill 0.61)
  Top 0.254: v380.53,30.47 369.86,30.47 368.84,29.45 367.83,29.45 365.29,26.91 350.05,26.91 349.54,27.42 345.48,27.42 344.97,27.93 D04.S1 | 377.48,145.78 v377.99,146.29 | 377.48,145.78 340.4,145.78 v339.89,146.29 | 338.87,171.18 335.32,171.18 B04.N2 | v339.38,171.18 338.87,171.18 | 338.87,171.18 340.4,172.71 342.43,172.71 343.44,171.69 347,171.69 B03.N2 | v389.67,230.11 345.98,230.11 344.97,231.13 A04.S1 | v390.69,146.29 384.08,146.29 383.58,145.78 377.48,145.78
  Bottom 0.254: v380.53,30.47 381.04,30.98 381.04,35.55 384.08,38.6 384.08,69.58 381.04,72.63 381.04,73.65 383.58,76.19 383.58,88.38 377.99,93.97 v377.99,146.29 | v339.89,146.29 339.89,166.61 340.9,167.63 340.9,169.66 v339.38,171.18 | v389.67,230.11 389.16,229.6 389.16,200.65 388.66,200.14 388.66,186.42 390.18,184.9 390.18,180.84 389.16,179.82 389.16,152.9 390.18,151.88 390.18,146.8 v390.69,146.29
IM_09\  (via drill 0.61)
  Top 0.254: v333.79,170.17 349.03,170.17 350.56,168.64 B03.P2
  Bottom 0.254: D04.D2 334.81,64 333.79,65.01 333.79,145.78 334.3,146.29 334.3,150.86 333.28,151.88 333.28,160.52 333.79,161.02 v333.79,170.17 333.79,212.33 333.28,212.84 333.28,264.66 334.81,266.18 A04.D2
IM_10\  (via drill 0.61)
  Top 0.254: v357.67,50.79 356.14,52.31 350.05,52.31 347,55.36 340.4,55.36 339.89,55.87 338.87,55.87 338.87,59.93 D04.E2 | v367.32,54.34 368.84,55.87 386.12,55.87 388.15,57.9 v390.69,57.9 | v391.2,105.65 389.67,107.18 389.67,117.84 391.2,117.84 391.7,118.35 391.7,122.92 v390.18,122.92 | v379.51,154.42 379.51,156.96 380.02,156.96 381.04,157.98 381.04,160.01 390.18,160.01 v391.2,158.99 | v380.53,172.71 380.53,176.77 381.04,177.28 381.04,179.82 v380.02,179.82 | v377.99,188.46 381.54,188.46 386.12,193.03 386.12,210.81 v382.56,210.81 | v382.56,236.21 383.07,236.72 383.58,236.72 390.18,243.32 390.18,250.43 v385.1,250.43 | v375.45,287.01 v345.48,287.01 | v341.41,264.15 340.9,263.64 338.87,263.64 A04.E2
  Route2 0.254: v357.67,50.79 360.72,47.74 v367.32,54.34
  Route15 0.254: v390.18,122.92 390.18,140.2 388.66,141.72 388.66,143.75 381.04,151.37 381.04,152.9 v379.51,154.42 | v391.2,158.99 390.18,160.01 390.18,163.06 v380.53,172.71 | v380.02,179.82 380.02,181.34 377.99,183.38 v377.99,188.46 | v382.56,210.81 382.56,215.38 389.16,221.98 v382.05,229.1
  Bottom 0.254: v390.69,57.9 390.69,69.08 390.18,69.58 390.18,75.17 389.67,75.68 389.67,95.49 391.2,97.02 v391.2,105.65 | v382.05,229.1 381.04,230.11 381.04,233.16 381.54,233.67 381.54,235.19 v382.56,236.21 | v385.1,250.43 384.08,251.45 384.08,278.37 v375.45,287.01 | v345.48,287.01 342.94,284.47 342.94,265.67 v341.41,264.15
IM_11\  (via drill 0.61)
  Top 0.254: v317.54,15.23 316.01,13.7 280.96,13.7 279.94,14.72 266.23,14.72 265.72,14.21 238.8,14.21 236.76,12.18 v236.76,11.67 | v232.7,11.67 231.18,11.67 229.65,10.15 204.76,10.15 203.74,11.16 190.54,11.16 189.52,10.15 132.12,10.15 131.1,11.16 123.99,11.16 122.46,12.69 v84.87,12.69 | v60.49,147.31 58.96,148.83 v30.52,148.83 | v27.98,291.58 27.98,293.61 54.39,293.61 56.42,291.58 61,291.58 62.01,290.56 67.09,290.56 67.6,290.06 97.57,290.06 98.08,290.56 108.24,290.56 110.78,293.1 117.89,293.1 118.4,292.6 136.18,292.6 138.72,295.14 163.61,295.14 165.64,293.1 194.6,293.1 195.62,294.12 207.81,294.12 208.82,295.14 v211.36,295.14 | v249.46,283.96 v242.86,283.96 | v254.04,293.61 254.54,294.12 265.21,294.12 266.74,292.6 281.47,292.6 282.99,294.12 293.15,294.12 293.66,294.63 305.85,294.63 306.87,295.64 v333.28,295.64 | v356.65,188.96 356.65,189.98 v363.26,196.58 | v351.57,253.99 350.56,255 349.03,255 348.52,255.51 344.46,255.51 343.95,256.02 339.89,256.02 338.87,257.04 A04.H2
  Route2 0.254: v318.04,33.52 333.79,49.26 335.82,49.26 336.84,50.28 336.84,51.8 337.86,52.82 337.86,53.33 D04.H2 | v356.65,188.96 342.94,175.25 342.94,170.68 341.41,169.15 339.38,169.15 338.87,168.64 B04.P2 | v363.26,196.58 365.29,198.62 365.29,199.63 368.34,202.68 368.34,208.27 368.84,208.78 v368.84,210.3
  Route15 0.254: v366.81,226.56 365.29,228.08 365.29,232.65 v360.21,237.73
  Bottom 0.254: v318.04,33.52 317.03,32.5 317.03,29.45 320.08,26.4 320.08,17.77 v317.54,15.23 | v232.7,11.67 v236.76,11.67 | v84.87,12.69 66.58,12.69 66.58,33.01 62.01,37.58 62.01,145.78 v60.49,147.31 | v30.52,148.83 28.99,150.36 28.99,245.35 28.48,245.86 28.48,291.07 v27.98,291.58 | v211.36,295.14 213.9,295.14 213.9,293.61 214.41,293.1 242.86,293.1 v242.86,283.96 | v249.46,283.96 254.04,288.53 v254.04,293.61 | v333.28,295.64 333.79,295.14 333.79,270.24 336.84,267.2 336.84,258.56 337.86,257.54 A04.H2 | v368.84,210.3 369.35,210.81 369.35,222.49 366.81,225.03 v366.81,226.56 | v360.21,237.73 352.59,245.35 352.59,252.46 351.57,253.48 v351.57,253.99
INT_RQ\  (via drill 0.61)
  Top 0.254: v231.18,254.5 231.18,253.99 232.7,252.46 234.22,252.46 236.26,254.5 237.78,254.5 237.78,252.46 236.76,251.45 A12.K1 | v234.73,288.53 235.24,288.02 237.78,288.02 238.29,287.52 239.81,287.52 240.32,287.01 287.06,287.01 287.56,287.52 291.63,287.52 v292.14,288.02 | v290.1,266.69 294.68,262.12 v299.25,262.12 | v298.74,240.27 v302.8,236.21 | v302.3,216.4 308.39,216.4 v309.92,214.87
  Route2 0.254: v293.15,270.75 293.15,269.74 v290.1,266.69
  Route15 0.254: v231.18,254.5 233.21,256.53 233.21,257.54 236.76,261.1 v234.22,263.64 | v302.8,228.08 v300.77,226.05 | v309.92,214.87 320.58,204.2 320.58,202.68 v321.6,201.66
  Bottom 0.254: v234.22,263.64 234.73,264.15 234.73,275.32 235.24,275.83 235.24,281.42 234.73,281.93 234.73,283.96 235.24,284.47 235.24,288.02 v234.73,288.53 | v292.14,288.02 291.63,287.52 291.63,277.36 292.14,276.85 292.14,271.77 v293.15,270.75 | v299.25,262.12 298.74,261.61 v298.74,240.27 | v302.8,236.21 304.33,234.68 304.33,232.65 304.84,232.14 304.84,230.11 v302.8,228.08 | v300.77,226.05 301.28,225.54 301.28,221.48 302.3,220.46 v302.3,216.4 | v321.6,201.66 325.16,201.66 325.16,202.17 B05.B1
IOP_1  (via drill 0.61)
  Top 0.254: C05.P2 322.62,105.14 323.63,106.16 329.22,106.16 330.24,105.14 337.86,105.14 C04.P2 | v339.89,91.43 340.9,90.41 343.95,90.41 347,87.36 350.56,87.36 v352.08,88.89 | v353.1,83.81 353.6,84.32 360.72,84.32 v361.22,83.81
  Bottom 0.254: 361.73,83.81 361.73,208.27 361.22,208.78 361.22,220.46 361.73,220.97 361.73,245.35 363.26,246.88 363.26,250.43 A02.K2 | 361.73,83.81 361.73,49.77 363.26,48.25 D02.K2 | v339.89,91.43 339.89,102.6 338.36,104.13 C04.P2 | v352.08,88.89 353.1,87.87 v353.1,83.81 | 361.73,83.81 v361.22,83.81
IOP_2  (via drill 0.61)
  Top 0.254: C05.R2 319.57,102.1 v323.12,102.1 323.63,102.1 324.65,103.11 327.19,103.11 328.71,101.59 C04.R2 | v362.24,33.52 334.3,33.52 328.2,39.61 327.7,39.61 v324.65,42.66 | v379.51,244.84 377.48,242.81 369.86,242.81 369.35,243.32 365.29,243.32 364.27,244.34 A02.M2 | v381.54,246.88 384.08,249.42 384.08,251.45 386.62,251.45 387.13,251.96 387.13,255.51 v386.12,255.51 | v372.91,292.09 369.86,295.14 334.3,295.14 333.79,294.63 v329.22,294.63 | v305.34,276.85 305.34,274.82 300.26,274.82 v299.76,275.32 | v297.22,273.8 296.71,274.31 292.64,274.31 292.14,273.8 292.14,272.78 v290.1,272.78 | v253.53,224.02 v243.88,224.02 | v241.34,230.62 237.78,230.62 237.27,230.11 232.7,230.11 227.62,225.03 223.56,225.03 222.03,223.51 v222.03,223 | v215.94,260.08 214.41,261.61 196.63,261.61 v196.12,261.1 | v195.62,295.64 194.6,296.66 137.2,296.66 134.66,294.12 119.92,294.12 119.42,294.63 109.26,294.63 106.72,292.09 77.25,292.09 76.74,291.58 69.12,291.58 67.09,293.61 57.95,293.61 56.93,294.63 31.02,294.63 29.5,296.15 v27.98,296.15
  Route2 0.254: v299.76,275.32 298.74,275.32 v297.22,273.8 | v290.61,247.89 284.52,241.8 283.5,241.8 275.88,234.18 273.34,234.18 v270.29,231.13
  Route15 0.254: v270.29,231.13 269.28,230.11 269.28,229.6 265.72,226.05 264.7,226.05 262.16,223.51 261.66,224.02 v253.53,224.02 | v243.88,224.02 245.91,226.05 v241.34,230.62 | v27.47,140.2 33.06,145.78 40.17,138.67 41.69,138.67 57.95,122.42 61,122.42 106.21,77.2 115.35,77.2 159.55,33.01 160.06,33.01 166.15,26.91 169.2,26.91 178.34,17.77 180.88,17.77 181.39,17.26 189.01,17.26 204.25,2.02 244.89,2.02 245.4,1.51 285.02,1.51 306.36,22.85 308.39,20.82 310.93,20.82 312.96,22.85 315,20.82 323.12,20.82 331.25,28.94 328.71,31.48 328.71,31.99 326.68,34.02 326.68,40.63 v324.65,42.66
  Bottom 0.254: v362.24,33.52 362.24,39.61 363.26,40.63 D02.M2 | v324.65,42.66 320.58,46.72 320.58,70.6 318.04,73.14 318.04,83.81 323.63,89.4 323.63,101.59 v323.12,102.1 | v381.54,246.88 v379.51,244.84 | v386.12,255.51 386.12,278.88 v372.91,292.09 | v329.22,294.63 317.54,294.63 317.54,295.64 316.01,297.17 305.34,297.17 v305.34,276.85 | v290.1,272.78 292.14,270.75 292.14,260.08 291.63,259.58 291.63,258.05 292.14,257.54 292.14,255.51 291.63,255 291.63,251.96 292.14,251.45 292.14,249.42 v290.61,247.89 | v222.03,223 222.03,227.06 219.49,229.6 219.49,255 215.94,258.56 v215.94,260.08 | v196.12,261.1 196.63,261.61 196.63,291.07 195.62,292.09 v195.62,295.64 | v27.98,296.15 22.39,290.56 22.39,145.28 v27.47,140.2
IOP_4  (via drill 0.61)
  Top 0.254: C05.S2 322.62,98.54 326.68,98.54 328.2,100.06 329.22,100.06 330.24,99.05 337.86,99.05 C04.S2 338.87,98.54 341.41,98.54 342.94,100.06 v362.75,100.06
  Bottom 0.254: 362.24,99.56 362.24,90.92 363.76,89.4 363.76,78.22 365.29,76.7 365.29,46.22 364.78,45.71 364.78,36.56 363.76,35.55 D02.P2 | 362.24,99.56 v362.75,100.06 | 362.24,99.56 362.24,207.25 363.26,208.27 363.26,221.48 365.29,223.51 365.29,232.14 364.27,233.16 364.27,237.73 A02.P2
LDMF  (via drill 0.61)
  Top 0.254: v324.14,128 324.14,130.04 325.16,131.05 327.7,131.05 328.2,130.54 C05.E1 | v289.6,55.36 289.09,54.85 v287.06,54.85 | v253.02,54.34 249.97,54.34 D11.H1
  Route2 0.254: v324.14,128 312.96,116.83 311.95,116.83 306.36,111.24 306.36,110.22 309.41,107.18 298.74,96.51 298.74,94.98 297.72,94.98 v291.12,88.38 | v287.06,54.85 279.44,62.47 272.83,55.87 267.24,55.87 266.74,55.36 254.04,55.36 v253.02,54.34
  Bottom 0.254: D11.B1 245.91,69.08 245.91,66.54 243.37,64 240.32,64 D11.D2 239.81,62.98 239.81,59.93 244.38,55.36 244.38,54.34 248.96,54.34 D11.H1 | v291.12,88.38 291.63,87.87 291.63,85.33 293.15,83.81 293.15,72.63 289.09,68.57 289.09,55.87 v289.6,55.36
LDMF\  (via drill 0.61)
  Top 0.254: v287.06,167.63 284.52,167.63 B08.P2 | v288.07,160.52 288.58,160.01 291.12,160.01 292.14,161.02 295.18,161.02 296.2,160.01 303.82,160.01 304.84,161.02 307.88,161.02 308.9,160.01 312.96,160.01 v313.47,160.52 | v318.55,156.45 319.06,156.96 v322.11,156.96
  Route15 0.254: v313.47,160.52 314.49,160.52 v318.55,156.45 | v325.16,143.24 v329.73,138.67
  Bottom 0.254: v287.06,167.63 288.58,166.1 288.58,161.02 v288.07,160.52 | v322.11,156.96 323.63,156.96 323.63,151.88 323.12,151.37 323.12,145.78 325.16,143.75 v325.16,143.24 | v329.73,138.67 330.24,138.16 330.24,131.05 331.25,130.04 331.25,128.51 329.73,126.99 C05.F1
LPB_00  (via drill 0.61)
  Top 0.254: v4.1,214.87 9.69,220.46 32.55,220.46 42.2,230.11 43.72,230.11 44.23,229.6 48.3,229.6 48.8,229.1 A25.T2 | v4.1,22.34 19.85,6.59 109.26,6.59 111.8,9.13 120.94,9.13 122.97,7.1 192.57,7.1 193.58,8.12 200.7,8.12 201.71,7.1 233.72,7.1 234.73,8.12 241.84,8.12 242.35,7.61 250.99,7.61 252.51,6.08 283.5,6.08 284.52,7.1 v297.72,7.1 | v297.72,61.96 296.2,61.96 295.69,61.46 295.69,59.93 291.12,59.93 D08.E1
  Route15 0.254: v297.22,119.37 287.56,129.02 287.56,132.58 C08.D1
  Bottom 0.254: v4.1,214.87 3.59,214.36 3.59,209.79 4.61,208.78 4.61,151.88 3.59,150.86 3.59,148.83 4.61,147.82 4.61,22.85 v4.1,22.34 | v297.72,7.1 298.23,7.61 298.23,52.82 | 298.23,52.82 298.23,56.38 297.22,57.39 297.22,58.41 298.23,59.42 298.23,61.46 v297.72,61.96 | v297.22,119.37 301.79,114.8 301.79,91.43 302.8,90.41 303.82,90.41 303.82,77.71 300.77,74.66 300.77,71.62 301.28,71.11 301.28,55.87 298.23,52.82
LPB_00\  (via drill 0.61)
  Top 0.254: v283.5,43.17 281.98,43.17 278.42,39.61 264.2,39.61 262.67,41.14 D10.M1 | v282.99,56.88 287.06,56.88 D08.F1
  Bottom 0.254: v283.5,43.17 282.99,43.68 v282.99,56.88
LPB_01  (via drill 0.61)
  Top 0.254: v51.85,220.46 51.34,219.95 12.74,219.95 v4.61,211.82 | v4.61,20.31 18.83,6.08 109.76,6.08 112.3,8.62 120.43,8.62 122.46,6.59 193.08,6.59 194.09,7.61 200.19,7.61 201.2,6.59 234.22,6.59 235.24,7.61 241.34,7.61 241.84,7.1 250.48,7.1 252,5.58 284.52,5.58 v285.02,6.08 | v279.44,96 279.44,93.97 v282.99,90.41 | v281.98,73.14 280.96,72.12 v279.94,72.12 | v284.52,62.47 285.02,61.96 293.66,61.96 v294.68,60.95 | v293.15,47.23 290.61,44.69 288.07,44.69 D08.L1
  Route2 0.254: v279.44,96 289.09,105.65 289.09,111.75 290.1,112.76 290.1,116.83 C08.K1
  Bottom 0.254: v51.85,220.46 51.85,225.03 A25.U2 | v4.61,211.82 5.12,211.32 5.12,151.37 4.1,150.36 4.1,149.34 5.12,148.32 5.12,20.82 v4.61,20.31 | v285.02,6.08 285.02,20.82 286.04,21.83 286.04,42.66 287.06,43.68 D08.L1 | v282.99,90.41 282.99,87.87 279.94,84.82 279.94,75.17 v281.98,73.14 | v279.94,72.12 279.44,71.62 279.44,69.08 279.94,68.57 282.48,68.57 282.48,64.5 v284.52,62.47 | v294.68,60.95 295.18,60.44 295.18,49.26 v293.15,47.23
LPB_01\  (via drill 0.61)
  Top 0.254: v260.13,29.45 260.64,29.96 270.8,29.96 v271.82,28.94 | v277.4,35.55 278.42,36.56 283.5,36.56 287.56,40.63 290.1,40.63 D08.M1
  Bottom 0.254: v260.13,29.45 260.13,36.56 259.12,37.58 D10.N1 | v271.82,28.94 274.86,25.9 277.4,25.9 v277.4,35.55
LPB_02  (via drill 0.61)
  Top 0.254: v46.77,209.28 18.83,209.28 17.82,208.27 v3.59,208.27 | v3.59,24.37 19.34,8.62 109.26,8.62 110.78,10.15 121.96,10.15 122.46,9.64 123.48,9.64 125,8.12 191.55,8.12 192.57,9.13 201.71,9.13 202.73,8.12 232.7,8.12 233.72,9.13 242.86,9.13 243.37,8.62 252,8.62 253.02,7.61 276.9,7.61 277.4,8.12 v278.93,8.12 | v278.93,26.91 289.09,26.91 290.1,27.93 D08.S1 291.12,28.44 293.66,28.44 295.18,29.96 326.17,29.96 v326.68,30.47 | v289.09,85.84 289.6,85.33 308.9,85.33 313.47,80.76 v314.49,80.76
  Route15 0.254: v287.56,91.43 289.09,92.95 289.09,96.51 287.06,98.54 287.06,101.08 C08.R1 | v320.58,74.66 v314.49,80.76
  Bottom 0.254: v46.77,209.28 47.28,209.79 47.28,216.9 48.3,217.92 48.3,220.46 49.31,221.48 A25.V2 | v3.59,208.27 4.1,207.76 4.1,152.39 3.08,151.37 3.08,148.32 4.1,147.31 4.1,24.88 v3.59,24.37 | v278.93,8.12 278.42,8.62 278.42,26.4 v278.93,26.91 | v287.56,91.43 289.09,89.9 v289.09,85.84 | v320.58,74.66 323.63,74.66 323.63,73.65 326.68,70.6 326.68,52.31 327.19,51.8 327.19,48.76 326.68,48.25 326.68,46.22 327.19,45.71 327.19,42.66 326.68,42.15 v326.68,30.47
LPB_02\  (via drill 0.61)
  Top 0.254: v263.69,16.75 v290.1,16.75
  Bottom 0.254: v263.69,16.75 263.18,17.26 263.18,34.02 262.67,34.53 D10.P1 | v290.1,16.75 290.1,21.83 D08.U1
LPB_03  (via drill 0.61)
  Top 0.254: v12.23,271.77 15.28,274.82 38.14,274.82 39.15,275.83 A26.A2 | v8.67,2.02 9.18,1.51 112.3,1.51 115.86,5.07 116.88,5.07 118.91,3.04 243.88,3.04 244.89,4.05 246.92,4.05 248.45,2.53 288.58,2.53 v289.09,3.04 | v289.6,52.31 288.58,53.33 284.52,53.33 D08.H2 | v297.72,101.59 296.2,100.06 288.58,100.06 v288.07,99.56
  Route15 0.254: v296.71,109.21 286.55,119.37 286.04,119.37 284.01,121.4 284.01,123.43 C08.H2 | v287.06,97.02 286.55,97.02 284.01,94.48 v284.52,93.97
  Bottom 0.254: v12.23,271.77 8.67,268.21 v8.67,2.02 | v289.09,3.04 289.09,51.8 v289.6,52.31 | v296.71,109.21 298.23,107.68 298.23,102.1 v297.72,101.59 | v288.07,99.56 287.06,98.54 v287.06,97.02 | v284.52,93.97 283.5,93.97 283.5,93.46 281.98,91.94 281.98,89.9 282.48,89.4 282.48,88.38 279.44,85.33 279.44,74.16 285.53,68.06 285.53,55.36 284.52,54.34 D08.H2
LPB_03\  (via drill 0.61)
  Top 0.254: v259.12,34.53 261.15,36.56 272.83,36.56 275.37,39.1 279.44,39.1 v282.48,42.15
  Bottom 0.254: v259.12,34.53 259.12,32.5 D10.R1 | v282.48,42.15 282.48,46.72 280.96,48.25 280.96,50.28 D08.J2
LPB_04  (via drill 0.61)
  Top 0.254: v14.77,267.7 18.83,271.77 35.09,271.77 36.1,272.78 A26.B2 | v45.76,7.61 46.26,8.12 109.76,8.12 111.29,9.64 121.45,9.64 121.96,9.13 122.97,9.13 124.5,7.61 192.06,7.61 193.08,8.62 201.2,8.62 202.22,7.61 233.21,7.61 234.22,8.62 242.35,8.62 242.86,8.12 251.5,8.12 252.51,7.1 v277.91,7.1 | v278.42,34.53 278.93,35.04 283.5,35.04 D08.P2 284.52,35.04 288.07,35.04 289.6,36.56 307.38,36.56 v309.41,38.6 | v275.37,106.67 279.44,106.67 280.45,107.68 C08.N2 | v278.93,92.95 282.99,88.89 285.53,88.89 286.04,88.38 286.04,87.36 v295.69,87.36 | v295.69,75.17 296.2,74.66 298.74,74.66 v303.82,69.58
  Route15 0.254: v273.34,97.02 274.86,97.02 v278.93,92.95 | v308.9,64.5 v303.82,69.58
  Bottom 0.254: v14.77,267.7 9.18,262.12 9.18,44.18 v45.76,7.61 | v277.91,7.1 277.91,34.02 v278.42,34.53 | v275.37,106.67 275.88,106.16 275.88,97.52 275.37,97.02 v273.34,97.02 | v295.69,75.17 v295.69,87.36 | v308.9,64.5 308.39,64 308.39,51.3 311.44,48.25 311.44,40.63 v309.41,38.6
LPB_04\
  Top 0.254: D10.R2 253.02,31.99 254.04,33.01 278.42,33.01 279.44,31.99 280.45,31.99 D08.R2
LPB_05  (via drill 0.61)
  Top 0.254: v280.45,9.64 279.94,9.13 255.56,9.13 254.54,8.12 253.53,8.12 252.51,9.13 243.88,9.13 243.37,9.64 237.78,9.64 | v237.27,10.15 237.78,9.64 | v237.27,69.58 v239.3,71.62 | v240.83,76.7 241.34,77.2 250.99,77.2 252.51,75.68 v266.74,75.68 | v266.74,72.12 267.24,71.62 v272.32,71.62 | v275.37,76.19 279.94,80.76 279.94,83.81 v280.96,83.81 | v11.72,263.13 19.85,271.26 38.14,271.26 39.15,270.24 A26.C2 | v48.3,9.64 109.26,9.64 110.27,10.66 122.46,10.66 122.97,10.15 123.99,10.15 125.51,8.62 191.04,8.62 192.06,9.64 202.22,9.64 203.24,8.62 232.19,8.62 233.21,9.64 237.78,9.64
  Bottom 0.254: v280.45,9.64 280.45,17.77 280.96,18.28 D08.V2 | v237.27,10.15 237.78,10.66 237.78,24.88 235.24,27.42 235.24,41.64 234.73,42.15 234.73,64 235.75,65.01 237.78,65.01 237.78,69.08 v237.27,69.58 | v239.3,71.62 240.83,73.14 v240.83,76.7 | v266.74,75.68 v266.74,72.12 | v272.32,71.62 273.34,72.63 273.34,74.16 v275.37,76.19 | v280.96,83.81 280.96,84.82 284.01,87.87 284.01,91.43 C08.U2 | v11.72,263.13 9.69,261.1 9.69,48.25 v48.3,9.64
LPB_05\
  Top 0.254: D08.V1 287.06,18.28 286.04,17.26 264.7,17.26 261.66,20.31 258.61,20.31 257.08,21.83 256.07,21.83 D10.U2
  Bottom 0.254: D10.T2 253.02,24.88 255.05,22.85 255.05,22.34 D10.U2 255.56,22.85 255.56,27.93 D10.S2
LPB_NOT_EQ_1  (via drill 0.61)
  Top 0.254: v252,21.83 249.97,23.86 244.89,23.86 244.38,24.37 240.83,24.37 240.32,23.86 239.3,23.86 238.8,24.37 234.73,24.37 234.22,23.86 v232.19,23.86 | v219.49,23.36 218.98,23.86 213.9,23.86 212.89,22.85 210.86,22.85 206.79,18.78 206.79,17.26 205.27,15.74 200.19,15.74 199.17,14.72 186.98,14.72 185.96,13.7 135.67,13.7 134.66,14.72 132.62,14.72 131.61,15.74 117.38,15.74 116.88,16.24 95.54,16.24 94.52,17.26 83.35,17.26 v82.84,17.77 | v65.57,193.03 67.09,194.55 87.92,194.55 88.43,195.06 v94.02,195.06 | v94.52,221.48 95.03,220.97 100.11,220.97 100.62,221.48 100.62,223.51 110.27,223.51 110.78,224.02 116.88,224.02 120.94,228.08 v122.46,228.08 | v133.13,270.75 133.64,271.26 142.28,271.26 142.78,270.75 146.34,270.75 146.85,271.26 161.58,271.26 v162.09,270.75 | v220.51,260.59 221.02,260.08 225.08,260.08 226.1,259.07 v238.29,259.07 | v259.12,244.84 261.66,244.84 A10.M1
  Route2 0.254: v205.78,263.64 208.32,261.1 209.33,261.1 209.84,261.61 219.49,261.61 v220.51,260.59
  Route15 0.254: v122.46,228.08 122.46,229.6 125.51,232.65 v126.02,232.14 | v183.42,273.29 192.06,281.93 v198.16,275.83 | v246.92,250.94 248.45,249.42 254.54,249.42 v259.12,244.84
  Bottom 0.254: v252,21.83 252,20.31 252.51,19.8 D10.V2 | v232.19,23.86 232.19,15.23 230.67,13.7 224.57,13.7 224.57,10.66 224.06,10.15 219.49,10.15 v219.49,23.36 | v82.84,17.77 62.52,38.09 62.52,143.75 65.57,146.8 65.57,148.32 63.03,150.86 63.03,154.93 62.52,155.44 62.52,189.98 v65.57,193.03 | v94.02,195.06 95.03,196.08 95.03,220.97 v94.52,221.48 | v126.02,232.14 129.58,235.7 130.59,235.7 130.59,252.97 130.08,253.48 130.08,267.7 v133.13,270.75 | v162.09,270.75 162.09,275.32 164.63,277.86 181.39,277.86 181.39,275.32 v183.42,273.29 | v198.16,275.83 206.28,267.7 206.28,264.15 v205.78,263.64 | v238.29,259.07 237.78,259.58 237.78,262.62 238.29,263.13 239.3,263.13 241.34,261.1 241.34,256.53 v246.92,250.94
LPB_TO_DTB  (via drill 0.61)
  Top 0.254: v290.1,132.07 285.53,127.5 281.47,127.5 C08.F2 | v241.34,221.48 242.35,220.46 275.37,220.46 v275.88,220.97 | v291.63,147.82 v276.39,147.82 | v280.45,111.24 283.5,111.24 C08.M2
  Bottom 0.254: 286.55,117.34 287.06,117.84 287.06,119.88 C08.J1 | 286.55,117.34 285.02,115.81 285.02,112.26 284.52,111.75 C08.M2 | 286.55,117.34 289.09,114.8 289.09,106.16 290.1,105.14 C08.P1 | 279.44,111.24 279.44,124.96 280.45,125.97 280.45,126.48 C08.F2 | 279.44,111.24 279.44,97.52 280.96,96 C08.T2 | v290.1,132.07 290.1,136.13 C08.C1 290.61,137.15 290.61,139.69 292.14,141.21 292.14,147.31 v291.63,147.82 | v241.34,221.48 241.34,223 240.32,224.02 240.32,228.08 A11.T2 | v275.88,220.97 276.39,220.46 276.39,192.52 276.9,192.01 276.9,148.32 v276.39,147.82 | 279.44,111.24 v280.45,111.24
M-STOP\  (via drill 0.61)
  Top 0.254: v196.12,223.51 196.63,224.02 211.87,224.02 214.92,220.97 234.73,220.97 v235.24,221.48 | v235.24,228.59 236.26,229.6 238.8,229.6 239.3,230.11 240.32,230.11 240.83,229.6 244.38,229.6 246.42,231.64 248.96,231.64 A11.S1 | B14.D1 203.74,197.6 199.68,197.6 199.17,198.11 v194.6,198.11 193.58,199.12 192.57,199.12 191.55,198.11 181.9,198.11 v180.88,199.12 | v193.58,28.44 192.06,29.96 178.85,29.96 178.34,30.47 170.22,30.47 169.71,29.96 164.12,29.96 v162.09,27.93 | v140.75,37.58 138.72,39.61 120.94,39.61 116.37,44.18 112.3,44.18 110.78,45.71 95.54,45.71 v95.03,45.2 | v95.03,156.45 97.57,153.91 114.84,153.91 117.38,156.45 v118.91,156.45 | v119.92,179.31 129.58,179.31 v134.66,184.39 | v139.74,193.03 139.74,194.04 141.26,195.57 170.22,195.57 171.23,194.55 v173.26,194.55 | v293.15,111.24 291.12,109.21 284.52,109.21 v284.01,108.7 | v262.16,83.3 261.15,82.28 247.43,82.28 246.92,82.79 240.32,82.79 v239.3,81.78 | v214.92,44.69 213.9,45.71 206.79,45.71 205.78,44.69 D14.L1
  Route2 0.254: v173.26,194.55 173.77,194.55 178.85,199.63 180.38,199.63 v180.88,199.12 | v293.15,111.24 295.69,113.78 295.69,115.3 296.71,116.32 296.71,116.83 C07.K2 | v284.01,108.7 284.01,108.19 278.93,103.11 278.93,100.06 272.32,93.46 271.31,93.46 270.8,92.95 270.8,91.94 v262.16,83.3 | v228.64,69.58 228.64,69.08 228.13,68.57 225.59,68.57 v217.97,60.95 | v214.92,44.69 v216.95,46.72
  Route15 0.254: v198.16,53.33 v196.12,51.3 | v239.3,81.78 231.68,74.16 231.68,72.12 231.18,71.62 230.67,71.62 v228.64,69.58
  Bottom 0.254: v194.6,198.11 194.09,198.62 194.09,208.27 196.63,210.81 196.63,223 v196.12,223.51 | v235.24,221.48 v235.24,228.59 | v198.16,53.33 198.66,53.33 203.24,48.76 203.24,46.72 204.76,45.2 D14.L1 | v196.12,51.3 196.63,50.79 196.63,31.99 193.58,28.94 v193.58,28.44 | v162.09,27.93 154.98,20.82 148.88,20.82 148.88,24.88 142.78,30.98 142.78,35.55 v140.75,37.58 | v95.03,45.2 95.54,45.71 95.54,85.84 95.03,86.35 v95.03,156.45 | v118.91,156.45 120.43,156.45 120.43,178.8 v119.92,179.31 | v134.66,184.39 135.67,185.41 135.67,185.92 139.74,189.98 v139.74,193.03 | v217.97,60.95 217.97,58.92 218.98,57.9 218.98,48.76 v216.95,46.72
MB_TO_DTB\
  Top 0.254: D12.H1 236.26,54.34 234.22,56.38 233.72,56.38 D12.F1
  Bottom 0.254: D12.J1 233.21,51.3 233.21,56.38 D12.F1 | D12.S1 237.27,28.94 237.78,29.45 237.78,46.72 237.27,47.23 D12.K1 236.26,48.25 236.26,53.33 D12.H1
MC00  (via drill 0.61)
  Top 0.254: B13.E2 214.92,193.03 220,193.03 B13.E1 | 26.45,222.49 25.94,222.49 24.93,223.51 v18.83,223.51 | 26.45,222.49 27.98,222.49 35.6,230.11 40.17,230.11 41.18,231.13 45.76,231.13 A26.S1 | v18.83,259.07 27.98,268.21 47.79,268.21 51.34,271.77 68.62,271.77 69.63,270.75 73.19,270.75 73.7,271.26 76.24,271.26 79.28,268.21 88.94,268.21 89.44,268.72 92.49,268.72 93,268.21 97.57,268.21 100.11,265.67 102.14,265.67 102.65,265.16 v135.16,265.16 | v138.72,251.45 140.75,249.42 170.22,249.42 171.23,250.43 v173.77,250.43 | v183.42,216.4 183.42,211.32 184.95,211.32 185.96,210.3 200.7,210.3 v201.2,210.81 | v246.92,61.96 250.99,61.96 252,62.98 D10.D2 | v198.16,46.22 197.65,45.71 182.92,45.71 v181.9,44.69 | v117.89,39.61 114.84,42.66 61.5,42.66 57.95,46.22 v44.74,46.22 | v42.71,145.28 42.2,145.78 20.86,145.78 v19.34,147.31 | v19.85,210.3 v26.45,216.9 | v26.45,221.48 26.45,222.49
  Route2 0.254: v244.89,59.93 243.88,58.92 240.83,58.92 239.3,60.44 231.18,52.31 230.67,52.31 227.62,49.26 226.6,49.26 v221.52,44.18 | v217.46,28.44 211.36,34.53 210.35,34.53 209.84,35.04 209.84,35.55 198.66,46.72 v198.16,46.22
  Route15 0.254: v179.87,231.13 v182.41,228.59 | v201.2,210.81 205.78,206.24 205.78,204.2 212.38,197.6 212.38,195.57 213.9,194.04 B13.E2
  Bottom 0.254: v18.83,223.51 v18.83,259.07 | v135.16,265.16 136.18,265.16 136.18,254.5 136.69,253.99 136.69,253.48 v138.72,251.45 | v173.77,250.43 174.79,249.42 174.79,236.72 179.87,231.64 v179.87,231.13 | v182.41,228.59 183.93,227.06 183.93,216.9 v183.42,216.4 | v244.89,59.93 v246.92,61.96 | v221.52,44.18 222.03,43.68 222.03,31.99 219.49,29.45 219.49,28.94 218.98,28.44 v217.46,28.44 | v181.9,44.69 177.84,40.63 177.84,34.53 174.79,31.48 174.79,18.28 163.61,7.1 117.89,7.1 v117.89,39.61 | v44.74,46.22 44.23,46.72 44.23,142.23 42.71,143.75 v42.71,145.28 | v19.34,147.31 19.34,209.79 v19.85,210.3 | v26.45,216.9 v26.45,221.48
MC00\  (via drill 0.61)
  Top 0.254: v239.3,162.04 237.78,163.56 237.78,166.61 234.73,166.61 232.19,169.15 227.11,169.15 225.59,170.68 225.59,172.2 v224.57,172.2 | v224.57,183.88 223.05,185.41 v217.46,185.41 | v255.05,234.68 258.1,234.68 A10.R1 | v253.53,232.65 250.99,230.11 247.43,230.11 v246.92,230.62 | v246.92,204.71 241.34,204.71 240.32,205.73 v238.8,205.73 | v231.68,196.08 231.18,195.57 229.14,195.57 228.13,194.55 v217.97,194.55
  Route2 0.254: v239.3,162.04 239.3,158.99 B11.T2 | v238.8,205.73 238.8,204.2 v234.22,199.63
  Bottom 0.254: v224.57,172.2 v224.57,183.88 | v217.46,185.41 217.46,189.47 B13.F1 217.97,190.49 v217.97,194.55 | v255.05,234.68 253.53,233.16 v253.53,232.65 | v246.92,230.62 247.43,230.11 247.43,210.3 246.92,209.79 v246.92,204.71 | v234.22,199.63 231.68,197.09 v231.68,196.08
MC01  (via drill 0.61)
  Top 0.254: A26.T1 43.22,228.08 47.28,228.08 48.8,226.56 48.8,223.51 50.33,223.51 53.88,219.95 v209.84,219.95 v277.91,219.95 | v222.54,132.07 244.38,132.07 245.91,130.54 248.96,130.54 C11.E1
  Bottom 0.254: v209.84,219.95 209.84,194.04 213.9,189.98 213.9,187.44 B13.H2 B13.J1 218.98,182.36 218.98,173.72 222.54,170.17 v222.54,132.07 | v277.91,219.95 278.42,220.46 278.42,242.81 279.94,244.34 279.94,245.86 280.96,246.88 A08.L2
MC01\  (via drill 0.61)
  Top 0.254: v254.04,96.51 v249.97,96.51 | C11.B1 v249.97,139.69 250.48,139.69 252,138.16 253.53,138.16 v254.04,138.67 | v252.51,167.63 249.97,167.63 B11.P1 | v211.87,180.84 216.44,176.26 235.75,176.26 236.26,175.76 245.4,175.76 248.45,172.71 v248.96,172.71
  Bottom 0.254: v254.04,96.51 254.04,91.43 254.54,90.92 254.54,86.86 254.04,86.35 254.04,66.03 254.54,65.52 254.54,61.96 255.56,60.95 D10.E2 | v249.97,96.51 250.48,97.02 250.48,139.18 v249.97,139.69 | v252.51,167.63 254.04,166.1 v254.04,138.67 | v211.87,180.84 211.87,183.38 B13.J2 | v248.96,172.71 248.96,168.64 B11.P1
MC02  (via drill 0.61)
  Top 0.254: v227.11,59.93 229.65,59.93 D12.E2 | v49.82,225.03 54.39,220.46 208.32,220.46 v208.82,220.97 | v241.34,178.3 240.83,178.8 218.98,178.8 217.97,177.79 B13.L1 | v231.18,51.3 230.67,51.8 228.13,51.8 227.62,52.31 224.06,52.31 222.03,50.28 218.98,50.28 217.97,49.26 v216.44,49.26 | v215.94,40.12 212.89,37.07 212.38,37.07 211.87,36.56 146.85,36.56 143.8,33.52 v60.49,33.52
  Bottom 0.254: v227.11,59.93 227.11,62.98 D12.D2 | v49.82,225.03 46.77,225.03 A26.U1 45.76,225.03 45.25,224.52 45.25,209.28 47.28,207.25 47.28,152.39 51.85,147.82 51.85,146.29 61,137.15 61,34.02 v60.49,33.52 | v208.82,220.97 208.82,219.44 209.33,218.94 209.33,191.5 209.84,191 209.84,188.96 217.46,181.34 217.46,177.79 B13.L1 | v241.34,178.3 241.34,161.02 241.84,160.52 241.84,156.96 242.86,155.94 B11.U2 | v231.18,51.3 231.68,51.8 231.68,58.92 230.67,59.93 D12.E2 | v216.44,49.26 215.94,48.76 v215.94,40.12
MC02\  (via drill 0.61)
  Route2 0.254: v216.95,130.04 213.9,133.08 222.03,141.21 222.03,157.47 v229.65,165.09
  Route15 0.254: v253.53,65.01 253.53,66.03 247.94,71.62 247.94,75.17 v243.88,79.24 | v242.35,85.33 241.34,85.33 238.29,88.38 238.29,105.14 227.62,115.81 227.62,117.34 225.08,119.88 225.08,121.91 v216.95,130.04 | v229.65,165.09 225.08,169.66 225.08,170.17 223.05,172.2 223.05,172.71 221.02,174.74 B13.M1
  Bottom 0.254: B13.M1 220,174.74 220,178.8 219.49,179.31 219.49,198.11 220.51,199.12 B13.C1 | v253.53,65.01 254.04,64.5 254.04,62.98 252,60.95 252,58.41 252.51,57.9 D10.F2 | v243.88,79.24 242.35,80.76 v242.35,85.33
MF00  (via drill 0.61)
  Top 0.254: v247.43,66.54 246.92,67.04 v244.89,67.04 | v235.75,63.49 234.22,61.96 v231.18,61.96 | v171.23,70.09 v167.17,70.09 | v157.01,78.22 155.99,79.24 v144.82,79.24 | v142.78,81.27 142.28,81.78 134.15,81.78 132.62,83.3 v131.61,83.3 | v120.94,120.38 120.94,121.91 58.46,121.91 v40.68,139.69 | v40.68,176.26 35.09,181.85 35.09,192.52 36.61,192.52 37.12,193.03 37.12,195.57 35.6,195.57 v33.56,197.6
  Route2 0.254: v231.18,61.96 229.65,61.96 228.64,60.95 228.64,59.93 227.62,58.92 224.06,58.92 223.56,58.41 214.92,58.41 212.38,55.87 204.25,55.87 v203.24,56.88 | v163.1,72.63 157.52,78.22 v157.01,78.22 | v33.56,197.6 33.56,198.11 41.18,205.73 41.18,207.25 55.41,221.48 A25.V1
  Route15 0.254: v244.89,67.04 243.88,68.06 240.32,68.06 v235.75,63.49 | v199.68,60.44 197.65,60.44 196.12,61.96 191.55,61.96 191.04,62.47 189.01,62.47 186.47,65.01 182.92,65.01 v178.85,60.95 | v131.61,83.3 v127.04,87.87
  Bottom 0.254: v247.43,66.54 247.94,66.03 247.94,61.96 248.96,60.95 D11.E1 | v199.68,60.44 v203.24,56.88 | v178.85,60.95 180.88,62.98 180.88,70.6 180.38,71.11 171.23,71.11 v171.23,70.09 | v167.17,70.09 164.63,72.63 v163.1,72.63 | v144.82,79.24 v142.78,81.27 | v127.04,87.87 126.02,86.86 120.94,86.86 v120.94,120.38 | v40.68,139.69 41.18,140.2 41.18,175.76 v40.68,176.26
MF00\  (via drill 0.61)
  Top 0.254: v331.25,58.92 279.44,58.92 276.39,55.87 246.92,55.87 246.42,56.38 D11.F1 | v331.25,139.18 330.74,139.69 v327.19,139.69 | v330.74,197.09 334.3,197.09 B04.D2
  Bottom 0.254: v331.25,58.92 331.25,73.14 332.27,74.16 332.27,136.64 331.25,137.66 v331.25,139.18 | v327.19,139.69 328.2,139.69 330.24,141.72 330.24,170.68 328.71,172.2 328.71,173.72 B05.M1 329.22,174.74 329.73,175.25 329.73,177.79 330.74,178.8 v330.74,197.09
MF01  (via drill 0.61)
  Top 0.254: v183.42,56.38 183.93,55.87 218.48,55.87 221.02,58.41 234.73,58.41 238.29,54.85 241.84,54.85 242.35,54.34 D11.H2 | v173.26,41.64 169.2,37.58 v167.68,37.58 | v147.36,62.98 145.32,65.01 140.75,65.01 137.2,68.57 117.89,68.57 115.86,70.6 111.29,70.6 107.22,74.66 v46.26,74.66 | v45.76,151.88 43.72,153.91 24.93,153.91 21.88,156.96 21.88,207.25 v23.4,207.25 | v10.7,226.56 9.18,225.03 3.59,225.03 3.08,225.54 3.08,234.18 3.59,234.18 4.1,234.68 4.1,249.42 15.28,249.42 27.47,261.61 32.04,261.61 v32.55,261.1
  Route2 0.254: v147.36,62.98 v155.99,54.34
  Route15 0.254: v23.4,212.33 13.75,221.98 v13.24,221.98
  Bottom 0.254: v183.42,56.38 180.88,56.38 180.88,49.26 v173.26,41.64 | v167.68,37.58 158.53,46.72 158.53,51.8 v155.99,54.34 | v46.26,74.66 44.74,76.19 44.74,143.75 45.76,144.77 v45.76,151.88 | v23.4,212.33 v23.4,207.25 | v13.24,221.98 12.74,222.49 12.74,223 10.7,225.03 v10.7,226.56 | v32.55,261.1 32.04,261.61 32.04,285.99 36.61,290.56 46.26,290.56 46.26,276.85 A26.A1
MF01\  (via drill 0.61)
  Top 0.254: v298.23,57.9 297.72,58.41 279.94,58.41 276.9,55.36 247.94,55.36 243.88,51.3 240.32,51.3 D11.J2 | v298.74,110.22 299.25,109.72 310.93,109.72 v312.46,111.24 | v313.47,150.36 313.98,149.85 323.12,149.85 v324.14,150.86 | v331.76,198.11 v336.33,198.11
  Bottom 0.254: v298.23,57.9 298.74,58.41 v298.74,110.22 | v312.46,111.24 313.98,112.76 313.98,149.85 v313.47,150.36 | v324.14,150.86 324.14,169.66 325.16,170.68 B05.N1 325.66,171.69 325.66,173.22 329.22,176.77 329.22,178.3 330.24,179.31 330.24,194.04 329.73,194.55 329.73,198.11 v331.76,198.11 | v336.33,198.11 336.33,195.57 337.86,194.04 B04.E2
MF02  (via drill 0.61)
  Top 0.254: v243.88,44.69 245.4,44.69 D11.L1 | v227.62,48.25 225.59,46.22 218.98,46.22 v218.48,46.72 | v184.44,42.15 183.93,42.66 172.76,42.66 168.69,38.6 v165.14,38.6 | v157.52,46.72 157.01,46.22 133.64,46.22 132.12,47.74 v131.61,47.74 | v129.07,50.28 127.04,52.31 124.5,52.31 123.99,51.8 120.43,51.8 119.92,52.31 117.89,52.31 v117.38,51.8 | v118.4,53.84 117.89,54.34 114.34,54.34 113.32,55.36 110.27,55.36 v108.24,53.33 | v110.27,48.25 109.76,48.76 107.73,48.76 107.22,49.26 35.6,49.26 v2.58,82.28 | v2.07,206.24 2.07,259.07 6.64,259.07 9.69,262.12 9.69,270.75 12.74,270.75 16.29,274.31 40.17,274.31 41.18,273.29 42.2,273.29 A26.B1
  Route2 0.254: v243.88,44.69 239.81,48.76 237.27,46.22 229.65,46.22 v227.62,48.25 | v131.61,47.74 v129.07,50.28
  Route15 0.254: v218.48,46.72 217.46,45.71 212.38,45.71 208.82,49.26 193.08,49.26 185.96,42.15 v184.44,42.15
  Bottom 0.254: v165.14,38.6 158.53,45.2 158.53,45.71 v157.52,46.72 | v117.38,51.8 118.4,52.82 v118.4,53.84 | v108.24,53.33 108.24,49.77 109.76,48.25 v110.27,48.25 | v2.58,82.28 2.07,82.79 2.07,203.19 3.08,204.2 3.08,205.22 v2.07,206.24
MF02\  (via drill 0.61)
  Top 0.254: v249.46,37.07 253.02,33.52 v279.44,33.52 | v284.01,115.81 285.02,115.81 286.04,116.83 v286.04,118.35 | v286.04,182.87 286.55,182.36 317.54,182.36 | 317.54,182.36 336.84,182.36 337.86,181.34 B04.K2 | v317.54,183.38 317.54,182.36
  Bottom 0.254: v249.46,37.07 249.46,40.63 D11.M1 | v279.44,33.52 279.44,45.71 278.93,46.22 278.93,89.9 282.99,93.97 282.99,114.8 v284.01,115.81 | v286.04,182.87 v286.04,118.35 | v317.54,183.38 317.54,191 319.06,192.52 319.06,196.08 B05.D2
MK_BLK_END  (via drill 0.61)
  Top 0.254: v159.55,37.58 163.61,41.64 v165.14,41.64 | v165.14,59.93 160.06,65.01 156.5,65.01 155.48,64 153.45,64 151.42,61.96 149.9,61.96 v144.82,67.04 | v152.44,87.87 153.96,89.4 v154.47,89.4 | v168.69,110.73 170.22,112.26 175.3,112.26 175.8,112.76 176.82,112.76 177.84,111.75 v178.85,111.75
  Route2 0.254: v178.85,111.75 182.41,115.3 184.44,115.3 187.49,118.35 187.49,119.37 202.22,134.1 202.22,134.61 206.28,138.67 206.28,143.24 218.48,155.44 218.48,156.96 222.03,160.52 222.03,163.06 222.54,163.56 222.54,165.09 225.08,167.63 227.62,167.63 229.14,169.15 233.72,169.15 242.35,177.79 242.35,178.8 239.81,181.34 244.38,185.92 244.38,187.44 244.89,187.95 246.42,187.95 250.48,192.01 250.48,197.6 257.59,204.71 257.59,205.73 v262.67,210.81 | v256.07,215.89 258.61,218.43 258.61,219.44 263.18,224.02 263.18,226.56 264.7,228.08 A09.T2
  Route15 0.254: v150.4,72.63 v144.82,67.04 | v154.47,89.4 166.15,101.08 v167.17,101.08 | v262.67,210.81 262.16,210.81 260.13,212.84 259.12,212.84 v256.07,215.89
  Bottom 0.254: v159.55,37.58 155.99,34.02 155.99,24.37 154.47,22.85 CD18.BU1 | v165.14,41.64 168.18,44.69 168.18,55.87 165.14,58.92 v165.14,59.93 | v150.4,72.63 150.4,85.84 v152.44,87.87 | v167.17,101.08 168.69,102.6 168.69,106.16 167.68,107.18 167.68,109.72 v168.69,110.73
MK_BLK_END\  (via drill 0.61)
  Top 0.254: v170.72,18.28 170.22,17.77 152.44,17.77 151.42,18.78 CD18.BV1 | v120.43,22.34 118.91,23.86 115.35,23.86 114.34,24.88 111.29,24.88 110.27,23.86 v101.13,23.86 | v81.32,88.89 v93.51,76.7 | v78.78,166.1 79.28,166.61 94.52,166.61 v95.54,167.63 | v103.67,181.34 104.68,180.33 104.68,179.82 105.19,179.31 116.88,179.31 v118.4,180.84 | v119.42,209.28 119.92,208.78 v122.46,208.78 | v132.62,211.82 133.13,212.33 150.91,212.33 151.93,213.35 151.93,215.38 v150.91,215.38 | v181.39,247.38 183.42,247.38 184.44,248.4 184.44,248.91 189.01,248.91 v189.52,248.4 | v221.52,273.8 223.56,273.8 226.6,270.75 v227.62,270.75
  Route2 0.254: v150.91,215.38 148.88,217.41 163.61,232.14 165.14,232.14 166.15,233.16 167.17,233.16 v181.39,247.38 | v227.62,270.75 229.14,270.75 229.65,271.26 234.73,271.26 241.84,278.37 263.69,278.37 273.34,268.72 274.36,269.74 A09.C1
  Route15 0.254: v122.46,208.78 123.99,210.3 128.05,210.3 131.1,213.35 v132.62,211.82 | v193.58,251.45 195.62,253.48 196.63,253.48 197.65,252.46 199.17,252.46 218.98,272.28 220.51,272.28 221.52,273.29 v221.52,273.8
  Bottom 0.254: v170.72,18.28 160.06,7.61 120.43,7.61 v120.43,22.34 | v101.13,23.86 95.03,29.96 95.03,43.68 94.02,44.69 94.02,45.71 95.03,46.72 95.03,75.17 v93.51,76.7 | v81.32,88.89 79.28,90.92 79.28,165.6 v78.78,166.1 | v95.54,167.63 101.64,173.72 101.64,178.3 103.67,180.33 v103.67,181.34 | v118.4,180.84 120.43,182.87 120.43,208.27 v119.42,209.28 | v189.52,248.4 192.57,251.45 v193.58,251.45
MK_BLK_MK  (via drill 0.61)
  Top 0.254: v149.39,86.35 160.06,86.35 160.56,86.86 252.51,86.86 253.02,86.35 v258.61,86.35 | D10.A1 261.66,72.63 259.62,70.6 259.12,70.6 D10.B1
  Bottom 0.254: v149.39,86.35 149.39,124.45 148.37,125.46 148.37,129.02 147.86,129.53 CD18.AE2 | v258.61,86.35 258.61,70.6 D10.B1
MK_BLK_START\  (via drill 0.61)
  Top 0.254: v151.42,123.43 150.4,122.42 140.24,122.42 137.7,124.96 136.18,124.96 135.67,125.46 v129.07,125.46 | v128.05,127.5 126.02,125.46 125,125.46 122.97,127.5 122.97,129.02 123.48,129.02 123.48,133.59 v121.96,133.59 | v119.92,135.62 118.91,134.61 87.92,134.61 85.38,132.07 52.87,132.07 40.17,144.77 v13.24,144.77 | v12.74,202.17 17.82,207.25 19.34,207.25 20.36,208.27 28.99,208.27 32.55,204.71 41.18,204.71 42.71,206.24 43.72,206.24 45.25,204.71 64.55,204.71 67.09,207.25 v75.73,207.25 | v76.24,247.38 75.73,247.89 v73.19,247.89 | v204.25,276.85 205.27,275.83 v206.28,275.83 | v270.29,276.34 274.36,276.34 A09.A1
  Route2 0.254: v208.82,273.29 213.4,277.86 240.32,277.86 241.34,278.88 267.75,278.88 v270.29,276.34
  Route15 0.254: v75.73,207.25 75.73,208.78 v79.28,212.33 | v77.25,226.05 v75.22,228.08
  Bottom 0.254: v151.42,123.43 151.42,126.48 CD18.AF1 | v129.07,125.46 128.05,126.48 v128.05,127.5 | v119.92,135.62 v121.96,133.59 | v13.24,144.77 13.24,154.42 12.74,154.93 v12.74,202.17 | v79.28,212.33 78.27,213.35 78.27,217.41 78.78,217.92 79.79,217.92 79.79,222.49 77.25,225.03 v77.25,226.05 | v75.22,228.08 73.19,230.11 73.19,240.78 76.24,243.83 v76.24,247.38 | v73.19,247.89 73.19,292.09 78.27,297.17 204.25,297.17 204.25,293.1 204.76,292.6 204.76,277.36 v204.25,276.85 | v206.28,275.83 v208.82,273.29
MK_DATA\  (via drill 0.61)
  Top 0.254: v145.32,98.54 143.8,97.02 103.67,97.02 100.62,100.06 v81.32,100.06 | v81.82,175.76 81.82,178.8 94.02,178.8 v95.03,177.79 | v97.57,180.33 96.56,181.34 v95.54,181.34 | v97.06,193.03 98.59,194.55 103.16,194.55 103.67,194.04 104.68,194.04 105.19,194.55 v119.42,194.55 | v131.61,215.38 132.62,214.36 150.4,214.36 v150.91,213.86 | v160.06,221.48 162.09,223.51 174.28,223.51 v174.79,223 | v194.6,248.4 195.11,248.91 206.28,248.91 v206.79,248.4 | v267.75,272.78 270.8,272.78 A09.B1
  Route2 0.254: v147.36,96 146.34,97.02 146.34,97.52 v145.32,98.54 | v123.99,208.27 124.5,208.27 v131.61,215.38 | v150.91,213.86 156.5,219.44 157.52,219.44 159.55,221.48 v160.06,221.48 | v175.8,229.1 194.6,247.89 v194.6,248.4 | v206.79,248.4 209.33,248.4 209.84,248.91 211.87,248.91 212.89,249.92 212.89,251.45 216.95,255.51 224.06,255.51 227.62,259.07 229.65,259.07 232.19,261.61 233.72,261.61 235.24,263.13 235.24,264.66 238.8,268.21 258.1,268.21 261.15,271.26 266.23,271.26 v267.75,272.78
  Route15 0.254: v119.42,194.55 v121.96,197.09
  Bottom 0.254: v147.36,96 147.36,92.44 CD18.AU2 | v81.32,100.06 79.79,101.59 79.79,157.98 82.33,160.52 82.33,175.25 v81.82,175.76 | v95.03,177.79 v97.57,180.33 | v95.54,181.34 95.54,191.5 v97.06,193.03 | v121.96,197.09 123.99,199.12 123.99,201.16 123.48,201.66 123.48,205.22 123.99,205.73 v123.99,208.27 | v174.79,223 174.79,228.08 v175.8,229.1
MK_END  (via drill 0.61)
  Top 0.254: v138.72,130.04 141.26,127.5 143.29,127.5 143.8,126.99 CD18.AF2 | v150.91,179.82 v148.37,177.28 | v185.46,225.03 186.47,226.05 187.49,226.05 188.5,227.06 v193.08,227.06 | v217.46,263.13 218.48,262.12 231.18,262.12 231.68,262.62 231.68,266.69 v230.16,266.69 | v270.8,269.74 272.32,271.26 275.37,271.26 275.88,270.75 275.88,269.74 v280.45,269.74 | v287.06,269.74 290.1,269.74 A08.C1
  Route2 0.254: v153.45,184.39 153.45,185.92 151.42,187.95 158.53,195.06 158.53,196.08 165.14,202.68 165.14,207.25 175.8,217.92 177.33,217.92 177.84,218.43 178.85,218.43 v185.46,225.03 | v210.86,244.84 v193.08,227.06 | v230.16,266.69 231.18,266.69 242.35,277.86 243.37,277.86 244.89,276.34 244.89,275.83 v245.91,274.82
  Route15 0.254: v147.36,138.67 v138.72,130.04 | v252.51,283.96 254.04,285.48 257.59,281.93 258.1,281.93 258.61,281.42 258.61,280.91 259.12,280.4 261.66,280.4 268.77,273.29 268.77,271.77 v270.8,269.74 | v280.45,269.74 280.96,269.74 v283.5,267.2
  Bottom 0.254: v147.36,138.67 147.36,140.2 149.39,142.23 149.39,156.45 147.36,158.48 147.36,159.5 148.88,161.02 148.88,176.77 v148.37,177.28 | v150.91,179.82 151.42,180.33 151.42,181.34 153.45,183.38 v153.45,184.39 | v210.86,244.84 212.38,246.37 212.38,248.91 211.87,249.42 210.86,249.42 210.86,251.45 212.38,252.97 212.38,261.61 210.86,263.13 210.86,264.15 212.89,266.18 215.43,266.18 215.43,265.16 v217.46,263.13 | v245.91,274.82 247.94,276.85 247.94,280.91 250.99,283.96 v252.51,283.96 | v283.5,267.2 286.04,267.2 286.04,268.72 v287.06,269.74
MK_END\  (via drill 0.61)