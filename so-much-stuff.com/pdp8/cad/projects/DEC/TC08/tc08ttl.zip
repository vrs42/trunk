# EAGLE schematic tc08ttl (EAGLE 4.11), part 2 of 2
## Power pins joined to a net without a drawn wire
-15V: A18.B2(-15V) A20.B2(-15V) A21.B2(-15V) A22.B2(-15V) A23.B2(-15V) B18.B2(-15V) B20.B2(-15V) B21.B2(-15V) B22.B2(-15V) B23.B2
GND: A02.A1 A02.C1 A02.C2 A02.F1 A02.F2 A02.J2 A02.K1 A02.L2 A02.N1 A02.N2 A02.R1 A02.R2 A02.T1 A02.U2 A03.A1 A03.C1 A03.C2 A03.F1 A03.F2 A03.J2 A03.K1 A03.L2 A03.N1 A03.N2 A03.R1 A03.R2 A03.T1 A03.U2 A04.A1 A04.C1 A04.C2 A04.F1 A04.F2 A04.J2 A04.K1 A04.L2 A04.N1 A04.N2 A04.R1 A04.R2 A04.T1 A04.U2 A05.A1 A05.C1 A05.C2 A05.F1 A05.F2 A05.J2 A05.K1 A05.L2 A05.N1 A05.N2 A05.R1 A05.R2 A05.T1 A05.U2 A06.A1 A06.C1 A06.C2 A06.F1 A06.F2 A06.J2 A06.K1 A06.L2 A06.N1 A06.N2 A06.R1 A06.R2 A06.T1 A06.U2 A07.C2(GND) A07.T1(GND) A08.C2(GND) A08.T1(GND) A09.C2(GND) A09.T1(GND) A10.B2(GND) A10.T1(GND) A11.C2(GND) A11.T1(GND) A12.B2(GND) A12.T1(GND) A14.C2(GND) A14.T1(GND) A15.C2(GND) A15.T1(GND) A16.C2(GND) A16.T1(GND) A18.C2(GND) A20.C2(GND) A21.C2(GND) A22.C2(GND) A22.M2(GND) A23.C2(GND) A23.T1(GND) A23.U1(GND) A23.V1(GND) AB19.AC2 AB19.AK2 AB19.AS2 AB19.AT2 AB19.BE2 AB19.BL2 B02.C2(GND) B02.T1(GND) B02.U1(GND) B02.V1(GND) B03.C2(GND) B03.T1(GND) B03.U1(GND) B03.V1(GND) B04.C2(GND) B04.T1(GND) B04.U1(GND) B04.V1(GND) B05.C2(GND) B05.T1(GND) B05.U1(GND) B05.V1(GND) B06.C2(GND) B06.T1(GND) B07.C2(GND) B07.T1(GND) B08.B2(GND) B08.T1(GND) B09.C2(GND) B09.T1(GND) B10.C2(GND) B10.T1(GND) B11.C2(GND) B11.T1(GND) B12.C2(GND) B12.T1(GND) B13.C2(GND) B13.T1(GND) B14.C2(GND) B14.T1(GND) B15.B2(GND) B15.T1(GND) B16.C2(GND) B16.T1(GND) B18.C2(GND) B20.C2(GND) B21.C2(GND) B22.C2(GND) B22.T1(GND) B22.U1(GND) B22.V1(GND) B23.C2 C02.C2(GND) C02.T1(GND) C03.C2(GND) C03.T1(GND) C05.C2(GND) C05.T1(GND) C06.C2(GND) C06.T1(GND) C07.C2(GND) C07.T1(GND) C08.C2(GND) C08.T1(GND) C09.C2(GND) C09.T1(GND) C10.C2(GND) C10.T1(GND) C11.B2(GND) C11.T1(GND) C12.C2(GND) C12.T1(GND) C13.C2(GND) C13.T1(GND) C14.C2(GND) C14.T1(GND) C15.B2(GND) C15.T1(GND) C16.C2(GND) C16.T1(GND) C17.C2(GND) C17.T1(GND) CD18.AC2(GND) CD18.AT1(GND) CD18.BC2(GND) CD18.BT1(GND) D02.A1 D02.C1 D02.C2 D02.F1 D02.F2 D02.J2 D02.K1 D02.L2 D02.N1 D02.N2 D02.R1 D02.R2 D02.T1 D02.U2 D03.A1 D03.C1 D03.C2 D03.F1 D03.F2 D03.J2 D03.K1 D03.L2 D03.N1 D03.N2 D03.R1 D03.R2 D03.T1 D03.U2 D04.A1 D04.C1 D04.C2 D04.F1 D04.F2 D04.J2 D04.K1 D04.L2 D04.N1 D04.N2 D04.R1 D04.R2 D04.T1 D04.U2 D05.A1 D05.C1 D05.C2 D05.F1 D05.F2 D05.J2 D05.K1 D05.L2 D05.N1 D05.N2 D05.R1 D05.R2 D05.T1 D05.U2 D06.A1 D06.C1 D06.C2 D06.F1 D06.F2 D06.J2 D06.K1 D06.L2 D06.N1 D06.N2 D06.R1 D06.R2 D06.T1 D06.U2 D07.C2(GND) D07.T1(GND) D08.C2(GND) D08.T1(GND) D09.C2(GND) D09.T1(GND) D10.C2(GND) D10.T1(GND) D11.C2(GND) D11.T1(GND) D12.C2(GND) D12.T1(GND) D13.C2(GND) D13.T1(GND) D14.C2(GND) D14.T1(GND) D15.C2(GND) D15.T1(GND) D16.C2(GND) D16.T1(GND) D17.C2(GND) D17.T1(GND) IC1.7(GND) IC2.7(P:GND) IC3.7(P:GND) IC4.7(P:GND) IC5.7(P:GND) IC6.7(GND) IC7.7(P:GND) IC8.7(P:GND) IC9.7(P:GND)
VCC: A07.A2(VCC) A08.A2(VCC) A09.A2(VCC) A10.A2(VCC) A11.A2(VCC) A12.A2(VCC) A14.A2(VCC) A15.A2(VCC) A16.A2(VCC) A18.A2(VCC) A20.A2(VCC) A21.A2(VCC) A22.A2(VCC) A23.A2(VCC) B02.A2(VCC) B03.A2(VCC) B04.A2(VCC) B05.A2(VCC) B06.A2(VCC) B07.A2(VCC) B08.A2(VCC) B09.A2(VCC) B10.A2(VCC) B11.A2(VCC) B12.A2(VCC) B13.A2(VCC) B14.A2(VCC) B15.A2(VCC) B16.A2(VCC) B18.A2(VCC) B20.A2(VCC) B21.A2(VCC) B22.A2(VCC) C02.A2(VCC) C03.A2(VCC) C05.A2(VCC) C06.A2(VCC) C07.A2(VCC) C08.A2(VCC) C09.A2(VCC) C10.A2(VCC) C11.A2(VCC) C12.A2(VCC) C13.A2(VCC) C14.A2(VCC) C15.A2(VCC) C16.A2(VCC) C17.A2(VCC) CD18.AA2(VCC) CD18.BA2(VCC) D07.A2(VCC) D08.A2(VCC) D09.A2(VCC) D10.A2(VCC) D11.A2(VCC) D12.A2(VCC) D13.A2(VCC) D14.A2(VCC) D15.A2(VCC) D16.A2(VCC) D17.A2(VCC) IC1.14(VCC) IC2.14(P:VCC) IC3.14(P:VCC) IC4.14(P:VCC) IC5.14(P:VCC) IC6.14(VCC) IC7.14(P:VCC) IC8.14(P:VCC) IC9.14(P:VCC)

## Library data of the parts
A02-A06 D02-D06 = dec-m:M903: Two-sided Posibus cable/connector.
A07 D07 = dec-m:M161: Octal or Decimal Decoder
A08 B09 B13 B14 C09 C14 D11 = dec-m:M206X: Two sets of 3 D flip-flops
A09 B12 = dec-m:M117: 6 4-input NAND Gates
A10 A12 B08 B15 C11 C15 = dec-m:M113: 10 2-input NAND Gates
A11 B06 C06 C13 C17 = dec-m:M111: Sixteen inverters.
A13 A17 A27 A28 B17 B24-B28 C19-C28 D01 D19-D28 = dec-m:H807: Empty card slot
A14 D16 = dec-m:M302: Dual one-shot
A15 B10 C16 D12 = dec-m:M627: 6 4-input NAND Power Amplifier
A16 B16 D13 D17 = dec-m:M602: Dual Pulse Amplifier
A18 A20 A21 B18 B20 = dec-m:G888: Manchester Reader/Writer
A22 = dec-m:M502: Dual Negative Input Converter
A23 B22 = dec-m:M633: 6 Dual Negative Bus Drivers
A24 = dec-m:W023: One-sided 18 pin connector/cable.
A25 A26 = dec-m:M916: Simple 36 pin connector/wire cable
AB01 = dec-m:G821: +5V Regulator
AB19 = dec-m:W032: Cable Connector (15 signals)
B02-B05 = dec-m:M623: 6 Dual Bus Drivers
B07 C07 D08 = dec-m:M207: 6 J-K flip-flops
B11 C12 = dec-m:M115: 8 3-input NAND Gates
B21 = dec-m:G879: Transport Detector
B23 = dec-m:W005: 15 Clamped Loads
C02 C03 = dec-m:M101-ARRAY: M101 Bus Data Interface
C05 = dec-m:M103: M103 Device Selector Used to decode IOT requests.
C08 C10 D09 = dec-m:M121: 6 2-2 AND-NOR Gates
CD18 = dec-m:M228: Mark Track Decoder
D10 = dec-m:M119: 3 8-input NAND Gates
D14 = dec-m:M307: Dual Integrating One-Shot
D15 = dec-m:M401: Variable Clock
IC1 IC6 = 74xx-jameco:74*30: 8-input NAND gate
IC2 IC7 IC8 = 74xx-jameco:74*00: Quad 2-input NAND gate
IC3 IC9 = 74xx-jameco:74*04: Hex INVERTER
IC4 IC5 = 74xx-jameco:74*74: Dual D type positive edge triggered FLIP FLOP, preset and clear

## Net classes
1 Power: width 0.635 mm, drill 0.381 mm, clearance 0.381 mm