# EAGLE board tc083-18 (EAGLE 4.11), part 6 of 6
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
W01 (continued)
  Top 0.254: CD18.BJ2 276.47,42.13 275.46,43.14 275.46,58.38 286.13,69.05 286.13,149.31 283.59,151.85 283.59,172.17 286.13,174.71 289.68,174.71 289.68,121.88 305.94,105.63 305.94,103.59 318.13,91.4 378.58,91.4 378.58,267.68 379.6,268.69 387.73,268.69 387.73,227.04 397.38,217.39 397.38,216.37 397.89,215.86 400.43,215.86 400.43,223.99 400.93,224.5 400.93,248.88 401.95,249.9 401.95,250.91 A26.J2
W02
  Route15 0.254: CD18.BV2 277.49,10.12 289.68,22.31 289.68,50.76 337.43,98.51 337.43,120.87 385.19,168.62 385.19,189.95 416.17,220.94 416.17,229.07 410.59,234.66 410.59,241.26 407.54,244.31 407.54,246.34 406.01,247.87 A26.K2
W03  (via drill 0.61)
  Top 0.254: v278.51,53.3 278.51,51.78 CD18.BE2 | v319.15,93.94 319.15,95.47 318.64,95.97 318.64,148.81 320.67,150.84 320.67,151.85 320.16,152.36 320.16,161.51 v320.67,162.01
  Route2 0.254: v278.51,53.3 284.09,58.89 285.11,58.89 285.62,59.4 285.62,61.43 318.13,93.94 v319.15,93.94 | v320.67,162.01 337.43,178.78 338.45,178.78 352.17,192.49 352.17,193.51 353.69,195.03 354.2,195.03 354.71,195.54 354.71,196.05 365.88,207.23 366.9,207.23 384.17,224.5 384.17,226.53 402.46,244.82 A26.L2
W04
  Route2 0.254: CD18.AT2 275.46,86.83 270.38,91.91 276.47,98.01 276.47,108.67 284.09,116.29 285.11,116.29 316.1,147.28 316.1,148.3 319.65,151.85 319.65,154.39 338.96,173.7 339.47,173.7 353.18,187.41 353.18,187.92 357.75,192.49 358.26,192.49 359.79,194.02 359.79,194.53 367.41,202.15 367.91,202.15 368.42,202.65 368.42,203.67 395.35,230.59 396.36,230.59 403.47,237.71 403.47,239.23 405.51,241.26 A26.M2
W05
  Route15 0.254: CD18.BU2 278.51,13.68 278.51,17.23 289.17,27.9 289.17,66 316.61,93.43 315.08,94.96 315.08,127.98 354.2,167.09 355.21,167.09 369.44,181.32 369.44,182.84 385.69,199.1 393.31,199.1 413.13,218.91 410.59,221.45 410.59,232.63 406.52,236.69 403.98,236.69 402.46,238.21 A26.N2
W06
  Route15 0.254: CD18.AM2 278.51,102.58 278.51,104.1 291.21,116.8 301.87,116.8 353.18,168.11 353.18,169.63 369.95,186.4 369.44,186.91 369.44,189.45 409.57,229.58 407.54,231.61 407.54,233.64 406.01,235.17 A26.P2
W07
  Route2 0.254: CD18.AK2 279.01,108.67 280.54,108.67 286.13,114.26 286.13,116.29 333.88,164.05 333.88,165.57 347.59,179.29 348.61,179.29 365.37,196.05 365.37,197.57 372.99,205.19 375.03,205.19 401.95,232.12 A26.R2
W08
  Route2 0.254: CD18.AL1 282.06,105.63 287.14,105.63 301.87,120.36 301.87,123.41 327.78,149.31 327.78,149.82 338.96,161 339.47,161 353.18,174.71 353.18,175.22 370.96,193 371.47,193 381.12,202.65 381.12,204.69 400.93,224.5 400.93,226.53 401.44,227.04 402.97,227.04 405,229.07 A26.S2
W09
  Top 0.254: CD18.BF2 277.49,47.71 280.54,47.71 280.54,26.38 287.65,19.27 287.65,9.61 295.27,1.99 400.93,1.99 400.93,223.48 401.95,224.5 401.95,225.51 A26.T2
W+UTS  (via drill 0.61)
  Top 0.254: v183.51,106.13 183.51,102.58 C12.M2 | v223.13,147.28 223.13,190.97 223.64,191.48 223.64,200.11 224.15,200.62 224.15,228.05 223.13,229.07 v223.13,254.47 | v237.36,270.22 237.36,273.27 A15.A1 | v229.74,262.6 229.74,258.53 230.75,257.52 230.75,254.98 A15.H2
  Route2 0.254: v183.51,106.13 193.67,116.29 193.67,117.82 v223.13,147.28 | v237.36,270.22 v229.74,262.6
  Bottom 0.254: v223.13,254.47 230.25,254.47 A15.H2
W-INH\  (via drill 0.61)
  Route2 0.254: v177.92,174.71 177.92,175.22 186.05,183.35 187.07,183.35 188.08,184.37 189.1,184.37 B12.H1
  Route15 0.254: v118.49,219.42 130.17,207.73 130.17,206.72 145.92,190.97 147.95,190.97 152.01,186.91 152.52,186.91 v163.19,176.24
  Bottom 0.254: v118.49,219.42 116.45,219.42 A08.V2 | v163.19,176.24 165.22,176.24 166.24,175.22 167.25,175.22 167.76,174.71 170.3,174.71 B11.L1 170.81,174.71 v177.92,174.71
WB00  (via drill 0.61)
  Top 0.254: v191.64,74.13 v191.64,84.29 | v219.58,110.71 219.58,112.23 217.55,114.26 217.55,117.31 C14.F1 | v318.13,233.64 318.64,233.13 318.64,208.24 v318.13,207.73 | v271.39,207.73 271.39,202.65 272.41,201.64 272.41,169.13 v271.9,168.62
  Route2 0.254: v325.75,238.72 v330.83,243.8 | v152.52,73.11 143.38,63.97 142.36,63.97 D09.A1 | v191.64,84.29 210.43,103.09 211.96,103.09 v219.58,110.71 | v223.64,118.83 224.66,118.83 232.79,126.96 232.79,127.47 233.29,127.98 234.82,127.98 275.46,168.62 B18.N2 | v318.13,233.64 322.7,238.21 A21.N2
  Route15 0.254: v374.52,244.31 v383.15,235.67
  Bottom 0.254: v325.75,238.72 323.21,238.72 A21.N2 | v330.83,243.8 374.01,243.8 v374.52,244.31 | v383.15,235.67 389.25,235.67 A25.P2 | v152.52,73.11 153.03,73.62 159.13,73.62 160.14,74.64 188.08,74.64 188.59,74.13 v191.64,74.13 | v223.64,118.83 219.07,118.83 218.56,118.33 C14.F1 | v318.13,207.73 317.62,208.24 271.9,208.24 v271.39,207.73 | v271.9,168.62 274.95,168.62 B18.N2
WB00\  (via drill 0.61)
  Top 0.254: v154.55,126.45 154.55,124.93 C10.D1 | v321.69,235.67 320.16,234.15 320.16,212.81 v320.67,212.31 | v270.38,206.72 270.89,206.21 270.89,202.15 271.9,201.13 271.9,170.14 270.89,169.13 270.89,165.57 v270.38,165.06
  Route2 0.254: v164.71,136.61 v154.55,126.45 | v270.38,165.06 270.38,164.55 234.31,128.49 231.77,128.49 230.75,129.5 225.17,123.91 225.17,122.9 224.66,122.39 222.63,122.39 221.61,121.37 C14.E1 | v315.59,207.23 v320.67,212.31
  Route15 0.254: v201.29,135.6 210.94,125.95 211.96,125.95 v215.01,122.9
  Bottom 0.254: v164.71,136.61 165.22,136.11 173.86,136.11 174.87,137.12 185.03,137.12 186.56,135.6 v201.29,135.6 | v215.01,122.9 218.56,122.9 220.09,121.37 221.1,121.37 C14.E1 | v270.38,165.06 278.51,165.06 B18.P2 | v321.69,235.67 325.75,235.67 A21.P2 | v315.59,207.23 315.08,207.73 272.92,207.73 271.9,206.72 v270.38,206.72
WB01  (via drill 0.61)
  Top 0.254: v306.95,171.16 306.95,168.62 B20.N2 | v320.67,184.87 v320.67,207.73 | v213.48,122.9 213.48,118.83 212.97,118.33 212.97,113.25 211.96,112.23 C14.J2
  Route2 0.254: v145.41,48.22 158.62,61.43 158.62,61.94 v164.71,68.03 | v171.83,68.03 172.33,68.03 181.48,77.18 181.48,77.69 189.61,85.81 191.13,85.81 197.73,92.42 197.73,98.01 200.27,100.55 200.78,100.55 207.39,107.15 207.39,109.18 207.89,109.69 209.93,109.69 211.45,111.21 C14.J2 | v306.95,171.16 v320.67,184.87 | v362.33,207.73 386.2,231.61 A25.R2 | v213.48,122.9 213.48,123.41 v227.71,137.63 | v275.97,137.12 303.4,164.55 303.4,165.06 306.45,168.11 B20.N2
  Bottom 0.254: v145.41,48.22 139.31,48.22 D09.F1 | v171.83,68.03 v164.71,68.03 | v320.67,207.73 321.18,208.24 361.82,208.24 v362.33,207.73 | v227.71,137.63 237.36,137.63 237.87,137.12 240.41,137.12 240.91,136.61 275.46,136.61 v275.97,137.12
WB01\  (via drill 0.61)
  Top 0.254: v310,163.03 310,165.06 B20.P2
  Route2 0.254: v171.32,119.85 170.3,119.85 167.25,116.8 166.24,116.8 158.11,108.67 C10.K1 | v310,163.03 307.97,161 307.46,161 306.95,160.49 306.45,160.49 283.08,137.12 v283.08,136.61 | v236.85,136.61 224.66,124.42 222.12,124.42 216.02,118.33 216.02,115.79 215.01,114.77 C14.H2
  Route15 0.254: v203.32,119.85 v208.4,114.77
  Bottom 0.254: v171.32,119.85 v203.32,119.85 | v208.4,114.77 214.5,114.77 C14.H2 | v283.08,136.61 280.03,136.61 279.52,136.11 240.41,136.11 239.9,136.61 v236.85,136.61
WB02
  Top 0.254: A20.N2 307.46,239.23 312.03,239.23 312.03,239.74 336.93,239.74 336.93,273.77 350.13,286.98 350.13,289.01 352.67,291.55 388.23,291.55 388.23,230.59 389.25,229.58 A25.S2
  Route2 0.254: D09.M1 142.36,32.47 149.47,32.47 159.63,42.63 160.65,42.63 174.87,56.86 174.87,58.89 191.13,75.15 192.15,75.15 193.67,76.67 195.7,76.67 203.83,84.8 206.37,84.8 219.58,98.01 219.58,100.04 221.1,101.56 C14.M1 221.61,102.58 224.15,105.12 224.15,106.13 235.83,117.82 235.83,121.88 241.42,127.47 242.95,127.47 264.28,148.81 264.28,150.33 274.44,160.49 274.44,163.03 279.01,167.6 276.98,169.63 274.95,169.63 272.41,167.09 268.35,167.09 263.27,162.01 261.23,164.05 261.23,166.59 274.44,179.79 274.44,182.33 289.68,197.57 289.68,201.13 305.94,217.39 305.94,233.13 306.95,234.15 306.95,238.21 A20.N2
WB02\  (via drill 0.61)
  Top 0.254: v158.62,92.42 159.13,91.91 159.13,75.15 v158.62,74.64 | v303.4,235.67 303.4,234.15 303.91,233.64 303.91,232.63 304.41,232.12 304.41,216.88 305.43,215.86 305.43,203.67 303.91,202.15 303.91,180.3 302.89,179.29 302.89,172.68 302.38,172.17 v302.38,149.31
  Route2 0.254: v189.1,75.15 206.37,92.42 207.39,92.42 218.05,103.09 218.05,104.61 C14.L1 | v302.38,149.31 302.38,148.81 294.25,140.68 293.75,140.68 269.87,116.8 268.35,116.8 258.69,107.15 256.66,107.15 v253.61,104.1
  Bottom 0.254: v158.62,92.42 155.06,92.42 C10.R1 | v158.62,74.64 159.13,75.15 v189.1,75.15 | v303.4,235.67 310,235.67 A20.P2 | v253.61,104.1 244.98,104.1 243.96,103.09 239.39,103.09 238.37,104.1 224.15,104.1 223.13,105.12 222.12,105.12 221.61,104.61 218.56,104.61 C14.L1
WC  (via drill 0.61)
  Top 0.254: B11.K1 173.86,177.76 173.86,173.7 174.87,172.68 174.87,150.84 173.86,149.82 173.86,136.11 174.87,135.09 174.87,81.75 173.86,80.73 173.86,66 174.87,64.99 174.87,22.82 173.86,21.81 173.86,19.77 D11.S1 | v414.65,250.91 414.65,245.33 414.14,244.82 414.14,234.66 414.65,234.15 v414.65,217.39
  Route2 0.254: v170.3,177.76 v164.21,171.67 | v216.53,221.45 200.27,205.19 199.26,205.19 191.13,197.07 191.13,195.54 173.86,178.27 B11.K1
  Route15 0.254: v414.65,250.91 411.6,253.96 A26.H1
  Bottom 0.254: v164.21,171.67 158.62,171.67 B10.M1 | v170.3,177.76 173.35,177.76 B11.K1 | v414.65,217.39 399.41,217.39 398.9,217.89 397.89,217.89 396.36,216.37 383.15,216.37 382.65,216.88 376.55,216.88 375.53,215.86 369.44,215.86 368.42,214.85 333.37,214.85 332.35,215.86 331.34,215.86 329.31,217.89 327.27,217.89 326.77,217.39 301.87,217.39 301.37,217.89 268.35,217.89 267.84,217.39 259.71,217.39 258.19,218.91 255.14,218.91 253.61,217.39 238.88,217.39 234.82,221.45 v216.53,221.45
WC0  (via drill 0.61)
  Top 0.254: v82.42,99.53 v82.42,101.56
  Route15 0.254: v43.81,115.79 45.84,113.75 46.35,113.75 47.37,112.74 48.38,112.74 48.89,112.23 48.89,111.21 54.99,105.12 54.99,104.61 55.49,104.1 56.51,104.1 v61.08,99.53
  Bottom 0.254: v43.81,115.79 43.3,116.29 22.47,116.29 21.46,115.28 15.36,115.28 C01.H1 | v61.08,99.53 63.62,99.53 64.13,100.04 81.91,100.04 v82.42,99.53 | v82.42,101.56 82.93,102.07 87.5,102.07 C06.M2
WC0\  (via drill 0.61)
  Top 0.254: v84.96,94.45 84.96,98.51 C06.N2
  Route15 0.254: v84.96,94.45 98.17,81.24 98.17,80.23 v104.26,74.13 | v112.9,73.62 113.91,73.62 131.69,55.84 133.22,55.84 145.92,43.14 145.92,42.13 163.7,24.35 164.21,24.35 v165.73,22.82
  Bottom 0.254: v104.26,74.13 104.77,73.62 v112.9,73.62 | v165.73,22.82 170.3,22.82 D11.R1
WC\  (via drill 0.61)
  Top 0.254: v167.25,28.41 167.25,31.97 D11.M2 167.25,32.47 167.25,35.52 v168.27,36.54 | v178.43,84.29 178.43,68.54 177.41,67.53 177.41,64.48 176.91,63.97 176.91,46.19 v177.41,45.68 | v163.19,172.68 162.68,172.17 162.68,161.51 163.19,161 163.7,161 164.21,160.49 164.21,158.97 165.73,157.44 165.73,148.81 165.22,148.3 165.22,138.65 163.7,137.12 163.7,136.11 165.22,134.58 165.22,96.48 v164.71,95.97
  Route2 0.254: v177.92,17.74 173.86,13.68 D11.U1 | v178.43,84.29 179.95,85.81 C12.T2 | v177.41,45.68 v168.27,36.54 | v163.19,172.68 164.21,172.68 169.29,177.76 169.29,178.27 169.79,178.78 170.81,178.78 174.87,182.84 175.38,182.84 178.94,186.4 179.45,186.4 179.95,186.91 B12.F2 | v164.71,95.97 v167.25,98.51
  Route15 0.254: v167.25,28.41 v177.92,17.74 | v167.25,98.51 167.76,98.51 179.95,86.32 C12.T2
WR_EN  (via drill 0.61)
  Top 0.254: A20.R2 306.95,231.61 306.95,228.05 305.94,227.04 305.94,218.4 306.95,217.39 306.95,202.15 305.43,200.62 305.43,166.08 306.95,164.55 306.95,162.52 B20.R2 | v408.55,255.49 408.55,257.01 A26.F1 | C15.A1 237.36,133.57 237.36,129.5 238.88,127.98 238.88,106.13 237.36,104.61 237.36,102.58 C15.M1 237.36,101.56 v237.36,99.02 | 136.77,46.19 135.76,47.21 135.76,50.76 D09.E2 | 136.77,35.52 136.77,22.82 135.76,21.81 135.76,19.77 D09.S2 | 136.77,46.19 136.77,35.52 | 136.77,35.52 v136.27,35.52 | 137.28,46.19 v137.28,45.17 137.28,32.98 138.81,31.46 138.81,29.43 D09.N1 | 137.28,46.19 137.28,55.33 138.81,56.86 138.81,60.41 D09.B1 138.81,61.43 v138.81,68.03 | v151.51,80.73 151.51,82.77 C10.U2 151.51,83.27 151.51,87.34 149.98,88.86 149.98,113.25 151,114.26 C10.H2 | 137.28,46.19 136.77,46.19
  Route2 0.254: v408.55,255.49 398.9,245.83 397.89,245.83 v389.76,237.71 | v326.26,232.12 v331.85,237.71 | v237.36,99.02 221.61,83.27 C14.U1 | v151.51,80.73 v138.81,68.03 | v169.79,113.25 173.35,116.8 173.35,117.31 179.95,123.91 C12.D2 | v211.45,76.16 v218.56,83.27 | v280.54,135.6 305.94,161 306.45,161 306.95,161.51 B20.R2 | v239.39,135.6 238.88,135.6 237.36,134.07 C15.A1
  Route15 0.254: v156.59,75.65 156.08,75.65 151.51,80.23 v151.51,80.73
  Bottom 0.254: A20.R2 307.46,232.12 310,232.12 311.02,231.1 314.57,231.1 315.59,232.12 322.7,232.12 A21.R2 323.21,232.12 v326.26,232.12 | v389.76,237.71 389.25,237.2 332.35,237.2 v331.85,237.71 | v136.27,35.52 132.71,35.52 D09.L2 | v137.28,45.17 141.35,45.17 D09.H1 | v169.79,113.25 155.57,113.25 154.05,114.77 152.01,114.77 C10.H2 | v218.56,83.27 221.1,83.27 C14.U1 | v211.45,76.16 210.94,76.67 184.53,76.67 183.51,75.65 v156.59,75.65 | v239.39,135.6 v280.54,135.6
WR_EN\  (via drill 0.61)
  Top 0.254: v180.46,115.79 180.46,112.23 C12.J2 | v224.15,92.42 v224.15,114.77 224.66,115.28 224.66,120.36 v224.15,120.87 | v171.32,166.08 171.83,166.59 171.83,182.33 170.3,183.86 170.3,186.91 B11.F1 | v159.63,154.39 159.63,151.85 160.65,150.84 160.65,148.81 160.14,148.3 160.14,119.34 161.67,117.82 161.67,115.79 v162.17,115.28
  Route2 0.254: v224.15,92.42 221.61,89.88 C14.S1 | v224.15,120.87 227.2,123.91 C15.D2 | v159.63,154.39 v171.32,166.08
  Bottom 0.254: 180.46,116.29 171.32,116.29 169.79,114.77 167.76,114.77 C11.H2 166.75,114.77 162.68,114.77 v162.17,115.28 | 180.46,116.29 222.12,116.29 223.64,114.77 v224.15,114.77 230.25,114.77 C15.H2 | 180.46,116.29 v180.46,115.79
WRITE_ALL  (via drill 0.61)
  Top 0.254: v102.23,67.02 102.23,33.49 103.25,32.47 D07.M2 | v127.63,67.02 v127.63,130.52 127.63,134.58 126.61,135.6 126.61,149.82 127.63,150.84 127.63,204.69 126.61,205.7 126.61,207.73 127.12,208.24 127.12,219.42 v126.61,219.93 | v119.5,227.04 119.5,228.56 A08.S2 | v186.56,184.37 186.56,186.91 B12.F1
  Route2 0.254: v127.63,130.52 128.14,130.52 139.31,141.69 139.31,142.2 163.19,166.08 163.7,166.08 v169.29,171.67 | v186.56,184.37 186.05,184.37 173.86,172.17 B11.M1
  Route15 0.254: v126.61,219.93 v119.5,227.04
  Bottom 0.254: v102.23,67.02 102.74,66.51 127.12,66.51 v127.63,67.02 | v169.29,171.67 173.35,171.67 B11.M1
WRITE_DATA  (via drill 0.61)
  Top 0.254: v129.66,229.07 129.15,228.56 129.15,211.8 130.17,210.78 v130.17,209.26 | v186.56,209.26 186.56,200.62 B12.B1 | v100.71,50.76 100.71,48.73 D07.F2 | v160.65,77.18 160.14,77.69 160.14,115.28 161.16,116.29 161.16,117.31 159.63,118.83 v159.63,149.31 | v161.67,209.26 161.67,180.81 161.16,180.3 161.16,153.89 v162.68,152.36
  Route2 0.254: v129.66,229.07 132.2,231.61 A09.R2 | v100.71,50.76 105.79,55.84 105.79,56.35 126.11,76.67 v126.61,76.67 | v159.63,149.31 v162.68,152.36 169.29,158.97 169.29,160.49 170.3,161.51 B11.R1
  Bottom 0.254: v130.17,209.26 130.68,209.77 161.67,209.77 | 161.67,209.77 186.05,209.77 v186.56,209.26 | v126.61,76.67 127.12,77.18 144.9,77.18 145.41,77.69 160.14,77.69 v160.65,77.18 | v161.67,209.26 161.67,209.77
WRITE_DATA\  (via drill 0.61)
  Top 0.254: v110.87,48.22 111.37,48.73 111.37,69.05 v110.87,69.56 | v121.03,79.72 121.03,89.88 121.53,90.39 121.53,131.53 122.55,132.55 122.55,147.28 121.53,148.3 121.53,159.47 v122.04,159.98
  Route2 0.254: v121.03,79.72 v110.87,69.56
  Route15 0.254: v122.04,159.98 122.55,159.98 125.09,162.52 118.49,169.13 117.98,169.13 117.47,169.63 117.47,170.65 118.99,172.17 119.5,171.67 B08.M2
  Bottom 0.254: v110.87,48.22 107.31,48.22 D07.F1
WRITE_OK  (via drill 0.61)
  Top 0.254: v262.76,116.8 262.76,115.28 C17.H2 | v232.79,145.76 232.79,157.44 233.8,158.46 233.8,161.51 B15.R1 | v224.15,186.91 223.64,186.4 223.64,170.65 v224.15,170.14
  Route2 0.254: v328.29,253.45 338.45,263.61 A22.D2 | v290.7,252.95 286.63,248.88 286.63,247.87 273.43,234.66 272.92,234.66 238.88,200.62 238.88,200.11 238.37,199.61 236.34,199.61 228.21,191.48 228.21,190.97 v224.15,186.91
  Route15 0.254: v180.46,189.45 173.35,196.56 B11.C1 | v205.86,188.94 225.17,169.63 225.17,169.13 | 225.17,169.13 v232.28,162.01 | v262.76,116.8 259.71,119.85 258.19,119.85 239.39,138.65 239.39,139.15 v232.79,145.76 | v224.15,170.14 225.17,169.13
  Bottom 0.254: v180.46,189.45 205.35,189.45 v205.86,188.94 | v232.28,162.01 233.8,162.01 B15.R1 | v328.29,253.45 327.78,252.95 v290.7,252.95
WRITE_OK+UTS
  Top 0.254: B12.K1 189.1,178.27 187.57,179.79 187.57,192.49 186.56,193.51 B12.D1
  Route15 0.254: C17.M1 268.85,102.58 268.85,104.1 260.22,112.74 259.2,112.74 242.44,129.5 242.44,130.52 237.87,135.09 236.85,135.09 210.43,161.51 210.43,163.03 198.75,174.71 198.75,175.22 192.15,181.83 190.62,181.83 188.08,179.29 189.1,178.27 B12.K1
WRTM  (via drill 0.61)
  Top 0.254: v103.25,54.83 102.74,54.32 102.74,45.68 103.25,45.17 D07.H2 | v151.51,104.1 151.51,108.17 C10.K2 | v145.41,175.22 146.43,174.21 146.43,134.58 145.41,133.57 145.41,125.44 146.93,123.91 146.93,120.87 147.44,120.36 147.44,119.34 146.43,118.33 146.43,110.2 v146.93,109.69
  Route2 0.254: v103.25,54.83 145.92,97.5 145.92,98.51 v151.51,104.1 | v171.32,203.16 160.14,191.99 160.14,189.45 145.92,175.22 v145.41,175.22
  Route15 0.254: v168.27,104.1 v173.35,99.02
  Bottom 0.254: v173.35,99.02 179.95,99.02 C12.N2 | v151.51,104.1 v168.27,104.1 | v171.32,203.16 173.35,203.16 B11.A1 | v146.93,109.69 147.95,108.67 151,108.67 C10.K2
WRTM+FR03
  Top 0.254: C12.V2 180.97,80.23 181.99,81.24 181.99,84.8 188.59,91.4 188.59,100.55 189.61,101.56 C12.M1
  Route15 0.254: B08.K2 120.01,177.76 120.01,173.19 121.03,172.17 121.03,168.11 127.63,161.51 128.65,161.51 156.59,133.57 156.59,133.06 157.09,132.55 158.11,132.55 169.79,120.87 171.83,120.87 172.33,120.36 172.33,118.83 174.87,116.29 174.87,114.77 182.49,107.15 186.56,107.15 188.08,105.63 188.08,104.1 189.61,102.58 C12.M1
WRTM\  (via drill 0.61)
  Top 0.254: v108.83,61.94 108.83,46.19 109.85,45.17 D07.H1 | v97.15,73.62 96.64,74.13 96.64,91.91 98.67,93.94 98.67,94.96 98.17,95.47 98.17,105.63 v99.18,106.64
  Route2 0.254: v99.18,106.64 103.25,110.71 103.75,110.71 106.8,113.75 107.31,113.75 112.39,118.83 112.39,119.34 112.9,119.85 114.93,119.85 129.15,134.07 129.15,135.6 146.93,153.38 147.95,153.38 v148.46,153.89
  Route15 0.254: v97.15,73.62 v108.83,61.94 | v148.46,153.89 143.89,158.46 143.89,158.97 130.17,172.68 128.14,172.68 120.52,180.3 120.52,182.84 119.5,183.86 B08.H2
XOR_TO_LPB
  Top 0.254: C10.E2 151,120.87 148.46,118.33 C10.F2 148.46,117.31 149.47,116.29 149.47,84.8 | 149.47,84.8 149.98,84.29 149.98,80.73 151,79.72 152.52,79.72 152.52,87.34 152.01,87.85 152.01,88.86 C10.S2 | 149.47,84.8 148.46,85.81 C10.T2
  Route15 0.254: D12.P2 183.51,26.38 183.51,28.92 186.05,31.46 186.56,31.46 190.62,35.52 178.94,47.21 178.94,50.25 166.24,62.95 166.24,64.48 150.49,80.23 150.49,81.75 149.98,82.26 149.98,84.29 148.46,85.81 C10.T2
XSA_DY
  Top 0.254: B14.L2 211.96,175.22 213.48,176.75 213.48,192.49 217.55,196.56 217.55,199.61 B14.B1 218.56,200.62 219.58,201.64 219.58,255.99 223.13,255.99 224.66,254.47 224.66,226.53 229.23,221.96 229.23,151.85 230.25,150.84 230.25,146.77 232.28,144.74 232.28,123.41 235.83,119.85 235.83,81.75 248.03,81.75 251.07,84.8 251.07,85.81 259.2,85.81 C17.T2
  Bottom 0.254: A08.D2 115.95,263.61 108.83,256.5 83.43,256.5 69.72,242.79 50.41,242.79 44.83,237.2 44.83,230.09 34.67,230.09 22.98,218.4 22.98,201.64 159.13,201.64 159.63,202.15 199.77,202.15 200.27,201.64 216.53,201.64 217.55,200.62 B14.B1
XSAD
  Route15 0.254: A09.R1 139.31,232.12 145.41,232.12 151.51,238.21 142.87,246.85 140.84,246.85 131.19,256.5 131.19,264.63 136.77,270.22 141.35,265.65 142.87,265.65 163.7,244.82 A11.L2
XSAD\  (via drill 0.61)
  Top 0.254: v168.27,187.41 168.78,187.92 168.78,228.05 169.29,228.56 169.29,242.28 167.25,244.31 167.25,247.87 A11.K2 | v240.41,116.29 v240.41,121.88 | v193.67,69.05 193.67,40.09 195.7,38.06 195.7,36.03 D13.L2
  Route2 0.254: v240.41,116.29 238.88,114.77 238.88,114.26 227.71,103.09 225.17,103.09 222.12,100.04 222.12,98.01 221.61,97.5 221.1,97.5 207.39,83.78 207.39,82.77 v193.67,69.05
  Route15 0.254: v168.27,187.41 174.87,180.81 177.41,180.81 184.53,173.7 184.53,173.19 193.67,164.05 196.21,164.05 198.24,162.01 198.24,161 198.75,160.49 199.77,160.49 201.8,158.46 201.8,157.95 202.31,157.44 202.81,157.44 203.83,156.43 206.88,156.43 218.05,145.25 218.05,144.23 v240.41,121.88
XSTA  (via drill 0.61)
  Top 0.254: B07.D2 100.71,193.51 100.71,189.45 101.72,188.43 101.72,178.27 100.71,177.25 100.71,175.22 B07.L2 | C07.B1 106.8,131.03 106.8,146.77 105.79,147.79 v105.79,158.97 105.79,163.03 106.8,164.05 106.8,168.11 B07.N1 106.8,168.62 v106.8,171.16 108.33,172.68 v108.33,184.37 108.33,195.03 106.8,196.56 106.8,199.61 B07.B1 | 99.18,119.34 100.2,120.36 v100.2,121.37 100.2,123.91 C07.D2 100.2,124.93 v100.2,126.45 | 99.18,119.34 99.18,108.67 100.2,107.66 100.2,105.63 C07.L2 | 99.18,119.34 v99.18,119.85 | v170.3,31.46 170.3,29.43 D11.N1 | v160.65,46.7 v160.65,41.62
  Route2 0.254: v104.26,130.52 v100.2,126.45
  Route15 0.254: v106.8,171.16 v103.25,174.71 | v100.2,121.37 v106.8,114.77 | v170.3,31.46 170.3,31.97 v160.65,41.62 | v160.65,46.7 160.14,46.7 146.93,59.91 146.93,61.43 139.31,69.05 136.77,69.05 120.52,85.31 120.52,85.81 111.88,94.45 111.88,95.97 v102.74,105.12
  Bottom 0.254: v105.79,158.97 104.26,158.97 B07.S2 | v108.33,184.37 109.85,184.37 B07.H1 | v103.25,174.71 101.21,174.71 B07.L2 | v99.18,119.85 68.19,119.85 66.67,118.33 59.56,118.33 C04.F1 | v106.8,114.77 109.34,114.77 C07.H1 | v102.74,105.12 100.71,105.12 C07.L2 | v104.26,130.52 106.29,130.52 C07.B1
XSTA\  (via drill 0.61)
  Top 0.254: D13.K2 199.26,39.08 199.26,44.67 D13.H2 | v115.44,136.61 115.95,137.12 115.95,146.27 114.93,147.28 114.93,161 v114.42,161.51
  Route2 0.254: D13.J2 196.21,42.13 198.75,44.67 D13.H2 | D16.N2 243.96,29.43 246.5,31.97 D16.M2 | D14.L2 211.45,35.52 214.5,38.57 D14.K2 | v77.85,136.61 66.67,125.44 66.67,124.93 63.11,121.37 C04.E1 | v138.81,107.66 138.81,108.17 v140.84,110.2
  Route15 0.254: v234.82,37.05 242.95,28.92 D16.N2 | D14.L2 210.94,35.52 v201.29,45.17 200.78,45.17 195.7,50.25 194.69,50.25 190.11,54.83 189.61,54.83 167.25,77.18 167.25,78.7 159.13,86.83 158.11,86.83 143.89,101.05 143.89,102.58 v138.81,107.66 | v140.84,110.2 139.82,111.21 139.82,112.74 127.63,124.93 126.61,124.93 115.44,136.11 v115.44,136.61
  Bottom 0.254: v234.82,37.05 219.07,37.05 217.55,38.57 215.01,38.57 D14.K2 | v201.29,45.17 199.26,45.17 D13.H2 | v77.85,136.61 78.35,136.11 114.93,136.11 v115.44,136.61 | v114.42,161.51 114.42,162.01 115.95,162.01 B08.R2

## Text on the board
tPlace: 1 | 2 | 3 | 4 | 5 | 6 | 7 | 8 | 9 | 10 | 11 | 12 | 13 | 14 | 15 | 16 | 17 | 18 | 19 | 20 | 21 | 22 | 23 | 24 | 25 | 26 | 27 | 28