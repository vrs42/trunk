# EAGLE board tc083-18 (EAGLE 4.11), part 5 of 6
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
N$151 (continued)
  Top 0.254: D16.V2 242.95,10.63 242.44,11.14 242.44,21.81 242.95,22.31 D16.R2
N$153
  Top 0.254: A10.J2 148.46,251.93 148.46,257.01 A10.F2
N$155  (via drill 0.61)
  Top 0.254: v154.55,102.07 154.55,104.61 C10.L1
  Route2 0.254: v179.95,94.45 179.95,94.96 191.64,106.64 193.67,106.64 198.24,111.21 199.77,111.21 v210.94,122.39
  Route15 0.254: v162.17,94.45 v154.55,102.07
  Bottom 0.254: v162.17,94.45 v179.95,94.45 | v210.94,122.39 212.47,122.39 213.48,121.37 214.5,121.37 C14.E2
N$161
  Top 0.254: A09.P2 135.76,235.67 136.77,236.69 136.77,244.31 134.23,246.85 134.23,262.09 137.28,265.14 153.54,265.14 153.54,256.5 170.3,256.5 170.3,257.01 A11.F1
N$162
  Top 0.254: A12.D1 186.05,264.63 186.05,269.71 A12.B1
  Route2 0.254: A11.H1 173.86,254.98 174.37,254.98 186.05,266.66 186.05,269.2 186.56,269.71 A12.B1
N$185
  Route15 0.254: C10.E1 158.11,120.87 159.13,120.87 169.79,110.2 174.37,110.2 177.41,107.15 177.41,106.13 186.05,97.5 193.16,97.5 206.88,83.78 206.88,82.77 210.94,78.7 213.48,78.7 235.83,56.35 239.39,56.35 252.09,43.65 255.65,43.65 262.25,37.05 265.81,37.05 268.85,34 277.49,34 287.65,44.16 287.65,58.89 283.59,62.95 283.59,63.97 260.22,87.34 259.2,87.34 251.58,94.96 251.58,99.02 242.95,107.66 241.93,107.66 226.18,123.41 226.18,124.42 223.64,126.96 221.61,126.96 C14.C1
N$193  (via drill 0.61)
  Route2 0.254: v183.51,87.85 184.02,87.85 193.16,96.99 193.16,98.51 v204.85,110.2
  Bottom 0.254: v183.51,87.85 161.67,87.85 161.16,88.35 158.62,88.35 158.11,88.86 C10.S1 | v204.85,110.2 212.97,110.2 214.5,111.72 217.55,111.72 C14.J1
NC  (59 unrouted)
PAR
  Bottom 0.254: A08.U1 126.11,222.97 127.12,223.99 239.39,223.99 239.9,223.48 245.49,223.48 246.5,224.5 391.28,224.5 392.3,225.51 A25.T1
PAR\  (via drill 0.61)
  Route2 0.254: v123.06,229.07 88.51,194.53 88.01,194.53 79.88,186.4 78.35,186.4 67.18,175.22 67.18,174.71 66.67,174.21 65.15,174.21 63.11,172.17 B04.M1 | v187.57,261.07 184.02,257.52 184.02,257.01 183.51,256.5 183,256.5 177.92,251.42 177.92,250.41 v170.3,242.79 | v142.36,245.83 126.11,229.58 A08.S1
  Route15 0.254: v142.36,245.83 v145.41,242.79
  Bottom 0.254: v123.06,229.07 125.09,229.07 A08.S1 | v187.57,261.07 189.1,261.07 A12.E1 | v170.3,242.79 169.79,243.29 145.92,243.29 v145.41,242.79
PC+ES  (via drill 0.61)
  Route2 0.254: v171.83,254.47 173.86,256.5 174.37,256.5 181.99,264.12 181.99,264.63 182.49,265.14 183,265.14 v185.03,267.17
  Bottom 0.254: v171.83,254.47 167.76,254.47 A11.H2 | v185.03,267.17 189.1,267.17 A12.C1
PC+ES\
  Top 0.254: B11.R2 164.71,162.52 164.71,166.59 165.22,167.09 165.22,201.13 164.21,202.15 164.21,217.39 165.22,218.4 165.22,250.41 164.71,250.91 A11.J2
PWR_CLR\  (via drill 0.61)
  Top 0.254: v167.25,70.07 167.25,82.77 C11.U2 | v218.05,88.86 218.05,91.91 C14.R1 | v88.01,98.51 88.01,95.97 C06.P2 88.01,95.47 v88.01,93.43 | v119.5,147.79 119.5,152.36 B08.U2 120.01,152.87 120.52,153.38 120.52,157.44 121.03,157.95 v121.03,161 | A10.M2 152.01,242.28 152.01,244.31 152.52,244.82 152.52,246.34 153.03,246.85 153.03,249.39 152.52,249.9 152.52,250.91 152.01,251.42 152.01,253.96 A10.H2 151.51,254.98 v151.51,258.53 | v366.39,290.54 366.39,265.65 365.37,264.63 365.37,263.61 365.88,263.11 365.88,256.5 366.39,255.99 366.39,243.8 364.87,242.28 A23.M1 | v161.67,268.19 v161.67,275.3 | v113.91,168.11 114.42,168.62 114.42,189.45 113.91,189.95 v113.91,209.26
  Route2 0.254: v210.94,81.75 v218.05,88.86 | v119.5,147.79 94.61,122.9 93.59,122.9 90.55,119.85 90.04,119.85 78.86,108.67 C05.K1 | v206.88,290.54 190.11,273.77 A12.A1 | v151.51,258.53 152.01,258.53 v161.67,268.19 | v113.91,209.26 114.42,209.26 130.17,225.01 130.17,226.02 145.92,241.77 v146.43,241.77
  Route15 0.254: v167.25,70.07 173.35,63.97 D11.A1 | v88.01,98.51 78.35,108.17 C05.K1 | v110.36,71.59 93.59,88.35 93.09,88.35 v88.01,93.43 | v186.56,275.81 189.1,273.27 A12.A1 | v121.03,161 v113.91,168.11
  Bottom 0.254: v210.94,81.75 170.3,81.75 168.78,83.27 167.76,83.27 C11.U2 | v167.25,70.07 166.24,71.08 137.79,71.08 137.28,71.59 v110.36,71.59 | v366.39,290.54 365.88,291.05 207.39,291.05 v206.88,290.54 | v161.67,275.3 186.05,275.3 v186.56,275.81 | v146.43,241.77 151.51,241.77 A10.M2
RD+WD
  Top 0.254: C12.R1 186.05,92.93 185.54,93.43 185.54,134.58 181.99,138.14 181.99,191.99 180.46,193.51 B12.D2
  Route15 0.254: 128.65,242.79 131.19,242.79 133.22,240.75 134.74,240.75 138.3,237.2 139.82,237.2 141.35,235.67 A09.P1 | 128.65,242.79 128.14,242.79 127.12,243.8 121.03,243.8 114.93,249.9 108.83,243.8 108.83,228.56 113.41,223.99 107.82,218.4 105.79,218.4 95.63,228.56 95.63,230.09 78.86,246.85 77.85,246.85 63.11,261.58 47.87,261.58 40.25,269.2 35.68,264.63 35.68,263.11 51.94,246.85 51.94,243.8 59.56,236.18 63.11,236.18 77.85,221.45 78.35,221.45 91.56,208.24 93.09,208.24 99.69,201.64 101.21,201.64 115.44,187.41 115.44,174.21 115.95,173.7 115.95,168.62 B08.N2 | 128.65,242.79 128.65,225.51 135.25,218.91 140.33,223.99 142.87,223.99 143.89,222.97 144.9,222.97 146.93,220.94 148.97,220.94 149.98,219.93 152.52,219.93 178.43,194.02 179.45,194.02 B12.D2
RD_EN
  Bottom 0.254: C11.N2 163.7,99.53 156.08,99.53 155.06,100.55 151,100.55 149.98,101.56 149.98,106.64 163.19,106.64 167.76,111.21 170.3,111.21 C11.J1
RD_EN_LPB_00-02  (via drill 0.61)
  Top 0.254: D09.D1 138.81,53.81 138.81,50.25 139.82,49.24 v139.82,38.57 139.82,26.38 138.81,25.36 138.81,23.33 D09.R1 | v161.16,114.26 160.65,113.75 160.65,90.89 | 160.65,90.89 v161.16,90.39 | v161.67,72.1 161.67,77.69 160.65,78.7 160.65,90.89
  Route2 0.254: v161.67,72.1 v143.89,54.32
  Route15 0.254: v151,124.42 v161.16,114.26 | v190.11,91.4 192.15,89.37 192.65,89.37 195.7,86.32 C13.T2
  Bottom 0.254: v139.82,38.57 141.35,38.57 D09.K1 | v151,124.42 148.46,124.42 C10.D2 | v161.16,90.39 161.67,90.89 188.59,90.89 189.1,91.4 v190.11,91.4 | v143.89,54.32 139.31,54.32 D09.D1
RD_EN_LPB_03-05
  Top 0.254: 133.73,18.25 133.73,27.39 132.71,28.41 D09.N2 | 133.73,18.25 133.73,15.2 135.25,13.68 D09.U2 | 133.73,18.25 144.9,18.25 144.9,44.16 146.93,46.19 146.93,56.86 149.47,59.4 149.47,82.77 146.93,85.31 146.93,90.89 147.95,91.91 C10.R2
  Route2 0.254: D09.H2 135.25,44.67 135.25,40.09 134.23,39.08 134.23,30.95 132.71,29.43 D09.N2
  Bottom 0.254: C10.R2 148.46,91.91 148.97,91.4 188.08,91.4 189.1,92.42 195.7,92.42 C13.R2
RDD_00  (via drill 0.61)
  Top 0.254: v132.2,50.25 132.2,48.73 D09.F2 | 137.28,152.36 137.28,150.33 136.27,149.31 136.27,136.11 137.28,135.09 v137.28,110.71 | 137.28,152.36 137.28,157.95 136.77,158.46 136.77,166.59 136.27,167.09 136.27,168.11 135.76,168.62 135.76,171.16 B09.M2 | v145.41,102.58 144.9,102.07 144.9,93.43 145.92,92.42 145.92,84.29 146.93,83.27 146.93,82.26 146.43,81.75 146.43,63.46 v146.93,62.95 | v138.81,153.89 137.28,152.36
  Route2 0.254: v139.82,57.87 v132.2,50.25 | v146.93,62.95 146.93,62.45 142.36,57.87 D09.C1 | v321.69,222.97 321.69,222.47 312.03,212.81 v311.53,212.81 | v199.77,211.29 193.67,205.19 193.16,205.19 191.13,203.16 191.13,202.15 174.87,185.89 172.84,185.89 166.75,179.79 164.21,179.79 143.89,159.47 143.89,158.97 v138.81,153.89
  Route15 0.254: v137.28,110.71 v145.41,102.58
  Bottom 0.254: v139.82,57.87 141.35,57.87 D09.C1 | v321.69,222.97 325.75,222.97 A21.U2 | v311.53,212.81 310,211.29 279.01,211.29 278,212.31 266.82,212.31 266.31,212.81 245.99,212.81 244.98,211.8 240.91,211.8 239.39,210.27 224.15,210.27 223.13,211.29 217.55,211.29 217.04,210.78 200.27,210.78 v199.77,211.29
RDD_01  (via drill 0.61)
  Top 0.254: v138.81,37.55 138.81,41.11 D09.J1 | v153.03,153.89 153.03,151.35 152.52,150.84 152.52,136.61 153.03,136.11 153.03,115.79 154.55,114.26 154.55,113.25 154.05,112.74 153.54,112.74 153.54,89.37 154.05,88.86 154.05,87.85 153.54,87.34 v153.54,62.45 | v143.89,52.79 v143.89,42.13
  Route2 0.254: v138.81,37.55 137.28,36.03 137.28,35.01 135.25,32.98 135.25,32.47 D09.M2 | v153.54,62.45 153.03,62.45 144.9,54.32 144.9,53.81 v143.89,52.79 | v294.25,139.66 v306.95,152.36
  Route15 0.254: B09.P1 141.85,165.06 v153.03,153.89 v167.25,139.66
  Bottom 0.254: v143.89,42.13 143.38,41.62 139.31,41.62 D09.J1 | v306.95,152.36 310,152.36 B20.U2 | v294.25,139.66 252.6,139.66 252.09,140.17 234.31,140.17 233.29,141.19 212.47,141.19 210.94,139.66 208.91,139.66 207.39,141.19 197.73,141.19 196.72,140.17 190.11,140.17 188.59,141.69 187.57,141.69 186.05,140.17 180.46,140.17 179.45,139.15 167.76,139.15 v167.25,139.66
RDD_02  (via drill 0.61)
  Top 0.254: v141.85,23.84 141.85,25.36 D09.P1 141.35,26.38 140.33,27.39 140.33,37.55 140.84,38.06 140.84,40.09 140.33,40.6 140.33,56.86 140.84,57.37 v140.84,100.55 | v310,206.21 310,222.47 A20.U2 | v137.28,169.13 137.28,185.38 136.27,186.4 136.27,187.41 135.76,187.92 135.76,190.46 B09.E2
  Route2 0.254: v141.85,23.84 134.23,16.22 132.71,16.22 D09.T2 | v149.47,206.72 148.97,206.72 141.35,199.1 141.35,198.59 135.25,192.49 135.25,190.97 B09.E2 | v110.36,141.69 110.87,141.19 117.98,148.3 117.98,148.81 130.17,161 130.17,162.01 v137.28,169.13
  Route15 0.254: v140.84,100.55 140.84,101.05 137.79,104.1 137.79,104.61 137.28,105.12 137.28,107.66 136.77,108.17 136.77,109.18 127.63,118.33 127.63,122.9 110.87,139.66 110.87,141.19 v110.36,141.69
  Bottom 0.254: v149.47,206.72 181.48,206.72 181.99,207.23 192.65,207.23 193.67,208.24 206.88,208.24 208.4,206.72 211.45,206.72 211.96,207.23 235.83,207.23 236.85,206.21 238.88,206.21 240.41,207.73 266.82,207.73 269.36,205.19 271.39,205.19 271.9,205.7 274.95,205.7 275.97,206.72 309.49,206.72 v310,206.21
RDMK
  Top 0.254: CD18.AS2 279.01,89.88 280.03,90.89 280.03,134.58 279.01,135.6 279.01,152.36 B18.U2
READ_ALL\  (via drill 0.61)
  Top 0.254: v111.88,28.92 112.39,29.43 112.39,38.57 v111.88,39.08
  Route2 0.254: v111.88,39.08 130.68,57.87 132.2,57.87 142.36,68.03 142.36,68.54 142.87,69.05 143.89,69.05 152.52,77.69 154.55,77.69 161.67,84.8 161.67,87.34 172.33,98.01 172.33,100.55 173.35,101.56 C11.M1
  Bottom 0.254: v111.88,28.92 107.31,28.92 D07.N1
READ_DATA  (via drill 0.61)
  Top 0.254: v97.66,44.16 97.15,44.67 97.15,62.95 98.67,64.48 v98.67,73.62 | v156.59,188.43 156.59,239.23 155.06,240.75 155.06,244.31 A10.L1 | v147.95,178.78 147.44,178.27 147.44,146.27 v147.95,145.76 | v171.83,121.88 172.33,121.37 172.33,118.83 173.86,117.31 173.86,115.28 C11.H1
  Route2 0.254: v151,73.11 162.17,84.29 162.17,86.83 173.35,98.01 173.86,98.01 177.92,102.07 177.92,106.13 v179.95,108.17 | v156.59,188.43 156.59,186.91 148.46,178.78 v147.95,178.78
  Route15 0.254: v97.66,44.16 100.2,41.62 D07.J2 | v179.95,108.17 179.45,108.17 173.35,114.26 C11.H1 | v147.95,145.76 160.65,133.06 160.65,131.03 168.78,122.9 170.81,122.9 v171.83,121.88
  Bottom 0.254: v98.67,73.62 102.23,73.62 102.74,73.11 111.37,73.11 111.88,72.61 143.38,72.61 143.89,73.11 v151,73.11
READ_DATA\  (via drill 0.61)
  Top 0.254: v111.88,170.14 v111.88,41.62
  Route2 0.254: v111.88,170.14 116.45,174.71 B08.L2 | v158.62,175.73 163.7,180.81 B11.J2
  Bottom 0.254: v111.88,41.62 107.31,41.62 D07.J1 | v158.62,175.73 158.11,176.24 121.03,176.24 119.5,174.71 116.96,174.71 B08.L2
RSTA\
  Route2 0.254: B03.M2 40.25,172.17 40.25,175.73 41.78,177.25 41.78,179.29 43.3,180.81 B03.J1 | B03.C1 46.35,196.56 46.35,194.53 41.27,189.45 39.75,189.45 37.71,187.41 B03.F2 | C04.A1 62.1,133.57 62.1,131.53 53.46,122.9 50.92,122.9 47.87,119.85 43.81,119.85 36.7,126.96 33.65,123.91 32.63,123.91 32.13,123.41 30.6,123.41 19.93,112.74 16.38,112.74 12.82,109.18 11.3,109.18 5.2,115.28 7.23,117.31 7.23,123.41 16.89,133.06 16.89,137.12 35.68,155.92 35.68,156.43 42.79,163.54 44.83,163.54 46.35,165.06 B03.P1
  Route15 0.254: B03.F2 37.21,186.91 37.21,185.38 39.75,182.84 41.78,182.84 43.3,181.32 B03.J1 | B03.M2 40.25,172.17 38.73,173.7 38.73,175.22 37.71,176.24 33.65,176.24 32.13,174.71 36.7,170.14 38.22,170.14 42.79,165.57 46.35,165.57 B03.P1
RSTB\
  Top 0.254: B04.P1 62.1,166.08 61.08,167.09 61.08,196.05 62.1,197.07 B04.C1 | B04.M2 56,172.17 54.48,173.7 54.48,186.4 53.46,187.41 B04.F2
  Route2 0.254: B04.C1 62.1,197.07 62.1,195.03 56.51,189.45 53.97,189.45 52.95,188.43 B04.F2
  Route15 0.254: B04.J1 59.05,181.83 57.02,181.83 54.99,183.86 54.99,185.89 53.46,187.41 B04.F2
  Bottom 0.254: C05.C1 77.85,126.96 76.83,125.95 26.03,125.95 25.52,125.44 13.33,125.44 12.31,126.45 7.23,126.45 7.23,148.3 8.25,148.3 10.28,150.33 10.28,173.19 27.05,173.19 30.09,170.14 50.92,170.14 52.45,171.67 56,171.67 B04.M2
SE\  (via drill 0.61)
  Route2 0.254: v111.37,35.52 112.9,35.52 126.11,48.73 129.15,48.73 152.52,72.1 154.05,72.1 156.59,74.64 157.09,74.64 159.63,77.18 159.63,77.69 v178.94,96.99 | v171.83,109.18 175.38,112.74 175.38,118.33 179.95,122.9 180.97,122.9 182.49,124.42 182.49,125.44 183,125.95 184.02,125.95 202.31,144.23 202.31,145.76 209.42,152.87 209.42,155.41 215.01,161 215.51,161 216.02,161.51 216.02,162.52 v221.1,167.6
  Route15 0.254: v178.94,96.99 178.94,98.51 177.41,100.04 177.41,103.09 176.91,103.59 176.4,103.59 171.83,108.17 v171.83,109.18 | v221.1,167.6 216.02,172.68 215.51,172.68 213.48,174.71 213.48,176.75 206.88,183.35 206.88,185.38 199.26,193 199.26,195.03 191.13,203.16 191.13,206.21 184.02,213.32 183,213.32 177.92,218.4 175.89,218.4 162.68,231.61 162.68,234.66 161.16,236.18 160.65,236.18 148.97,247.87 147.95,247.87 141.85,253.96 A09.H1
  Bottom 0.254: v111.37,35.52 107.31,35.52 D07.L1
SEARCH  (via drill 0.61)
  Top 0.254: v153.03,88.35 153.03,113.25 v153.54,113.75
  Route2 0.254: v114.42,49.75 128.14,63.46 128.65,63.46 135.76,70.57 135.76,71.08 v153.03,88.35 | v153.54,113.75 163.7,123.91 C11.D2
  Bottom 0.254: v114.42,49.75 105.28,49.75 104.26,50.76 D07.E2
SEARCH\  (via drill 0.61)
  Top 0.254: v125.6,67.53 125.6,77.18 127.12,78.7 127.12,90.89 v126.61,91.4 | v154.05,119.85 153.54,120.36 153.54,136.61 153.03,137.12 153.03,150.33 153.54,150.84 153.54,151.85 156.08,154.39 156.08,176.75 v155.57,177.25
  Route2 0.254: v125.6,67.53 123.57,65.49 123.57,64.99 110.36,51.78 D07.E1 | v126.61,91.4 127.12,91.4 139.82,104.1 139.82,104.61 140.33,105.12 140.84,105.12 145.92,110.2 145.92,111.72 v154.05,119.85
  Bottom 0.254: 155.57,176.75 75.81,176.75 74.8,177.76 72.26,177.76 B05.K2 | 155.57,176.75 159.13,176.75 160.14,177.76 166.75,177.76 B11.K2 | v155.57,177.25 155.57,176.75
SEL
  Route15 0.254: A25.S1 395.85,229.58 395.85,233.13 381.63,247.36 381.63,249.9 370.96,260.57 366.9,260.57 355.72,271.74 353.69,271.74 337.43,288 142.36,288 115.44,261.07 117.47,259.04 117.47,256.5 118.99,254.98 A08.H2
SEL\
  Bottom 0.254: B04.H1 63.11,184.87 70.23,184.87 71.75,186.4 142.87,186.4 148.97,192.49 159.13,192.49 162.17,195.54 352.67,195.54 353.18,195.03 368.93,195.03 376.04,202.15 392.3,202.15 403.47,213.32 412.11,213.32 415.67,216.88 415.67,230.59 295.27,230.59 292.22,233.64 144.9,233.64 143.89,232.63 140.84,232.63 139.31,234.15 124.58,234.15 124.58,238.21 132.2,238.21 A09.N2 132.2,239.23 132.2,241.77 127.63,246.34 116.45,246.34 116.45,250.91 A08.J2
SH_DTB
  Top 0.254: A10.R2 148.97,231.61 153.54,231.61 153.54,230.09 156.08,227.55 156.08,190.97 153.54,188.43 153.54,186.4 157.6,186.4 157.6,190.46 B10.E1 | B09.B1 139.31,199.61 139.31,198.59 139.82,198.08 139.82,169.13 139.31,168.62 B09.N1 139.31,168.11 139.82,167.6 139.82,142.71 138.81,141.69 138.81,138.65 | C09.N1 139.31,99.53 139.82,100.04 139.82,129.5 139.31,130.01 C09.B1 138.81,131.03 138.81,138.65 | B09.D2 132.2,193.51 131.19,192.49 131.19,176.24 132.2,175.22 B09.L2 132.71,174.21 133.73,173.19 133.73,147.28 135.76,145.25 | 133.73,103.59 133.73,91.4 135.25,89.88 C09.S2 | 133.73,103.59 132.71,104.61 C09.L2 | 133.73,122.9 132.71,123.91 C09.D2 | 133.73,103.59 133.73,122.9 | 135.76,145.25 135.76,136.61 133.73,134.58 133.73,122.9 | 135.76,145.25 135.76,149.82 136.77,150.84 136.77,157.44 135.76,158.46 B09.S2 | 138.81,138.65 141.35,141.19 141.35,142.2 140.84,142.71 140.84,179.29 141.35,179.79 141.35,183.86 B09.H1
  Bottom 0.254: B09.H1 142.36,184.87 146.93,189.45 156.59,189.45 157.6,190.46 B10.E1 | C09.H1 141.35,114.26 139.31,114.26 135.25,110.2 132.71,110.2 132.71,105.63 C09.L2 132.71,104.61 137.28,104.61 137.79,104.1 143.38,104.1 143.38,101.56 141.35,99.53 139.31,99.53 C09.N1
SH_EN  (via drill 0.61)
  Top 0.254: C10.A1 157.6,133.57 157.6,130.01 159.13,128.49 v159.13,117.82 159.13,106.13 157.6,104.61 157.6,102.58 C10.M1 | v164.21,241.26 164.21,239.23 A11.N2 | v183,259.04 183,260.57 A12.E2 | v147.44,144.23 146.93,144.74 146.93,174.71 146.43,175.22 v146.43,183.35 | v153.54,190.46 v153.54,228.56
  Route2 0.254: v164.21,241.26 175.38,252.44 176.91,252.44 181.99,257.52 181.99,258.03 v183,259.04 | v146.43,183.35 v153.54,190.46 | v153.54,228.56 154.05,228.56 160.14,234.66 160.14,235.17 160.65,235.67 161.16,235.67 163.7,238.21 A11.N2
  Route15 0.254: v147.44,144.23 147.44,143.73 157.6,133.57 C10.A1
  Bottom 0.254: v159.13,117.82 155.06,117.82 C10.F1
SH_ST
  Top 0.254: CD18.AM1 284.6,102.58 283.59,103.59 283.59,135.6 284.09,136.11 284.09,150.33 283.08,151.35 283.08,172.68 285.62,175.22 291.21,175.22 291.21,147.28 300.86,137.63 305.94,137.63 305.94,158.97 308.48,161.51 308.48,234.66 305.94,237.2 305.94,239.74 310,243.8 327.27,243.8 327.27,263.61 317.62,273.27 317.62,274.79 304.41,288 267.84,288 267.84,134.58 268.35,134.07 C17.A1
SH_ST-B
  Route15 0.254: C16.P2 247.01,95.47 249.04,95.47 254.12,90.39 254.12,89.37 264.79,78.7 265.81,78.7 283.08,61.43 283.08,59.4 284.6,57.87 CD18.BC1
SHIFT_CK
  Top 0.254: CD18.BR2 276.47,22.31 275.46,21.3 275.46,2.5 274.95,1.99 272.41,1.99 272.41,32.47 272.92,32.98 272.92,55.84 272.41,56.35 272.41,89.37 272.92,89.88 272.92,104.61 269.36,108.17 C17.K1
SKP_RQ\
  Top 0.254: B05.F1 75.31,187.92 75.31,191.48 76.83,193 76.83,213.83 77.34,214.34 77.34,274.79 94.1,291.55 181.99,291.55 181.99,264.63 188.08,258.53 188.08,230.59 189.1,229.58 A12.S1
SP_DY\  (via drill 0.61)
  Top 0.254: v208.4,50.76 208.4,94.96 207.89,95.47 v207.89,102.07
  Route15 0.254: v208.4,50.76 210.94,48.22 D14.F2
  Bottom 0.254: v207.89,102.07 214.5,102.07 C14.M2
ST_BLK_MK
  Route2 0.254: A26.K1 412.11,247.87 417.19,242.79 410.59,236.18 410.59,230.59 372.49,192.49 372.49,191.48 369.44,188.43 369.44,185.38 353.18,169.13 353.18,168.11 307.97,122.9 306.45,122.9 289.68,106.13 289.68,104.61 279.52,94.45 276.98,94.45 275.46,92.93 CD18.AR2
  Bottom 0.254: C13.E2 199.26,121.37 200.78,122.9 207.89,122.9 210.43,125.44 222.12,125.44 223.13,124.42 225.17,124.42 226.69,122.9 256.66,122.9 261.23,118.33 261.23,97.5 270.38,97.5 274.95,92.93 CD18.AR2
ST_BLK_MK\  (via drill 0.61)
  Top 0.254: v177.92,135.6 177.41,136.11 v177.41,151.35 | v165.73,163.03 165.73,201.64 164.71,202.65 164.71,216.37 165.73,217.39 165.73,239.74 v166.24,240.25 | v132.2,260.57 132.2,263.61 A09.D2
  Route2 0.254: v146.43,246.34 141.85,241.77 A09.M1
  Route15 0.254: v177.92,135.6 195.7,117.82 C13.F2 | v177.41,151.35 v165.73,163.03 | v146.43,246.34 v132.2,260.57
  Bottom 0.254: v166.24,240.25 146.43,240.25 144.9,241.77 142.36,241.77 A09.M1
ST_CK  (via drill 0.61)
  Top 0.254: D17.M2 262.76,31.97 262.76,26.38 D17.P2 | v202.31,109.18 202.31,111.21 C13.J1 | v255.65,77.18 256.15,76.67 256.15,51.78 255.65,51.27 255.65,33.49 255.14,32.98 255.14,31.97 256.66,30.44 259.2,30.44 259.2,29.43 D17.N2 | v204.85,106.64 206.37,106.64 206.88,107.15 206.88,123.41 206.37,123.91 206.37,124.93 207.39,125.95 207.39,165.06 209.93,167.6 209.93,168.62 209.42,169.13 209.42,178.78 209.93,179.29 209.93,187.92 208.91,188.94 208.91,204.18 209.42,204.69 209.42,206.72 209.93,207.23 209.93,217.39 209.42,217.89 v209.42,236.18
  Route2 0.254: D17.N2 259.71,29.43 262.25,31.97 D17.M2
  Route15 0.254: v204.85,106.64 v202.31,109.18 | v225.67,105.12 237.36,93.43 239.9,93.43 240.41,92.93 240.41,92.42 v255.65,77.18
  Bottom 0.254: CD18.BR1 281.05,23.33 278.51,23.33 277.49,24.35 266.82,24.35 265.3,25.87 262.76,25.87 D17.P2 | v204.85,106.64 224.15,106.64 v225.67,105.12 | 209.42,236.69 165.73,236.69 164.71,235.67 158.62,235.67 A10.P1 | 209.42,236.69 406.52,236.69 407.54,235.67 411.6,235.67 A26.P1 | v209.42,236.18 209.42,236.69
ST_CK\
  Bottom 0.254: C13.K1 205.86,108.17 206.88,107.15 241.42,107.15 244.47,110.2 251.07,110.2 251.07,120.87 247.01,120.87 C16.E2
ST_CK_0P  (via drill 0.61)
  Top 0.254: v191.64,91.4 191.64,103.59 192.65,104.61 192.65,113.25 192.15,113.75 v192.15,122.9 | v183,182.84 183,183.86 B12.H2 | v191.64,174.21 191.64,158.46 192.65,157.44 192.65,138.65 v192.15,138.14
  Route2 0.254: v191.64,91.4 190.11,89.88 C12.S1 | v192.15,122.9 v199.77,130.52
  Route15 0.254: v183,182.84 183,182.33 191.13,174.21 v191.64,174.21 | v199.77,130.52 v192.15,138.14
  Bottom 0.254: v199.77,130.52 201.8,130.52 C13.B1
ST_CK_0P\  (via drill 0.61)
  Top 0.254: v254.63,40.09 255.14,40.6 255.14,51.78 255.65,52.29 255.65,75.65 254.63,76.67 v254.63,79.72
  Route15 0.254: v254.63,40.09 259.2,35.52 D17.L2 | v254.63,79.72 254.12,79.72 240.91,92.93 240.91,93.94 229.23,105.63 229.23,108.17 223.13,114.26 223.13,115.79 221.1,117.82 221.1,118.33 218.56,120.87 217.55,120.87 216.02,122.39 216.02,123.41 215.51,123.91 215.01,123.91 205.35,133.57 C13.A1
ST_DATA  (via drill 0.61)
  Top 0.254: v199.26,112.23 199.26,114.26 C13.H2 199.26,115.28 199.26,115.79 197.73,117.31 197.73,124.93 196.72,125.95 196.72,127.98 195.19,129.5 194.69,129.5 194.69,157.44 195.19,157.95 195.19,159.98 194.18,161 194.18,175.73 194.69,176.24 v194.69,198.08
  Route15 0.254: v194.69,198.08 189.61,203.16 B12.A1
  Bottom 0.254: v199.26,112.23 199.77,112.74 235.33,112.74 236.34,111.72 242.95,111.72 C16.J2
ST_FINAL  (via drill 0.61)
  Top 0.254: v134.23,181.32 v134.23,217.39 134.23,224.5 135.76,226.02 135.76,228.56 A09.S2 | v145.41,171.16 145.92,170.65 145.92,143.73 v145.41,143.22 | v382.14,215.86 v382.14,225.51
  Route2 0.254: v396.36,240.25 396.36,239.74 v382.14,225.51
  Route15 0.254: v180.46,121.88 180.46,121.37 194.69,107.15 196.21,107.15 v198.24,105.12 | v269.87,35.52 254.63,50.76 254.63,51.78 228.72,77.69 227.71,77.69 223.13,82.26 223.13,83.27 218.56,87.85 217.55,87.85 216.53,88.86 216.53,89.88 209.42,96.99 208.91,96.99 203.32,102.58 203.32,103.59 202.31,104.61 C13.L1 | v134.23,181.32 137.79,177.76 137.79,177.25 138.3,176.75 139.82,176.75 v145.41,171.16 | v145.41,143.22 145.92,143.22 155.06,134.07 155.06,133.57 161.67,126.96 v161.67,126.45
  Bottom 0.254: v180.46,121.88 176.91,121.88 175.89,122.9 171.83,122.9 170.81,123.91 C11.D1 170.3,124.42 166.75,124.42 165.22,125.95 162.17,125.95 v161.67,126.45 | v198.24,105.12 201.8,105.12 C13.L1 | v269.87,35.52 276.47,35.52 CD18.BL2 | v396.36,240.25 403.47,240.25 405,238.72 408.05,238.72 A26.N1 | v382.14,215.86 381.63,215.35 378.58,215.35 378.07,214.85 370.45,214.85 369.44,213.83 332.35,213.83 331.34,214.85 324.23,214.85 323.21,215.86 300.35,215.86 299.84,216.37 269.87,216.37 269.36,215.86 237.36,215.86 235.83,217.39 203.32,217.39 202.81,216.88 189.1,216.88 188.59,216.37 178.94,216.37 177.41,217.89 173.86,217.89 173.35,217.39 v134.23,217.39
ST_FINAL\
  Bottom 0.254: C11.M2 167.76,102.58 168.27,103.09 172.33,103.09 172.84,103.59 199.77,103.59 200.78,102.58 204.85,102.58 C13.M1 205.86,102.58 206.88,103.59 225.17,103.59 228.21,100.55 255.65,100.55 255.65,120.87 254.12,122.39 243.96,122.39 243.96,118.33 C16.F2
ST_IDLE  (via drill 0.61)
  Top 0.254: v224.15,77.18 v224.15,84.29 | v407.54,215.35 407.54,227.04 408.55,228.05 408.55,231.61 A26.R1 | v318.13,201.13 318.13,198.08 319.15,197.07 319.15,186.91 318.64,186.4 318.64,153.89 317.62,152.87 317.62,151.85 318.13,151.35 v318.13,94.96
  Route2 0.254: v318.13,201.13 v330.32,213.32 | v318.13,94.96 278.51,55.33 278,55.33 276.98,54.32 CD18.BD2
  Route15 0.254: v200.78,108.67 206.88,102.58 206.88,101.56 v224.15,84.29 | v252.6,76.16 253.11,76.16 272.41,56.86 272.41,56.35 272.92,55.84 274.95,55.84 276.47,54.32 CD18.BD2
  Bottom 0.254: v200.78,108.67 199.26,108.67 C13.K2 | v224.15,77.18 224.66,77.69 250.57,77.69 252.09,76.16 v252.6,76.16 | v407.54,215.35 388.74,215.35 387.73,214.34 379.6,214.34 379.09,213.83 371.47,213.83 370.45,212.81 330.83,212.81 v330.32,213.32
ST_IDLE\  (via drill 0.61)
  Top 0.254: v177.41,122.9 177.41,124.42 176.4,125.44 176.4,134.58 176.91,135.09 176.91,149.82 175.89,150.84 175.89,165.57 176.91,166.59 v176.91,190.97 | v144.39,221.96 v144.39,238.72 | A09.E2 135.76,260.57 135.76,258.03 137.28,256.5 137.28,242.79 138.81,241.26 138.81,239.23 A09.N1
  Route15 0.254: v177.41,122.9 178.43,121.88 178.94,121.88 195.7,105.12 C13.L2 | v176.91,190.97 175.89,191.99 175.38,191.99 149.47,217.89 148.46,217.89 v144.39,221.96
  Bottom 0.254: v144.39,238.72 139.31,238.72 A09.N1
ST_REV_CK  (via drill 0.61)
  Top 0.254: v283.59,1.99 283.59,15.71 284.6,16.73 284.6,19.27 CD18.BS1 | v191.13,39.59 v191.13,1.99 | B11.S1 173.86,158.46 173.86,155.41 172.33,153.89 172.33,136.61 173.86,135.09 173.86,134.07 C11.A1 | v191.64,208.75 192.15,208.24 v192.15,175.73 | v207.39,55.84 207.89,56.35 207.89,89.37 206.37,90.89 206.37,92.93 207.39,93.94 207.39,101.05 206.88,101.56 206.88,103.09 206.37,103.59 206.37,105.63 207.39,106.64 v207.39,124.42
  Route2 0.254: v406.52,244.82 397.89,236.18 397.89,235.17 v369.95,207.23 | v192.15,175.73 191.64,175.73 181.48,165.57 181.48,165.06 180.46,164.05 178.43,164.05 173.86,159.47 B11.S1 | v207.39,55.84 v191.13,39.59
  Route15 0.254: v191.13,39.59 v185.54,45.17 | D12.F2 179.95,47.71 183,44.67 D12.H2 | v180.97,125.95 173.35,133.57 C11.A1
  Bottom 0.254: v283.59,1.99 283.08,1.49 191.64,1.49 v191.13,1.99 | v185.54,45.17 183.51,45.17 D12.H2 | v180.97,125.95 197.73,125.95 199.26,124.42 201.8,124.42 C13.D1 202.81,124.42 v207.39,124.42 | v406.52,244.82 408.05,244.82 A26.L1 | v369.95,207.23 365.37,207.23 363.85,208.75 217.04,208.75 216.53,209.26 192.15,209.26 v191.64,208.75
SWTM  (via drill 0.61)
  Top 0.254: v123.06,151.35 123.06,149.82 B08.V1 | v87.5,160.49 88.01,161 88.01,165.06 B06.P2 | v170.3,208.75 170.3,200.62 B11.B1 | v146.43,119.85 145.92,119.34 145.92,109.18 146.93,108.17 146.93,101.56 147.44,101.05 147.44,100.04 147.95,99.53 C10.N2
  Route2 0.254: v226.69,100.55 v231.26,105.12 | v187.57,95.47 v192.65,100.55 | v123.06,151.35 126.11,154.39 126.61,154.39 143.89,171.67 143.89,172.17 160.14,188.43 160.65,188.43 170.81,198.59 170.81,199.61 B11.B1 | v392.3,209.26 402.46,219.42 A26.V2 | v120.01,146.27 122.55,148.81 B08.V1
  Route15 0.254: v123.06,151.35 113.91,160.49 v113.41,160.49 | v146.43,119.85 v120.01,146.27
  Bottom 0.254: C10.N2 148.46,99.02 149.98,99.02 151.51,97.5 175.89,97.5 177.41,95.97 183,95.97 C12.P2 184.02,95.97 186.05,95.97 186.56,95.47 v187.57,95.47 | v231.26,105.12 233.8,105.12 C15.L1 | v226.69,100.55 212.97,100.55 212.47,100.04 209.93,100.04 209.42,99.53 204.85,99.53 203.83,100.55 v192.65,100.55 | v113.41,160.49 v87.5,160.49 | v392.3,209.26 217.55,209.26 217.04,209.77 188.59,209.77 187.07,208.24 186.05,208.24 185.03,209.26 170.81,209.26 v170.3,208.75
SYNC  (via drill 0.61)
  Top 0.254: v273.43,31.97 v273.43,56.86 | v144.39,78.19 144.39,89.37 143.89,89.88 143.89,187.92 148.46,192.49 148.46,193.51 B10.D2
  Route15 0.254: v273.43,31.97 276.47,28.92 CD18.BN2 | v273.43,56.86 252.6,77.69 v252.09,77.69 | B10.E2 151.51,190.46 148.46,193.51 B10.D2
  Bottom 0.254: v252.09,77.69 251.58,78.19 v144.39,78.19
SYNC-P\
  Top 0.254: B13.A1 205.35,203.16 200.78,203.16 200.78,194.53 198.24,191.99 198.24,178.78 198.75,178.27 B13.K2
  Bottom 0.254: B10.J2 148.97,180.81 149.98,179.79 197.23,179.79 198.75,178.27 B13.K2
T3
  Route2 0.254: C17.S1 268.35,89.37 264.79,89.37 260.22,84.8 257.17,84.8 251.07,78.7 247.52,78.7 228.21,59.4 225.17,59.4 212.47,46.7 210.94,46.7 190.11,25.87 D12.P1
  Bottom 0.254: D12.P1 189.1,26.38 187.07,28.41 186.56,28.41 D12.N1
T_00\
  Top 0.254: A24.V2 370.96,219.93 372.49,221.45 372.49,243.8 375.03,246.34 375.03,249.39 368.42,249.39 368.42,159.47 360.29,151.35 360.29,150.84 359.28,149.82 355.21,149.82 B23.V2
  Bottom 0.254: B22.V2 338.96,148.81 339.47,148.3 353.69,148.3 354.2,148.81 B23.V2
T_01\  (via drill 0.61)
  Top 0.254: v353.18,171.67 352.67,172.17 352.67,220.94 v353.18,221.45 | v373.5,238.21 373.5,241.26 A24.M2
  Route2 0.254: v353.18,221.45 v360.8,229.07 | v373.5,238.21 364.87,229.58 A23.S1
  Bottom 0.254: v353.18,171.67 357.25,171.67 B23.M2 | v360.8,229.07 363.85,229.07 A23.S1
T_02\  (via drill 0.61)
  Top 0.254: v353.69,196.05 353.18,195.54 353.18,173.19 354.2,172.17 354.2,168.62 B23.N2 | v365.88,208.24 366.39,208.75 366.39,238.21 v365.88,238.72 | v358.26,250.41 358.26,253.96 A23.H2
  Route2 0.254: v353.69,196.05 v365.88,208.24
  Route15 0.254: v358.26,250.41 369.95,238.72 A24.N2
  Bottom 0.254: v365.88,238.72 369.95,238.72 A24.N2
T_03\
  Top 0.254: B23.P2 357.25,165.57 356.74,166.08 356.74,218.91 359.28,221.45 359.28,225.51 353.69,231.1 353.69,246.34 354.71,247.36 354.71,250.91 A23.J2
  Route15 0.254: A24.P2 373.5,235.67 370.45,235.67 366.39,239.74 364.36,239.74 356.74,247.36 356.74,249.39 355.21,250.91 A23.J2
T_04\
  Top 0.254: B23.R2 355.21,161.51 356.23,160.49 356.23,151.85 356.74,151.35 359.79,151.35 359.79,205.19 361.31,206.72 361.31,217.39 362.83,218.91 362.83,233.13 357.75,238.21 355.21,238.21 A23.N2
  Route15 0.254: A24.R2 369.95,232.12 363.34,232.12 358.77,236.69 356.74,236.69 355.21,238.21 A23.N2
T_05\
  Top 0.254: B23.S2 358.26,159.47 359.28,160.49 359.28,204.18 357.75,205.7 357.75,218.91 359.79,220.94 359.79,230.59 358.77,231.61 358.77,235.17 A23.P2
  Route15 0.254: A24.S2 373.5,229.58 365.88,229.58 364.87,230.59 360.8,230.59 359.79,231.61 359.79,234.15 358.77,235.17 A23.P2
T_06\
  Top 0.254: B23.T2 354.2,155.92 352.17,157.95 352.17,221.96 352.67,222.47 357.75,222.47 A23.U2
  Route15 0.254: A24.T2 369.95,226.02 363.34,226.02 359.28,221.96 358.77,222.47 A23.U2
T_07\
  Top 0.254: B23.U2 357.25,152.87 356.74,153.38 356.74,165.06 355.72,166.08 355.72,218.4 355.21,218.91 A23.V2
  Bottom 0.254: A23.V2 355.21,218.91 355.72,218.4 366.9,218.4 370.96,222.47 373.5,222.47 A24.U2
T_FWD\
  Route2 0.254: A23.K1 364.87,248.37 364.87,249.9 371.98,257.01 371.98,259.04 373.5,260.57 A24.E2
  Bottom 0.254: B23.H2 357.25,183.86 356.23,182.84 354.2,182.84 353.18,181.83 353.18,179.79 366.39,179.79 385.69,199.1 398.39,199.1 411.6,212.31 413.13,212.31 416.68,215.86 416.68,262.09 375.03,262.09 374.01,261.07 A24.E2
T_GO\  (via drill 0.61)
  Top 0.254: v366.39,204.18 366.9,204.69 366.9,256.5 366.39,257.01 v366.39,264.12
  Route2 0.254: v366.39,204.18 366.39,203.16 357.75,194.53 357.25,194.53 356.23,193.51 355.21,193.51 B23.D2 | v366.39,264.12 v369.44,267.17
  Bottom 0.254: v366.39,264.12 361.82,264.12 A23.D1 | v369.44,267.17 373.5,267.17 A24.C2
T_PWR_CLR\
  Route2 0.254: A24.H2 373.5,253.96 373.5,249.9 369.44,245.83 369.44,243.8 364.87,239.23 364.87,237.71 363.34,236.18 363.34,234.15 361.82,232.63 A23.R1
  Route15 0.254: B23.K2 357.25,178.27 357.25,182.84 356.74,183.35 356.74,210.27 375.53,229.07 374.01,230.59 365.88,230.59 365.37,231.1 362.83,231.1 361.82,232.12 A23.R1
T_REV\
  Route2 0.254: A23.L1 361.82,245.33 361.82,248.37 370.45,257.01 A24.F2
  Bottom 0.254: B23.J2 355.21,181.32 356.23,182.33 359.79,182.33 370.45,193 372.99,193 381.63,201.64 399.92,201.64 411.09,212.81 412.62,212.81 416.17,216.37 416.17,256.5 397.38,256.5 396.36,257.52 394.84,257.52 393.82,256.5 371.47,256.5 370.96,257.01 A24.F2
T_SINGLE_UNIT\
  Top 0.254: B21.T2 323.21,155.41 327.78,155.41 327.78,154.9 334.39,148.3 368.93,148.3 368.93,241.26 373.5,245.83 373.5,247.87 A24.K2
T_STOP\  (via drill 0.61)
  Top 0.254: v357.75,193.51 357.75,190.97 B23.E2 | v367.41,203.16 v367.41,257.52
  Route2 0.254: v357.75,193.51 v367.41,203.16 | v367.91,264.12 364.87,261.07 A23.E1
  Route15 0.254: v367.41,257.52 364.36,260.57 A23.E1
  Bottom 0.254: v367.91,264.12 369.95,264.12 A24.D2
T_TRK  (via drill 0.61)
  Top 0.254: D14.S1 221.1,19.27 221.1,13.68 D14.U1 | v225.67,90.39 225.67,87.34 225.17,86.83 v225.17,23.33 | v225.67,190.46 225.17,189.95 225.17,168.11 224.15,167.09 224.15,153.38 225.17,152.36 225.17,134.58 226.18,133.57 226.18,132.55 225.67,132.04 225.67,114.77 226.18,114.26 226.18,108.17 224.66,106.64 224.66,94.96 v225.17,94.45
  Route2 0.254: v242.95,191.99 243.45,191.99 270.89,219.42 270.89,219.93 v273.93,222.97 | v225.67,90.39 227.71,92.42 C15.R2 | v225.17,23.33 221.61,19.77 D14.S1
  Route15 0.254: v225.17,94.45 227.2,92.42 C15.R2
  Bottom 0.254: v242.95,191.99 235.83,191.99 235.33,191.48 231.77,191.48 231.26,190.97 B15.E2 230.25,190.46 v225.67,190.46 | v273.93,222.97 278,222.97 A18.U2
T_TRK\
  Route2 0.254: B15.E1 237.36,190.97 243.45,190.97 265.3,212.81 268.35,212.81 274.95,219.42 A18.V2
T_WRITE_OK\
  Route15 0.254: A22.H2 342.01,253.96 344.04,251.93 344.04,249.9 353.69,240.25 353.69,237.71 356.23,235.17 356.23,193.51 353.18,190.46 353.18,180.81 354.2,179.79 354.2,175.22 B23.L2 355.21,174.71 356.23,173.7 365.37,182.84 365.37,184.87 364.36,185.89 381.12,202.65 381.12,204.18 397.38,220.43 397.38,223.48 380.61,240.25 379.6,240.25 375.53,244.31 375.53,244.82 375.03,245.33 370.96,245.33 A24.L2
TIM
  Route15 0.254: A25.U1 395.35,222.97 391.28,222.97 390.27,223.99 381.63,223.99 374.52,231.1 373.5,231.1 370.96,233.64 363.34,233.64 350.64,246.34 350.64,247.87 342.51,255.99 254.12,255.99 244.98,265.14 243.96,265.14 237.87,271.23 235.33,271.23 231.77,274.79 228.72,274.79 225.67,277.84 133.22,277.84 116.45,261.07 117.98,259.55 117.98,258.03 120.52,255.49 120.52,247.36 122.55,245.33 A08.L1
TIM\  (via drill 0.61)
  Top 0.254: v64.13,168.62 64.13,185.38 v64.64,185.89
  Route2 0.254: v64.64,185.89 114.93,236.18 115.95,236.18 v121.53,241.77 | v129.66,241.77 132.2,244.31 A09.L2
  Bottom 0.254: v64.13,168.62 59.56,168.62 B04.N1 | v121.53,241.77 125.09,241.77 A08.M1 126.11,241.77 v129.66,241.77
TM_EN
  Top 0.254: A18.R2 274.95,231.61 274.95,229.58 272.92,227.55 272.92,164.55 274.95,162.52 B18.R2 274.95,161.51 270.89,157.44 270.89,112.74 263.77,105.63 263.77,91.4 | 263.77,91.4 263.77,81.75 258.19,76.16 258.19,46.7 260.73,44.16 260.73,27.9 258.19,25.36 258.19,22.31 248.53,12.66 248.53,8.6 210.43,8.6 209.93,9.11 209.93,11.14 197.23,23.84 197.23,98.51 201.8,98.51 C13.N1 | 263.77,91.4 253.61,101.56 C16.M1
  Route2 0.254: C15.S1 237.36,89.88 240.41,89.88 242.95,92.42 C16.R2 243.96,92.93 245.99,92.93 251.07,98.01 251.07,99.53 253.11,101.56 C16.M1
TM_EN\  (via drill 0.61)
  Top 0.254: v183.51,110.71 183.51,108.67 C12.K2 | v209.42,59.4 208.91,59.91 208.91,90.89 v209.42,91.4
  Route2 0.254: v183.51,110.71 v194.69,121.88
  Route15 0.254: D15.K2 230.25,38.57 227.71,41.11 D15.J2 227.2,41.62 v209.42,59.4 | v194.69,121.88 189.61,126.96 C12.C1 | v200.78,95.97 190.62,106.13 190.11,106.13 v187.57,108.67 | v209.42,91.4 205.35,95.47 C13.P1
  Bottom 0.254: v200.78,95.97 204.85,95.97 C13.P1 | v187.57,108.67 184.02,108.67 C12.K2
TP00  (via drill 0.61)
  Top 0.254: A16.M2 247.01,241.26 247.01,235.67 A16.P2 | A15.L1 233.8,244.31 233.8,240.75 232.79,239.74 232.79,218.4 233.8,217.39 233.8,202.15 232.79,201.13 232.79,184.87 233.8,183.86 233.8,181.32 B15.J1 | v240.41,181.32 v240.41,124.42 | B10.N1 154.55,168.62 153.54,169.63 153.54,179.29 152.01,180.81 152.01,183.86 B10.H2 | v127.63,207.23 v127.63,270.22 | v193.67,185.89 v193.67,191.48
  Route2 0.254: A16.M2 243.96,238.72 A16.N2 | v240.41,124.42 237.36,121.37 C15.E1 | v198.24,194.02 201.29,197.07 201.29,198.59 202.31,199.61 B13.B1 | v193.67,191.48 195.7,193.51 B13.D2
  Route15 0.254: B10.H2 151.51,184.37 148.46,187.41 B10.F2 147.95,187.41 146.93,188.43 146.43,188.43 v127.63,207.23
  Bottom 0.254: v240.41,181.32 234.31,181.32 B15.J1 233.8,181.32 229.74,181.32 228.21,182.84 207.39,182.84 206.37,183.86 B13.H1 205.35,184.37 201.8,184.37 200.78,185.38 193.67,185.38 | A16.M2 246.5,241.77 242.44,241.77 239.39,244.82 234.31,244.82 A15.L1 | v198.24,194.02 196.72,194.02 B13.D2 | 193.67,185.38 155.06,185.38 154.05,184.37 152.01,184.37 B10.H2 | v127.63,270.22 123.06,270.22 A08.B1 | 193.67,185.38 v193.67,185.89
TP00\
  Top 0.254: A15.K1 236.85,248.37 234.31,250.91 A15.J1 | A15.H1 236.85,254.47 234.31,257.01 A15.F1 234.31,258.03 236.85,260.57 A15.E1
  Route15 0.254: CD18.AN1 281.05,99.02 279.52,99.02 276.98,101.56 276.98,110.2 290.19,123.41 289.68,123.91 289.68,190.46 277.49,202.65 277.49,206.21 258.69,225.01 258.69,226.53 237.36,247.87 A15.K1
  Bottom 0.254: A15.H1 236.85,253.96 234.82,251.93 234.31,251.93 A15.J1
TP00_A  (via drill 0.61)
  Top 0.254: v156.59,146.77 156.59,179.79 158.11,181.32 158.11,183.86 B10.H1 | v237.87,207.73 238.37,208.24 238.37,224.5 237.36,225.51 237.36,228.56 A15.S1
  Route2 0.254: v180.97,207.73 161.67,188.43 161.67,186.91 161.16,186.4 160.14,186.4 158.11,184.37 B10.H1
  Route15 0.254: v156.59,146.77 175.38,127.98 175.38,127.47 179.95,122.9 180.97,122.9 183,120.87 C12.E2
  Bottom 0.254: v237.87,207.73 237.36,208.24 216.53,208.24 216.02,208.75 193.16,208.75 192.15,207.73 v180.97,207.73
TP00_A\
  Top 0.254: A15.R1 233.8,232.63 233.8,238.21 A15.N1 | A15.P1 236.85,235.67 236.85,241.26 A15.M1
  Bottom 0.254: 233.8,242.28 236.85,242.28 A15.M1 | 233.8,242.28 232.79,242.28 232.79,246.34 242.44,246.34 243.45,245.33 A16.L2 | 233.8,242.28 233.8,239.23 A15.N1
TP0_XTLK_DY\  (via drill 0.61)
  Top 0.254: v164.21,236.69 164.21,232.63 A11.R2
  Route2 0.254: v230.25,237.71 243.45,250.91 A16.J2
  Route15 0.254: A16.K2 246.5,248.37 243.96,250.91 A16.J2
  Bottom 0.254: v164.21,236.69 164.71,237.2 229.74,237.2 v230.25,237.71
TP01  (via drill 0.61)
  Top 0.254: B16.P2 246.5,165.57 246.5,171.16 B16.M2 246.5,172.17 v246.5,174.71 | v233.8,126.96 233.8,130.01 C15.B1 | v281.55,51.78 281.55,48.73 CD18.BF1 | v239.39,130.52 v239.39,92.42 | v241.93,167.09 241.42,166.59 241.42,133.57 v241.93,133.06 | v230.75,232.12 230.75,235.17 A15.P2 | v240.91,221.96 240.41,221.45 240.41,184.87 241.42,183.86 v241.42,179.79
  Route2 0.254: B16.M2 246.5,171.16 243.96,168.62 B16.N2 242.95,168.11 v241.93,167.09 | v166.75,111.72 v172.33,117.31 | v223.64,116.8 v233.8,126.96 | v239.39,130.52 v241.93,133.06
  Route15 0.254: v194.18,240.25 v183,251.42 | v226.18,235.67 v221.61,240.25 | v281.55,51.78 274.95,58.38 272.92,58.38 251.58,79.72 251.58,80.23 v239.39,92.42 | v240.91,221.96 v230.75,232.12 | v246.5,174.71 v241.42,179.79
  Bottom 0.254: v183,251.42 180.46,251.42 A12.J2 | v221.61,240.25 v194.18,240.25 | v226.18,235.67 230.25,235.67 A15.P2 | v166.75,111.72 164.71,111.72 C11.J2 | v172.33,117.31 172.84,116.8 v223.64,116.8 | v239.39,130.52 234.31,130.52 C15.B1
TP01\
  Top 0.254: A15.N2 228.21,239.23 230.25,241.26 A15.M2 230.25,242.28 228.21,244.31 A15.L2 228.21,245.33 228.21,245.83 230.25,247.87 A15.K2 230.25,248.37 230.25,248.88 228.21,250.91 A15.J2
TP01_A
  Route2 0.254: A15.V2 227.71,218.91 226.69,217.89 226.69,216.88 210.43,200.62 210.43,197.57 204.34,191.48 204.34,186.4 194.69,176.75 194.69,175.22 191.64,172.17 191.64,170.14 180.97,159.47 178.94,159.47 177.92,158.46 177.92,156.93 175.89,154.9 175.89,153.89 176.91,152.87 179.45,155.41 B12.T2
  Route15 0.254: C15.M2 230.75,102.58 230.75,103.09 228.72,105.12 228.72,106.13 228.21,106.64 227.2,106.64 223.64,110.2 221.61,110.2 212.47,119.34 209.42,119.34 191.13,137.63 191.13,140.68 184.02,147.79 184.02,149.82 181.99,151.85 181.99,153.89 180.46,155.41 B12.T2
TP01_A\
  Top 0.254: A15.U2 230.25,222.97 228.21,225.01 228.21,225.51 A15.T2 228.21,226.53 230.25,228.56 A15.S2 230.25,229.58 228.21,231.61 A15.R2
  Route15 0.254: B16.L2 243.45,175.22 243.45,176.24 239.39,180.3 239.39,212.31 232.79,218.91 232.79,220.94 231.26,222.47 A15.U2
TP1_XTLK_DY\  (via drill 0.61)
  Top 0.254: v240.41,224.5 239.9,223.99 239.9,183.86 v240.41,183.35
  Route2 0.254: v166.75,219.42 v172.33,225.01 | B16.H2 246.5,183.86 243.96,181.32 B16.J2
  Route15 0.254: v240.41,183.35 242.95,180.81 B16.J2
  Bottom 0.254: v166.75,219.42 164.71,219.42 A11.V2 | v172.33,225.01 172.84,224.5 v240.41,224.5
TS03\  (via drill 0.61)
  Top 0.254: D17.H2 262.76,44.67 262.76,39.08 D17.K2
  Route2 0.254: D17.J2 259.71,42.13 262.25,44.67 D17.H2
  Route15 0.254: v97.15,71.59 85.47,83.27 85.47,83.78 84.96,84.29 84.45,84.29 81.4,87.34 81.4,89.88 77.85,93.43 77.34,93.43 62.61,108.17 C04.K1 | v107.31,71.59 116.45,62.45 116.96,62.45 v120.01,59.4 | v241.42,59.4 259.2,41.62 D17.J2
  Bottom 0.254: v97.15,71.59 97.66,71.08 106.8,71.08 v107.31,71.59 | v120.01,59.4 143.89,59.4 144.9,58.38 149.47,58.38 150.49,59.4 207.39,59.4 208.4,58.38 212.97,58.38 213.99,59.4 222.63,59.4 223.64,58.38 229.23,58.38 230.25,59.4 v241.42,59.4
U+M_DY\  (via drill 0.61)
  Top 0.254: v210.43,56.86 210.43,59.91 209.42,60.92 209.42,89.88 210.43,90.89 v210.43,113.75
  Route15 0.254: v210.43,56.86 210.94,56.86 215.01,52.79 215.01,51.78 D14.E2 | v210.43,113.75 210.43,114.26 208.91,115.79 208.4,115.79 204.34,119.85 204.34,120.36 194.18,130.52 192.65,130.52 189.61,133.57 C12.A1
USR_00  (via drill 0.61)
  Top 0.254: v111.88,192.49 v111.88,207.73 111.88,232.63 113.41,234.15 113.41,246.34 112.9,246.85 112.9,261.58 113.41,262.09 113.41,264.63 112.9,265.14 112.9,273.27 113.91,274.28 113.91,275.3 114.42,275.81 v114.42,282.92
  Route2 0.254: v111.88,192.49 110.36,190.97 B07.E1
  Route15 0.254: v111.88,207.73 100.71,218.91 A07.V2 | v389.25,279.36 395.35,273.27 A25.A1 | v340.99,279.36 336.42,283.93 v336.42,284.44
  Bottom 0.254: v389.25,279.36 381.63,279.36 381.12,279.87 341.5,279.87 v340.99,279.36 | v336.42,284.44 335.91,284.95 331.85,284.95 330.83,285.97 265.81,285.97 264.79,284.95 255.65,284.95 254.63,285.97 212.97,285.97 211.96,284.95 203.83,284.95 203.32,284.44 154.05,284.44 153.03,283.43 148.46,283.43 147.95,282.92 v114.42,282.92
USR_00\  (via drill 0.61)
  Top 0.254: v106.8,189.45 106.8,187.92 B07.F1
  Route2 0.254: v48.38,206.21 48.38,205.19 46.86,203.67 B03.A1
  Route15 0.254: v106.8,189.45 95.12,201.13 94.61,201.13 v89.53,206.21
  Bottom 0.254: v89.53,206.21 80.89,206.21 80.39,205.7 71.24,205.7 70.73,206.21 v48.38,206.21
USR_01
  Top 0.254: B07.H2 103.25,184.87 102.74,185.38 102.74,221.96 103.25,222.47 A07.U2
  Route15 0.254: A25.B1 392.81,269.71 392.81,269.2 394.84,267.17 394.84,266.66 395.85,265.65 396.36,265.65 398.39,267.68 390.77,275.3 389.76,275.3 383.15,281.9 377.06,281.9 376.04,282.92 344.55,282.92 338.45,289.01 194.69,289.01 193.16,290.54 180.46,290.54 178.94,292.06 51.94,292.06 20.44,260.57 30.09,250.91 32.63,250.91 49.4,234.15 49.4,232.63 74.8,207.23 76.32,207.23 83.43,200.11 83.43,199.61 93.59,189.45 94.61,189.45 97.66,186.4 101.21,186.4 103.25,184.37 B07.H2
USR_01\  (via drill 0.61)
  Route15 0.254: v81.4,199.1 96.13,184.37 96.64,184.37 100.2,180.81 B07.J2
  Bottom 0.254: v81.4,199.1 47.37,199.1 46.35,200.11 43.81,200.11 B03.B1
USR_02
  Top 0.254: B07.L1 106.8,175.22 106.29,175.73 106.29,179.29 105.79,179.79 105.79,217.89 106.8,218.91 A07.V1
  Route15 0.254: A25.C1 395.85,267.68 395.85,269.2 392.81,272.25 392.3,272.25 390.77,273.77 390.77,274.28 390.27,274.79 389.25,274.79 382.65,281.39 376.55,281.39 375.53,282.41 344.04,282.41 337.94,288.51 194.18,288.51 192.65,290.03 179.95,290.03 178.43,291.55 135.25,291.55 111.37,267.68 111.37,265.65 97.15,251.42 97.15,231.61 105.28,223.48 105.28,221.45 106.8,219.93 A07.V1
USR_02\  (via drill 0.61)
  Top 0.254: v110.36,175.73 110.36,172.17 B07.M1
  Route15 0.254: v52.95,176.75 52.45,176.75 44.32,184.87 44.32,185.89 43.3,186.91 B03.F1
  Bottom 0.254: v110.36,175.73 109.85,176.24 75.31,176.24 74.8,176.75 59.05,176.75 58.54,176.24 54.99,176.24 54.48,176.75 v52.95,176.75
UTS  (via drill 0.61)
  Top 0.254: v216.02,138.65 216.02,101.05 214.5,99.53 214.5,98.01 211.96,95.47 211.96,92.93 C14.R2 | v237.36,161 237.36,165.06 B15.P1
  Route2 0.254: v216.02,138.65 216.02,139.15 223.13,146.27 223.64,146.27 225.17,147.79 225.17,148.81 v237.36,161 | v400.43,249.9 397.89,247.36 397.89,246.85 389.76,238.72 389.25,238.72 384.17,233.64 384.17,230.59 362.33,208.75 361.82,208.75 v360.29,207.23 | v274.44,206.72 270.89,203.16 270.89,202.15 254.63,185.89 254.63,183.86 246.5,175.73 245.99,175.73 245.49,175.22 245.49,173.7 237.36,165.57 B15.P1
  Route15 0.254: v210.94,207.73 193.67,225.01 193.67,227.55 178.43,242.79 176.4,242.79 165.22,253.96 165.22,255.99 164.71,256.5 163.19,256.5 158.62,261.07 A10.E1
  Bottom 0.254: v400.43,249.9 403.98,249.9 405.51,251.42 408.05,251.42 A26.J1 | v360.29,207.23 359.79,207.73 322.19,207.73 320.67,206.21 315.08,206.21 314.07,207.23 274.95,207.23 v274.44,206.72 272.92,206.72 272.41,206.21 271.39,206.21 270.89,205.7 269.87,205.7 267.33,208.24 239.9,208.24 238.37,206.72 237.36,206.72 236.34,207.73 v210.94,207.73
UTS\  (via drill 0.61)
  Top 0.254: C16.J1 250.06,112.23 250.06,117.31 C16.F1 250.06,118.33 250.06,123.91 C16.D1 250.06,124.93 250.06,130.01 C16.B1 | C16.K1 253.11,108.67 253.11,114.26 C16.H1 253.11,115.28 253.11,117.31 254.12,118.33 254.12,122.39 253.11,123.41 253.11,126.96 C16.C1 253.11,127.98 253.11,133.57 C16.A1 | v230.75,97.5 230.75,95.97 C15.P2
  Route2 0.254: C16.B1 250.06,131.03 252.6,133.57 C16.A1 | v245.49,111.72 237.87,104.1 237.36,104.1 v230.75,97.5
  Route15 0.254: v200.78,104.1 v208.91,95.97
  Bottom 0.254: C15.P2 230.25,95.97 223.64,95.97 222.63,96.99 218.56,96.99 217.55,95.97 215.51,95.97 C14.P2 214.5,95.97 v208.91,95.97 | v200.78,104.1 181.48,104.1 180.97,104.61 C12.L2 | v245.49,111.72 249.55,111.72 C16.J1
VCC
  Top 0.254: CD18.BA2 278,64.48 276.98,65.49 276.98,103.59 279.52,106.13 279.52,133.06 279.01,133.57 CD18.AA2 | AB01.BC1 14.35,197.07 14.35,191.48 AB01.BE1 | AB01.BB1 11.3,200.11 11.3,194.53 AB01.BD1 | AB01.AA2 8.76,273.27 11.3,270.73 AB01.AB1 12.31,269.71 14.35,267.68 AB01.AC1 14.35,266.66 12.31,264.63 AB01.AD1 12.31,263.61 14.35,261.58 14.35,261.07 AB01.AE1 14.35,260.57 12.31,258.53 12.31,258.03 AB01.AF1 12.31,257.01 14.35,254.98 AB01.AH1 14.35,253.96 12.31,251.93 AB01.AJ1 12.31,250.91 12.31,250.41 14.35,248.37 AB01.AK1 14.35,247.87 14.35,247.36 12.31,245.33 AB01.AL1 | A22.A2 342.51,273.27 343.02,272.76 343.02,214.85 342.51,214.34 342.51,203.67 B22.A2 | C16.A2 246.5,134.07 245.49,135.09 245.49,202.15 246.5,203.16 B16.A2
  Route15 0.254: AB01.BC1 15.36,197.57 22.98,205.19 24.51,203.67 B02.A2
  Bottom 0.254: 118.49,65.49 105.28,65.49 104.26,64.48 D07.A2 | 118.49,65.49 119.5,64.48 D08.A2 | 134.23,65.49 135.25,64.48 D09.A2 | 134.23,65.49 118.49,65.49 | 134.23,65.49 149.98,65.49 151,64.48 D10.A2 152.01,64.48 153.03,65.49 165.73,65.49 | 165.73,65.49 166.75,64.48 D11.A2 | 181.99,65.49 183,64.48 D12.A2 | 181.99,65.49 165.73,65.49 | 197.73,65.49 198.75,64.48 D13.A2 | 197.73,65.49 181.99,65.49 | 197.73,65.49 212.97,65.49 213.99,64.48 D14.A2 215.01,63.46 216.02,62.45 229.23,62.45 | 229.23,62.45 230.25,63.46 D15.A2 | 245.49,62.45 246.5,63.46 D16.A2 | 245.49,62.45 229.23,62.45 | 261.23,62.45 262.25,63.46 D17.A2 | 261.23,62.45 245.49,62.45 | 261.23,62.45 276.98,62.45 278,63.46 CD18.BA2 | 261.23,135.09 248.03,135.09 247.01,134.07 C16.A2 246.5,134.07 245.99,134.58 238.88,134.58 238.37,135.09 232.28,135.09 231.26,134.07 C15.A2 230.25,134.07 224.15,134.07 223.13,135.09 216.53,135.09 215.51,134.07 C14.A2 214.5,134.07 213.48,135.09 202.31,135.09 201.29,134.07 199.26,134.07 C13.A2 198.75,134.07 197.73,135.09 185.03,135.09 184.02,134.07 C12.A2 183,134.07 182.49,134.58 175.38,134.58 174.87,135.09 165.73,135.09 | 261.23,135.09 262.25,134.07 C17.A2 | 261.23,135.09 276.98,135.09 278,134.07 CD18.AA2 | 165.73,135.09 153.03,135.09 152.01,134.07 C10.A2 151,133.57 149.98,132.55 140.84,132.55 139.82,133.57 135.76,133.57 C09.A2 135.25,133.57 134.23,132.55 121.03,132.55 120.01,133.57 C08.A2 119.5,134.07 118.49,135.09 102.23,135.09 | 165.73,135.09 166.75,134.07 C11.A2 | C01.A2 8.76,133.57 9.27,133.06 23.49,133.06 24,133.57 C02.A2 25.01,134.07 28.57,134.07 29.59,135.09 42.29,135.09
  Bottom 0.254: 42.29,135.09 41.27,134.07 C03.A2 | 54.99,135.09 42.29,135.09 | 54.99,135.09 56,134.07 C04.A2 | 70.73,135.09 71.75,134.07 C05.A2 | 70.73,135.09 54.99,135.09 | 86.48,135.09 87.5,134.07 C06.A2 | 86.48,135.09 70.73,135.09 | 102.23,135.09 103.25,134.07 C07.A2 | 102.23,135.09 86.48,135.09 | 117.98,272.25 105.28,272.25 104.26,273.27 A07.A2 | 117.98,272.25 118.99,273.27 A08.A2 | 117.98,272.25 134.23,272.25 135.25,273.27 A09.A2 135.76,273.77 136.77,274.79 150.49,274.79 151.51,273.77 A10.A2 152.01,273.27 153.03,272.25 165.73,272.25 166.75,273.27 A11.A2 167.76,273.77 168.78,274.79 181.99,274.79 183,273.77 A12.A2 183.51,273.77 184.53,274.79 216.53,274.79 | 324.73,274.79 311.53,274.79 310.51,273.77 A20.A2 310,273.77 308.99,274.79 276.98,274.79 | 324.73,274.79 325.75,273.77 A21.A2 | 340.48,274.79 341.5,273.77 A22.A2 | 340.48,274.79 324.73,274.79 | 340.48,274.79 356.74,274.79 357.75,273.77 A23.A2 | 216.53,274.79 215.51,273.77 A14.A2 | 229.23,274.79 216.53,274.79 | 229.23,274.79 230.25,273.77 A15.A2 | 245.49,274.79 246.5,273.77 A16.A2 | 245.49,274.79 229.23,274.79 | 276.98,274.79 278,273.77 A18.A2 | 276.98,274.79 245.49,274.79 | 324.73,202.15 311.53,202.15 310.51,203.16 B20.A2 310,203.16 308.99,202.15 277.49,202.15 | 324.73,202.15 325.75,203.16 B21.A2 | 324.73,202.15 340.48,202.15 341.5,203.16 B22.A2 | 213.48,202.15 200.78,202.15 199.77,203.16 B13.A2 198.75,203.16 192.15,203.16 190.62,204.69 181.99,204.69 | 213.48,202.15 214.5,203.16 B14.A2 | 229.23,202.15 230.25,203.16 B15.A2 | 229.23,202.15 213.48,202.15 | 245.49,202.15 246.5,203.16 B16.A2 | 245.49,202.15 229.23,202.15 | 277.49,202.15 278.51,203.16 B18.A2
  Bottom 0.254: 277.49,202.15 245.49,202.15 | AB01.BB1 11.3,201.13 9.27,203.16 8.76,203.16 AB01.BA2 8.76,204.18 8.76,221.45 9.77,221.45 10.28,221.96 10.28,244.31 11.3,244.31 AB01.AL1 | AB01.BD1 12.31,193.51 14.35,191.48 AB01.BE1 | B02.A2 25.01,203.16 26.03,202.15 38.73,202.15 39.75,203.16 B03.A2 40.76,203.16 41.78,202.15 57.53,202.15 | 70.73,202.15 71.75,203.16 B05.A2 | 70.73,202.15 57.53,202.15 | 57.53,202.15 56.51,203.16 B04.A2 | 86.48,202.15 87.5,203.16 B06.A2 | 86.48,202.15 70.73,202.15 | 102.23,202.15 103.25,203.16 B07.A2 | 102.23,202.15 86.48,202.15 | 118.49,202.15 119.5,203.16 B08.A2 | 118.49,202.15 102.23,202.15 | 134.23,202.15 135.25,203.16 B09.A2 | 134.23,202.15 118.49,202.15 | 134.23,202.15 150.49,202.15 151.51,203.16 B10.A2 152.01,203.67 153.03,204.69 165.73,204.69 | 165.73,204.69 166.75,203.67 B11.A2 | 181.99,204.69 183,203.67 B12.A2 | 181.99,204.69 165.73,204.69
W01