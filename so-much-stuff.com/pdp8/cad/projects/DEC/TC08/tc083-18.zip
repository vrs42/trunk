# EAGLE board tc083-18 (EAGLE 4.11), part 3 of 6
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
GND (continued)
  Top 0.254: A04.N1 59.05,237.71 59.05,232.12 A04.R1 59.05,231.61 59.05,226.02 A04.T1 | AB01.AL2 5.71,245.33 8.25,247.87 AB01.AK2 8.25,248.37 8.25,253.96 AB01.AH2 8.76,254.98 9.77,255.99 9.77,265.65 8.76,266.66 AB01.AC2 | A02.F1 27.05,257.01 21.46,257.01 A02.F2 20.95,257.01 20.95,251.93 A02.J2 20.95,250.91 20.95,245.33 A02.L2 20.95,244.31 20.95,239.23 A02.N2 21.46,238.21 27.05,238.21 | 27.05,238.21 A02.N1 27.05,238.21 | A02.T1 27.05,226.53 27.05,231.61 A02.R1 27.05,232.63 27.05,238.21 | A06.C1 94.1,266.66 88.51,266.66 A06.C2 87.5,266.66 79.37,266.66 A05.C1 78.35,267.68 78.35,273.27 A05.A1 | A07.C2 103.25,266.66 94.61,266.66 A06.C1 | A06.A1 94.1,273.27 94.1,267.68 A06.C1 | A10.B2 147.95,269.71 139.82,269.71 139.82,269.2 138.3,267.68 135.76,267.68 A09.C2 | A07.T1 107.31,225.51 109.85,222.97 A07.U1 | A08.T2 116.45,225.51 122.04,225.51 A08.T1 | A06.N1 90.55,238.21 90.55,232.63 A06.R1 90.55,231.61 90.55,226.53 A06.T1 | A06.N2 84.45,239.23 84.45,244.31 A06.L2 84.96,245.33 87.5,247.87 A06.K2 87.5,248.37 84.96,250.91 A06.J2 84.45,251.93 84.45,257.01 A06.F2 84.96,257.01 90.55,257.01 A06.F1 | A05.L1 75.31,244.31 75.31,239.23 A05.N1 | A03.C2 40.76,266.66 46.35,266.66 A03.C1 | A03.A1 46.35,272.76 46.35,267.17 A03.C1 | A02.C2 25.01,266.66 30.6,266.66 A02.C1 30.6,267.68 30.6,273.27 A02.A1 | A05.F2 68.7,257.01 68.7,251.93 A05.J2 68.7,250.91 68.7,245.33 A05.L2 68.7,244.31 68.7,239.23 A05.N2 | A04.C1 62.1,266.66 56.51,266.66 A04.C2 56,266.66 46.86,266.66 A03.C1 | A04.A1 62.1,272.76 62.1,267.17 A04.C1 | A05.D1 75.31,264.63 72.77,267.17 A05.C2 71.75,266.66 69.72,264.63 A05.D2 68.7,264.63 68.7,266.66 63.11,266.66 A04.C1
  Top 0.254: A05.K1 78.35,248.37 78.35,253.96 A05.H1 | B05.T1 74.8,155.41 74.8,149.82 B05.V1 | AB01.BC2 8.25,197.07 8.25,195.54 7.23,194.53 AB01.BD2 7.23,193.51 7.23,189.95 8.25,188.94 8.25,184.87 AB01.BH2 8.25,184.37 8.25,178.78 AB01.BK2 | 79.88,180.81 75.81,180.81 B05.J1 | 79.88,180.81 79.88,166.59 78.86,165.57 B05.P1 77.85,165.06 77.85,164.05 77.34,163.54 77.34,153.38 77.85,152.87 B05.U1 | 70.23,185.89 70.23,173.7 71.75,172.17 B05.M2 | 70.23,185.89 69.21,186.91 B05.F2 | 70.23,185.89 70.23,195.03 71.75,196.56 B05.C2 | 79.88,180.81 79.88,195.54 78.86,196.56 B05.C1 | C16.C2 247.01,127.98 248.53,129.5 248.53,154.39 249.55,155.41 B16.T1 | C14.T1 218.56,86.83 222.63,86.83 222.63,89.88 224.15,91.4 228.72,91.4 228.72,129.5 228.21,130.01 C15.B2
  Bottom 0.254: A26.V1 408.05,219.93 405.51,222.47 A26.U2 405,222.97 403.98,223.99 365.88,223.99 364.87,222.97 A23.U1 364.36,222.47 361.82,219.93 A23.V1 | A23.T2 355.21,225.51 360.8,225.51 A23.T1 | A22.M2 342.51,241.26 343.53,240.25 353.69,240.25 354.71,241.26 357.75,241.26 A23.M2 358.77,241.26 360.8,241.26 361.82,240.25 394.33,240.25 395.35,241.26 A25.M1 | 229.23,265.65 216.53,265.65 215.51,266.66 A14.C2 | 229.23,265.65 230.25,266.66 A15.C2 | 229.23,265.65 245.49,265.65 246.5,266.66 A16.C2 247.52,266.66 248.53,265.65 280.03,265.65 | AB19.AR2 291.71,231.61 293.75,229.58 AB19.AS2 | 280.03,265.65 279.01,266.66 A18.C2 | 292.73,265.65 280.03,265.65 | 292.73,265.65 293.75,266.66 AB19.AC2 | 308.99,265.65 310,266.66 A20.C2 | 308.99,265.65 292.73,265.65 | 324.73,265.65 325.75,266.66 A21.C2 | 324.73,265.65 308.99,265.65 | 340.48,265.65 341.5,266.66 A22.C2 | 340.48,265.65 324.73,265.65 | 340.48,265.65 356.74,265.65 357.75,266.66 A23.C2 | 343.02,198.08 342.51,197.57 B22.C2 | 343.02,198.08 356.74,198.08 357.25,197.57 B23.C2 | 343.02,198.08 326.77,198.08 326.26,197.57 B21.C2 325.75,197.57 318.64,197.57 318.13,198.08 311.02,198.08 310.51,197.57 B20.C2 310,197.57 308.99,198.59 277.49,198.59 | AB19.BM2 294.76,171.67 296.29,170.14 324.23,170.14 338.45,155.92 B22.T2 | 233.29,227.04 219.07,227.04 218.56,226.53 A14.T1 | 233.29,227.04 233.8,226.53 A15.T1 | 233.29,227.04 249.04,227.04 249.55,226.53 A16.T1 | 216.02,198.08 217.04,199.1 226.69,199.1 | 216.02,198.08 215.51,197.57 B14.C2 | 226.69,199.1 227.2,199.61 B15.B2 | 245.49,198.59 244.98,199.1 226.69,199.1 | 245.49,198.59 246.5,197.57 B16.C2 | 277.49,198.59 278.51,197.57 B18.C2
  Bottom 0.254: 245.49,198.59 277.49,198.59 | 216.02,198.08 200.27,198.08 199.77,197.57 B13.C2 198.75,197.07 194.18,197.07 193.16,198.08 184.02,198.08 183.51,197.57 B12.C2 183,197.57 175.38,197.57 174.87,198.08 166.24,198.08 | 105.79,87.34 106.29,86.83 C07.T1 | 105.79,87.34 98.67,87.34 98.17,86.83 91.56,86.83 C06.T1 90.55,86.83 90.04,87.34 76.32,87.34 75.81,86.83 C05.T1 74.8,85.81 73.78,84.8 60.57,84.8 59.56,85.81 C04.T1 59.05,86.83 58.54,87.34 44.83,87.34 44.32,86.83 C03.T1 43.3,86.83 42.79,87.34 28.57,87.34 28.06,86.83 C02.T1 27.05,86.83 22.98,86.83 22.47,87.34 19.93,87.34 18.92,86.32 12.31,86.32 C01.T1 | 105.79,87.34 122.04,87.34 122.55,86.83 C08.T1 123.06,86.83 130.68,86.83 131.19,87.34 139.82,87.34 | 139.82,87.34 139.31,86.83 C09.T1 | 139.82,87.34 153.54,87.34 | 153.54,87.34 154.05,86.83 C10.T1 | 153.54,87.34 169.79,87.34 170.3,86.83 C11.T1 170.81,86.83 171.32,87.34 182.49,87.34 183,86.83 186.05,86.83 C12.T1 187.07,86.83 187.57,87.34 201.29,87.34 | 201.29,87.34 201.8,86.83 C13.T1 | 201.29,87.34 217.04,87.34 217.55,86.83 C14.T1 218.56,86.83 226.18,86.83 226.69,87.34 234.82,87.34 | 234.82,87.34 234.31,86.83 C15.T1 | 234.82,87.34 249.04,87.34 | 249.04,87.34 249.55,86.83 C16.T1 | 249.04,87.34 264.79,87.34 265.3,86.83 C17.T1 266.31,85.81 267.33,84.8 280.03,84.8 281.05,85.81 CD18.AT1 | 107.82,15.2 109.34,13.68 109.85,13.68 D07.U1 | 107.82,15.2 107.31,15.71 D07.T1 106.8,15.71 106.29,15.2 92.07,15.2 91.56,15.71 D06.T1 | 122.04,15.2 122.55,15.71 D08.T1 | 107.82,15.2 122.04,15.2 | 122.04,15.2 137.79,15.2 138.3,15.71 D09.T1 139.31,15.71 139.82,15.2 153.54,15.2 154.05,15.71 D10.T1 155.06,15.71 163.7,15.71 D11.T2
  Bottom 0.254: 173.35,20.79 173.35,25.36 D11.P1 | 173.35,20.79 172.33,20.79 172.33,16.73 170.81,16.73 D11.T1 | 185.03,17.74 184.53,18.25 178.94,18.25 176.4,20.79 173.35,20.79 | 185.03,17.74 186.05,16.73 D12.T1 | 200.78,17.74 201.8,16.73 D13.T1 | 185.03,17.74 200.78,17.74 | 216.53,17.74 217.55,16.73 D14.T1 | 200.78,17.74 216.53,17.74 | 232.79,17.74 233.8,16.73 D15.T1 | 216.53,17.74 232.79,17.74 | 248.53,17.74 249.55,16.73 D16.T1 | 232.79,17.74 248.53,17.74 | 264.28,17.74 265.3,16.73 D17.T1 | 248.53,17.74 264.28,17.74 | 264.28,17.74 280.03,17.74 281.05,16.73 CD18.BT1 | 149.98,56.35 136.77,56.35 135.76,57.37 D09.C2 135.25,57.87 134.23,58.89 121.03,58.89 120.01,57.87 D08.C2 119.5,57.37 118.49,56.35 105.28,56.35 104.26,57.37 D07.C2 103.25,57.37 94.61,57.37 D06.C1 94.1,57.37 88.51,57.37 D06.C2 87.5,57.37 79.37,57.37 D05.C1 | 149.98,56.35 151,57.37 D10.C2 | 165.73,56.35 166.75,57.37 D11.C2 | 165.73,56.35 149.98,56.35 | 181.99,56.35 183,57.37 D12.C2 | 181.99,56.35 165.73,56.35 | 181.99,56.35 197.73,56.35 198.75,57.37 D13.C2 199.26,57.87 200.27,58.89 206.88,58.89 207.89,57.87 213.99,57.87 D14.C2 215.01,57.37 216.02,56.35 229.23,56.35 | 229.23,56.35 230.25,57.37 D15.C2 | 245.49,56.35 246.5,57.37 D16.C2 | 229.23,56.35 245.49,56.35 | 245.49,56.35 261.23,56.35 262.25,57.37 D17.C2 262.76,57.87 263.77,58.89 276.98,58.89 278,57.87 CD18.BC2 | D03.K1 46.86,38.06 48.89,36.03 52.45,36.03 D04.L2 | D04.F1 58.54,47.71 52.95,47.71 D04.F2 | D02.F1 27.05,47.71 21.46,47.71 D02.F2 | D02.R2 21.46,22.31 27.05,22.31 D02.R1 28.06,22.31 36.7,22.31 D03.R2 37.71,22.31 43.3,22.31 D03.R1 43.81,22.31 52.45,22.31 D04.R2 52.95,22.31 58.54,22.31 D04.R1 59.56,22.31 68.7,22.31 D05.R2 69.72,22.31 75.31,22.31 D05.R1
  Bottom 0.254: D03.U2 40.76,13.68 42.79,15.71 43.3,15.71 D03.T1 | D02.K1 31.11,39.08 33.65,41.62 36.7,41.62 D03.J2 | D03.F1 43.3,47.71 37.71,47.71 D03.F2 | D06.R1 90.55,22.31 84.96,22.31 D06.R2 84.45,23.33 82.42,25.36 79.37,25.36 D05.P1 78.35,26.38 77.85,26.38 75.81,28.41 D05.N1 | D06.L2 84.96,36.03 86.99,38.06 87.5,38.06 D06.K2 | D06.J2 84.96,41.11 86.99,39.08 87.5,39.08 D06.K2 | D06.F1 90.55,47.71 84.96,47.71 D06.F2 | D06.K1 94.1,38.06 88.51,38.06 D06.K2 | D05.L1 75.81,36.03 77.85,38.06 78.35,38.06 D05.K1 78.35,39.08 77.85,39.08 75.81,41.11 D05.J1 | D04.K1 62.61,38.06 64.64,36.03 68.7,36.03 D05.L2 | D05.U2 72.77,13.68 74.8,15.71 75.31,15.71 D05.T1 | D02.C2 25.01,57.37 30.6,57.37 D02.C1 31.11,57.37 39.75,57.37 D03.C2 40.76,57.37 46.35,57.37 D03.C1 46.86,57.37 55.49,57.37 D04.C2 56.51,57.37 61.59,57.37 D04.C1 62.61,57.37 65.15,54.83 68.7,54.83 D05.D2 69.21,54.83 71.75,57.37 D05.C2 72.77,57.87 75.31,60.41 D05.B1 75.81,61.43 77.85,63.46 78.35,63.46 D05.A1 | D05.F1 75.81,48.73 77.85,50.76 78.35,50.76 D05.E1 78.35,51.78 77.85,51.78 75.81,53.81 D05.D1 | 26.03,128.99 25.01,127.98 C02.C2 | 39.24,128.99 26.03,128.99 | 39.24,128.99 40.25,127.98 C03.C2 | 26.03,128.99 25.52,128.99 22.47,132.04 8.76,132.04 8.76,127.98 C01.C2 | 54.99,128.99 56,127.98 C04.C2 | 54.99,128.99 39.24,128.99 | 54.99,128.99 70.73,128.99 71.75,127.98 C05.C2 72.26,127.98 73.27,128.99 79.88,128.99 81.4,127.47 87.5,127.47 C06.C2 88.51,127.98 89.53,128.99 102.23,128.99 | 102.23,128.99 103.25,127.98 C07.C2 | 102.23,128.99 118.49,128.99 119.5,127.98 C08.C2 120.01,127.98 121.03,128.99 134.23,128.99
  Bottom 0.254: 134.23,128.99 135.25,127.98 C09.C2 | 149.98,128.99 151,127.98 C10.C2 | 149.98,128.99 134.23,128.99 | 163.19,129.5 162.68,128.99 149.98,128.99 | 163.19,129.5 163.7,130.01 C11.B2 | 183,129.5 183,127.98 C12.C2 | 183,129.5 163.19,129.5 | 197.23,129.5 198.75,127.98 C13.C2 | 197.23,129.5 183,129.5 | 213.48,128.99 212.97,129.5 197.23,129.5 | 213.48,128.99 214.5,127.98 C14.C2 | 226.69,129.5 226.18,128.99 213.48,128.99 | 226.69,129.5 227.2,130.01 C15.B2 | 245.49,128.99 244.98,129.5 226.69,129.5 | 245.49,128.99 246.5,127.98 C16.C2 | 261.23,128.99 262.25,127.98 C17.C2 | 245.49,128.99 261.23,128.99 | 261.23,128.99 276.98,128.99 278,127.98 CD18.AC2 | A02.K1 31.11,248.37 33.14,250.41 36.7,250.41 A03.J2 | A03.F2 37.71,257.52 43.3,257.52 A03.F1 43.81,257.01 52.45,257.01 A04.F2 53.46,257.01 59.05,257.01 A04.F1 59.56,257.01 68.7,257.01 A05.F2 | A03.U2 40.76,222.97 42.79,225.01 43.3,225.01 A03.T1 | A03.R2 37.71,231.61 43.3,231.61 A03.R1 | A03.K1 46.86,248.37 48.89,250.41 52.45,250.41 A04.J2 | A04.U2 56.51,222.97 58.54,225.01 59.05,225.01 A04.T1 | A04.R2 53.46,231.61 59.05,231.61 A04.R1 | A02.R2 21.46,231.61 27.05,231.61 A02.R1 | 26.03,223.99 27.55,225.51 A02.T1 | 26.03,223.99 25.01,222.97 A02.U2 | 17.9,223.99 26.03,223.99 | 17.9,223.99 13.84,223.99 12.31,225.51 AB01.AT1 | AB01.AH2 8.76,253.96 10.28,252.44 20.44,252.44 20.95,251.93 A02.J2 | A03.N2 36.7,238.21 28.06,238.21 A02.N1 | 117.98,268.69 118.99,267.68 A08.C2 | 117.98,268.69 105.28,268.69 104.26,267.68 A07.C2 | 134.23,268.69 135.25,267.68 A09.C2 | 117.98,268.69 134.23,268.69 | 134.23,268.69 158.62,268.69 160.14,267.17 166.75,267.17 A11.C2 | A12.B2 179.45,270.73 178.43,271.74 152.01,271.74 151,270.73 148.97,270.73 A10.B2
  Bottom 0.254: 137.79,227.04 138.3,226.53 A09.T1 | 137.79,227.04 123.57,227.04 123.06,226.53 A08.T1 | 154.05,227.04 154.55,226.53 A10.T1 | 137.79,227.04 154.05,227.04 | 169.79,227.04 170.3,226.53 A11.T1 | 154.05,227.04 169.79,227.04 | 169.79,227.04 180.97,227.04 181.48,226.53 186.05,226.53 A12.T1 | A08.T2 115.95,225.51 112.9,225.51 110.36,222.97 A07.U1 109.85,222.97 108.83,223.99 89.53,223.99 | 89.53,223.99 91.05,225.51 A06.T1 | 89.53,223.99 88.51,222.97 A06.U2 | A06.R1 90.55,231.61 84.96,231.61 A06.R2 84.45,231.61 82.42,229.58 79.37,229.58 A05.S1 | A06.K1 94.1,247.87 88.51,247.87 A06.K2 | A06.N1 90.55,238.21 84.96,238.21 A06.N2 | A05.M1 78.35,242.28 77.85,242.28 75.81,244.31 A05.L1 75.81,245.33 78.35,247.87 A05.K1 | A05.N1 75.81,238.21 78.35,235.67 A05.P1 78.35,235.17 75.81,232.63 A05.R1 | A05.R2 69.72,231.61 75.31,231.61 A05.R1 | A05.U2 72.77,222.97 75.31,225.51 A05.T1 75.81,226.53 76.32,226.53 78.35,228.56 A05.S1 | A05.R1 75.81,231.61 77.85,229.58 78.35,229.58 A05.S1 | A03.C2 39.75,266.66 31.11,266.66 A02.C1 | A04.K1 63.11,247.36 65.15,245.33 68.7,245.33 A05.L2 | A05.D1 75.81,263.61 78.35,261.07 A05.E1 78.35,260.57 75.81,258.03 A05.F1 75.81,257.01 77.85,254.98 78.35,254.98 A05.H1 78.35,253.96 77.85,253.96 75.81,251.93 A05.J1 75.31,250.91 69.72,250.91 A05.J2 | A05.C2 72.77,267.68 73.27,267.68 75.31,269.71 A05.B1 75.81,269.71 76.32,269.71 78.35,267.68 A05.C1 | 156.59,156.93 155.57,155.92 B10.T1 | 169.29,156.93 156.59,156.93 | 169.29,156.93 170.3,155.92 B11.T1 | 185.03,156.93 186.05,155.92 B12.T1 | 185.03,156.93 169.29,156.93 | 185.03,156.93 201.29,156.93 202.31,155.92 B13.T1 202.81,155.92 204.34,155.92 205.35,156.93 216.53,156.93 217.55,155.92 B14.T1 218.56,155.41 219.58,154.39 232.79,154.39
  Bottom 0.254: 232.79,154.39 233.8,155.41 B15.T1 | 232.79,154.39 248.53,154.39 249.55,155.41 B16.T1 | 156.59,156.93 140.33,156.93 139.31,155.92 B09.T1 138.3,155.41 137.28,154.39 124.07,154.39 123.06,155.41 B08.T1 122.55,155.41 121.53,154.39 115.44,154.39 113.91,155.92 107.31,155.92 B07.T1 106.8,155.41 105.79,154.39 89.53,154.39 | B03.V1 43.81,149.82 46.35,152.36 B03.U1 | B03.U1 46.35,152.87 43.81,155.41 B03.T1 43.3,155.41 41.78,153.89 30.09,153.89 | B02.V1 28.06,150.33 30.09,152.36 30.6,152.36 B02.U1 30.6,153.38 30.09,153.89 | AB01.BT1 12.31,155.41 12.82,154.9 22.98,154.9 24,155.92 27.05,155.92 B02.T1 28.06,155.41 28.57,155.41 30.09,153.89 | B04.V1 59.56,150.33 61.59,152.36 62.1,152.36 B04.U1 | 60.07,154.9 61.59,153.38 62.1,153.38 B04.U1 | 60.07,154.9 59.56,155.41 B04.T1 | 76.83,150.84 78.35,152.36 B05.U1 | 76.83,150.84 75.81,149.82 B05.V1 | 89.53,154.39 90.55,155.41 B06.T1 | 89.53,154.39 76.83,154.39 75.81,155.41 B05.T1 | 76.83,150.84 64.64,150.84 63.11,152.36 B04.U1 | 60.07,154.9 48.89,154.9 46.86,152.87 B03.U1 | AB01.BL2 6.73,175.73 3.17,175.73 2.66,176.24 2.66,178.78 8.25,178.78 AB01.BK2 | 17.9,198.59 19.93,198.59 20.95,197.57 24,197.57 B02.C2 25.01,197.57 26.03,198.59 38.73,198.59 39.75,197.57 B03.C2 40.76,197.57 41.27,198.08 55.49,198.08 56,197.57 B04.C2 56.51,197.07 57.53,196.05 71.24,196.05 71.75,196.56 B05.C2 72.26,196.56 77.85,196.56 B05.C1 78.86,196.56 87.5,196.56 B06.C2 88.51,197.57 90.04,199.1 105.79,199.1 | 17.9,198.59 9.77,198.59 8.76,197.57 AB01.BC2 | 105.79,199.1 104.26,197.57 B07.C2 | 105.79,199.1 115.44,199.1 | 115.44,199.1 115.95,199.61 B08.B2
  Bottom 0.254: 134.74,198.08 133.73,199.1 115.44,199.1 | 134.74,198.08 135.25,197.57 B09.C2 | 151,198.08 151.51,197.57 B10.C2 | 134.74,198.08 151,198.08 | 166.24,198.08 166.75,197.57 B11.C2 | 151,198.08 166.24,198.08 | 17.9,198.59 17.9,223.99
I/O_0_TO_AC\  (via drill 0.61)
  Top 0.254: v58.03,25.87 57.53,26.38 57.53,65.49 56.51,66.51 56.51,80.73 58.03,82.26 58.03,118.83 v59.05,119.85 | v71.24,131.53 69.72,133.06 69.72,146.77 70.73,147.79 70.73,168.11 v71.24,168.62 | v67.69,228.05 67.18,227.55 67.18,199.61 67.69,199.1 68.19,199.1 68.7,198.59 68.7,197.57 67.18,196.05 67.18,194.02 66.67,193.51 66.67,184.37 67.69,183.35 v67.69,178.78
  Route2 0.254: v59.05,119.85 65.15,125.95 66.16,125.95 71.24,131.03 v71.24,131.53 | v71.24,168.62 75.31,172.68 75.31,174.21 B05.L1
  Route15 0.254: v67.69,228.05 v60.57,235.17 | v67.69,178.78 71.75,174.71 v72.26,174.71
  Bottom 0.254: v58.03,25.87 56.51,25.87 D04.P2 | v60.57,235.17 56.51,235.17 A04.P2 | v72.26,174.71 74.8,174.71 B05.L1
I/O_1_TO_CA_INH\  (via drill 0.61)
  Top 0.254: v81.4,32.47 81.4,40.09 81.91,40.6 81.91,43.65 82.42,44.16 82.42,82.77 v81.91,83.27 | v61.08,105.12 61.08,109.69 64.64,113.25 64.64,148.81 61.08,152.36 61.08,160.49 v61.59,161 | v81.91,241.77 81.91,222.47 82.42,221.96 82.42,185.38 v81.4,184.37 | v68.7,172.68 68.7,168.62 B05.N2
  Route2 0.254: v61.59,161 68.7,168.11 B05.N2 | v81.4,184.37 72.77,175.73 71.75,175.73 v68.7,172.68
  Route15 0.254: v81.91,83.27 64.13,101.05 64.13,102.07 v61.08,105.12
  Bottom 0.254: v81.4,32.47 87.5,32.47 D06.M2 | v81.91,241.77 87.5,241.77 A06.M2
I/O_ADDR_ACC\
  Top 0.254: A05.S2 72.77,228.56 73.78,227.55 73.78,20.79 72.77,19.77 D05.S2
  Route15 0.254: C02.U2 25.01,82.77 26.54,82.77 29.08,80.23 29.08,76.16 38.22,67.02 39.24,67.02 47.87,58.38 47.87,44.16 57.02,35.01 57.02,32.98 68.7,21.3 70.23,21.3 71.75,19.77 D05.S2
I/O_B-BRK
  Top 0.254: A05.P2 72.77,235.67 73.78,236.69 73.78,255.49 63.62,265.65 33.65,265.65 33.65,273.27 32.13,274.79 16.38,274.79 16.38,246.34 7.23,237.2 7.23,201.13 10.28,198.08 10.28,147.79 12.82,145.25 12.82,125.44 12.31,124.93 C01.D1
  Route15 0.254: D05.P2 72.26,26.38 72.26,30.44 71.24,31.46 71.24,56.86 67.69,60.41 67.69,63.46 51.94,79.21 51.94,81.24 37.71,95.47 37.71,96.48 36.19,98.01 36.19,100.04 17.39,118.83 15.87,118.83 13.84,120.87 13.84,122.9 12.31,124.42 C01.D1
I/O_B-RUN
  Top 0.254: D04.S2 56.51,19.77 57.02,20.28 57.02,64.99 54.99,67.02 54.99,155.41 57.53,157.95 57.53,227.55 56.51,228.56 A04.S2
  Route2 0.254: C01.A1 14.35,134.07 12.82,134.07 5.2,126.45 4.19,126.45 1.65,128.99 1.65,191.48 4.69,194.53 4.69,196.05 2.15,198.59 3.17,199.61 3.17,203.67 1.65,205.19 1.65,213.83 16.38,228.56 16.38,231.61 35.68,250.91 35.68,251.42 39.75,255.49 59.56,255.49 61.08,253.96 61.08,244.82 64.64,241.26 59.56,236.18 59.56,234.15 58.03,232.63 58.03,230.59 56.51,229.07 A04.S2
I/O_BAC_00  (via drill 0.61)
  Top 0.254: v28.06,78.19 28.06,61.43 D02.B1 | v32.63,235.67 v32.63,271.23 | v13.33,216.37 12.82,216.37 12.82,202.65 13.33,202.15 13.33,165.06 v14.35,164.05
  Route2 0.254: v28.06,78.19 35.17,85.31 35.17,87.85 42.29,94.96 42.29,99.53 52.95,110.2 53.46,110.2 61.08,117.82 v61.08,119.34 | v32.63,235.67 32.63,235.17 13.84,216.37 v13.33,216.37
  Route15 0.254: v61.08,119.34 46.86,133.57 C03.A1 46.35,133.57 43.3,136.61 43.3,137.12 25.52,154.9 25.52,155.41 22.98,157.95 20.95,157.95 14.85,164.05 v14.35,164.05
  Bottom 0.254: v32.63,271.23 32.13,270.73 28.06,270.73 A02.B1
I/O_BAC_01
  Top 0.254: D02.D1 28.06,54.83 29.08,55.84 29.08,217.89 29.59,218.4 29.59,262.09 28.06,263.61 A02.D1
  Route2 0.254: C03.D1 43.81,124.93 43.81,126.96 58.54,141.69 58.54,146.77 63.62,151.85 63.62,152.87 67.69,156.93 67.69,158.97 83.43,174.71 83.43,175.22 98.17,189.95 100.71,189.95 143.38,232.63 143.89,232.63 144.39,233.13 144.39,237.2 145.41,238.21 145.41,239.23 147.44,241.26 147.44,251.42 142.87,255.99 153.03,266.15 153.03,284.95 145.92,292.06 61.08,292.06 37.71,268.69 34.16,268.69 31.11,265.65 29.59,265.65 28.06,264.12 A02.D1
I/O_BAC_02  (via drill 0.61)
  Top 0.254: v30.6,54.32 30.6,51.78 D02.E1 | v18.92,76.16 18.41,76.67 18.41,90.89 18.92,91.4 v18.92,98.51 | v33.65,257.52 33.14,257.01 33.14,236.69 33.65,236.18 v33.65,233.64 | v16.89,216.88 16.89,182.84 15.87,181.83 15.87,179.29 16.38,178.78 16.38,177.25 15.36,176.24 15.36,175.22 16.89,173.7 16.89,154.39 16.38,153.89 v16.38,146.27
  Route2 0.254: v18.92,76.16 v13.84,71.08 | v18.92,98.51 35.68,115.28 39.24,115.28 42.29,118.33 43.3,118.33 C03.F1 | v33.65,233.64 33.14,233.64 16.89,217.39 v16.89,216.88
  Route15 0.254: v13.84,71.08 v30.6,54.32 | v33.65,257.52 30.6,260.57 A02.E1 | v16.38,146.27 16.89,146.27 29.59,133.57 29.59,133.06 30.09,132.55 32.13,132.55 44.32,120.36 44.32,118.33 C03.F1
I/O_BAC_03  (via drill 0.61)
  Top 0.254: v30.6,48.73 30.6,45.17 D02.H1 | v47.87,93.94 48.38,94.45 48.38,111.21 v47.87,111.72 | v30.6,251.93 30.6,253.96 A02.H1 | v17.9,239.23 17.9,216.37 17.39,215.86 17.39,189.95 18.92,188.43 18.92,187.41 18.41,186.91 18.41,171.16 v18.92,170.65 | v15.87,167.6 16.38,167.09 16.38,156.43 13.84,153.89 13.84,82.26 16.89,79.21 v16.89,62.45
  Route2 0.254: v16.89,62.45 16.89,62.95 v47.87,93.94 | v17.9,239.23 v30.6,251.93 | v18.92,170.65 v15.87,167.6
  Route15 0.254: v16.89,62.45 v30.6,48.73
  Bottom 0.254: v47.87,111.72 44.32,111.72 C03.J1
I/O_BAC_04  (via drill 0.61)
  Top 0.254: 17.39,57.37 v17.39,54.32 | 17.39,57.37 18.41,58.38 18.41,72.1 17.39,73.11 17.39,83.27 v16.89,83.78 | v27.55,247.36 27.55,250.91 A02.J1 | v18.92,238.21 18.41,237.71 18.41,215.86 17.9,215.35 17.9,190.97 v18.41,190.46 | v5.71,177.76 5.71,169.63 4.19,168.11 4.19,144.74 6.22,142.71 6.22,132.55 7.23,131.53 7.23,118.83 13.33,112.74 13.33,81.75 16.38,78.7 16.38,63.46 15.87,62.95 15.87,59.91 17.39,58.38 17.39,57.37
  Route2 0.254: v16.89,83.78 30.6,97.5 32.13,97.5 v40.25,105.63 | v27.55,247.36 27.05,247.36 18.92,239.23 v18.92,238.21 | v18.41,190.46 v5.71,177.76
  Route15 0.254: v17.39,54.32 28.06,43.65 28.06,42.13 D02.J1
  Bottom 0.254: v40.25,105.63 40.76,105.12 43.3,105.12 C03.L1
I/O_BAC_05  (via drill 0.61)
  Top 0.254: A02.L1 27.55,244.31 27.55,242.28 29.08,240.75 29.08,218.91 27.55,217.39 27.55,202.65 26.54,201.64 26.54,147.79 27.55,146.77 27.55,133.06 26.54,132.04 v26.54,97.5 26.54,78.19 27.55,77.18 27.55,62.95 26.54,61.94 26.54,39.08 27.55,38.06 27.55,36.03 D02.L1
  Bottom 0.254: v26.54,97.5 39.24,97.5 40.76,99.02 43.3,99.02 C03.N1
I/O_BAC_06  (via drill 0.61)
  Top 0.254: v39.24,21.3 39.24,21.81 38.73,22.31 v38.73,66 | v47.87,75.15 48.38,75.65 48.38,91.91 v47.87,92.42 | v48.38,224.5 48.89,223.99 48.89,215.86 v48.38,215.35
  Route2 0.254: v47.87,75.15 v38.73,66 | v113.41,152.87 103.75,143.22 101.21,143.22 79.88,121.88 79.88,120.36 75.31,115.79 74.29,115.79 73.78,115.28 73.78,114.26 67.18,107.66 66.16,107.66 53.46,94.96 v53.46,94.45
  Route15 0.254: v39.24,21.3 39.24,22.31 34.67,26.89 34.67,27.9 30.6,31.97 D02.M1 | v48.38,224.5 47.37,224.5 43.3,228.56 43.3,229.07 35.17,237.2 34.67,237.2 30.6,241.26 A02.M1 | v48.38,215.35 54.48,209.26 54.99,209.26 68.7,195.54 69.21,195.54 76.32,188.43 76.32,187.92 78.35,185.89 78.86,185.89 80.39,184.37 80.39,183.35 90.04,173.7 91.56,173.7 92.07,173.19 92.07,171.67 96.13,167.6 98.17,167.6 105.79,159.98 106.29,159.98 v113.41,152.87
  Bottom 0.254: C03.R1 44.32,92.42 v47.87,92.42 49.91,94.45 v53.46,94.45
I/O_BAC_07
  Top 0.254: A02.P1 31.11,235.17 32.63,233.64 32.63,27.9 31.11,26.38 D02.P1
  Route2 0.254: D02.P1 30.6,26.38 28.06,26.38 18.41,36.03 18.41,43.14 19.93,44.67 19.93,50.25 25.52,55.84 25.52,56.86 29.08,60.41 29.08,63.46 29.59,63.97 29.59,64.99 43.81,79.21 C03.V1
I/O_BAC_08
  Top 0.254: D02.S1 30.6,19.77 29.59,20.79 29.59,162.01 32.13,164.55 32.13,207.23 30.6,208.75 30.6,219.93 32.13,221.45 32.13,227.55 31.11,228.56 A02.S1
  Route2 0.254: C03.E2 40.25,120.87 38.22,120.87 36.19,118.83 36.19,117.82 22.47,104.1 18.92,104.1 15.87,101.05 14.35,101.05 2.15,113.25 6.73,117.82 6.73,123.91 16.38,133.57 16.38,137.63 19.43,140.68 19.43,145.76 22.47,148.81 22.47,150.84 20.95,152.36 10.79,142.2 10.79,141.69 10.28,141.19 9.27,141.19 2.15,148.3 2.15,181.32 3.68,182.84 3.68,192.49 5.2,194.02 5.2,195.54 6.22,196.56 6.22,199.1 9.77,202.65 9.77,205.7 29.08,225.01 29.08,227.04 30.6,228.56 A02.S1
I/O_BAC_09  (via drill 0.61)
  Top 0.254: v18.41,56.86 18.92,57.37 18.92,72.61 17.9,73.62 v17.9,91.91 | v2.15,244.82 1.65,244.31 1.65,200.62 v2.15,200.11 | v5.2,197.07 5.2,194.02 4.69,193.51 4.69,180.3 7.23,177.76 7.23,177.25 8.25,176.24 8.25,173.7 7.74,173.19 7.23,173.19 7.23,170.65 7.74,170.14 8.25,170.14 8.25,167.6 4.69,164.05 4.69,149.31 v5.2,148.81
  Route2 0.254: v17.9,91.91 33.14,107.15 33.14,109.18 v38.22,114.26 | v2.15,244.82 20.95,263.61 A02.D2
  Route15 0.254: v18.41,56.86 20.95,54.32 D02.D2 | v2.15,200.11 v5.2,197.07 | v5.2,148.81 30.09,123.91 30.6,123.91 33.14,121.37 33.14,119.34 v38.22,114.26
  Bottom 0.254: v38.22,114.26 38.73,114.77 40.25,114.77 C03.H2
I/O_BAC_10  (via drill 0.61)
  Top 0.254: v24.51,53.3 24.51,51.78 D02.E2 | v39.24,68.03 39.75,68.54 39.75,80.23 38.73,81.24 38.73,108.17 v38.22,108.67 | v99.18,188.94 99.18,185.89 98.67,185.38 98.67,173.7 99.18,173.19 v99.18,158.97
  Route2 0.254: v39.24,68.03 v24.51,53.3 | v99.18,158.97 98.67,158.97 75.81,136.11 72.77,136.11 72.26,135.6 71.75,135.6 64.13,127.98 64.13,126.45 47.87,110.2 46.35,110.2 v44.32,108.17
  Route15 0.254: v26.03,261.07 34.67,252.44 34.67,251.42 49.4,236.69 50.41,236.69 68.19,218.91 68.19,218.4 80.39,206.21 81.91,206.21 v99.18,188.94
  Bottom 0.254: v38.22,108.67 40.25,108.67 C03.K2 41.27,108.67 43.81,108.67 v44.32,108.17 | v26.03,261.07 25.01,261.07 A02.E2
I/O_BAC_11  (via drill 0.61)
  Top 0.254: v18.92,45.17 19.43,45.68 19.43,73.62 v18.92,74.13 | v40.76,97.5 40.76,101.56 C03.M2 | v104.77,187.92 105.28,187.41 105.28,177.76 105.79,177.25 105.79,164.05 102.74,161 102.74,155.92 105.28,153.38 105.28,147.28 106.29,146.27 106.29,132.55 105.28,131.53 105.28,120.87 104.77,120.36 v104.77,113.25
  Route2 0.254: v18.92,74.13 28.57,83.78 28.57,84.29 34.16,89.88 34.16,91.4 40.25,97.5 v40.76,97.5 | v104.77,113.25 103.25,113.25 102.23,112.23 102.23,111.72 94.61,104.1 92.58,104.1 88.01,99.53 87.5,99.53 84.45,96.48 v82.42,96.48
  Route15 0.254: v40.25,252.44 52.45,240.25 52.95,240.25 54.99,238.21 54.99,237.71 55.49,237.2 56,237.2 64.64,228.56 64.64,228.05 87.5,205.19 88.01,205.19 98.17,195.03 98.17,194.53 v104.77,187.92
  Bottom 0.254: v18.92,45.17 24,45.17 D02.H2 | v40.25,252.44 39.75,252.95 26.03,252.95 25.01,253.96 A02.H2 | v82.42,96.48 81.91,96.99 70.73,96.99 70.23,96.48 65.15,96.48 64.13,97.5 v40.76,97.5
I/O_BMB_00  (via drill 0.61)
  Top 0.254: v44.32,76.16 43.81,75.65 43.81,61.43 D03.B1 | v16.89,117.82 v16.89,105.63 | v30.6,131.53 30.6,133.57 C02.A1 | v12.82,241.26 12.82,240.75 13.33,240.25 13.33,217.89 12.31,216.88 12.31,202.15 12.82,201.64 v12.82,151.35
  Route2 0.254: v30.6,131.53 v16.89,117.82 | v41.78,270.22 32.63,261.07 32.63,260.57 15.87,243.8 15.36,243.8 v12.82,241.26
  Route15 0.254: v44.32,76.16 32.63,87.85 32.63,89.88 v16.89,105.63 | v12.82,151.35 30.6,133.57 C02.A1
  Bottom 0.254: v41.78,270.22 43.3,270.22 A03.B1
I/O_BMB_01  (via drill 0.61)
  Top 0.254: 45.33,137.63 45.33,58.89 43.3,56.86 43.3,54.83 D03.D1 | 45.33,137.63 45.33,258.03 43.3,260.06 43.3,263.11 A03.D1 | 45.33,137.63 v45.84,137.63
  Route2 0.254: v31.62,124.42 33.14,124.42 45.84,137.12 v45.84,137.63
  Bottom 0.254: v31.62,124.42 28.06,124.42 C02.D1
I/O_BMB_02  (via drill 0.61)
  Top 0.254: v46.35,55.84 46.35,51.78 D03.E1 | v16.89,103.59 v16.89,87.34 | v27.55,114.26 27.55,117.31 C02.F1 | v16.89,243.29 16.89,238.72 17.39,238.21 17.39,218.91 15.87,217.39 15.87,216.37 16.38,215.86 16.38,183.35 15.36,182.33 15.36,180.81 v14.85,180.3
  Route2 0.254: v27.55,114.26 v16.89,103.59 | v34.67,261.58 16.89,243.8 v16.89,243.29 | v14.85,180.3 v4.69,170.14
  Route15 0.254: v46.35,55.84 22.98,79.21 22.98,80.23 16.89,86.32 v16.89,87.34 | v4.69,170.14 1.65,167.09 1.65,144.23 3.68,142.2 4.19,142.2 18.92,127.47 18.92,124.42 23.49,119.85 25.01,119.85 27.05,117.82 C02.F1
  Bottom 0.254: v34.67,261.58 41.27,261.58 42.29,260.57 46.35,260.57 A03.E1
I/O_BMB_03  (via drill 0.61)
  Top 0.254: v33.65,48.22 33.14,48.73 33.14,111.21 | 33.14,111.21 v33.65,111.72 | v43.3,247.36 43.3,250.41 A03.J1 | v38.22,242.28 38.22,217.39 37.71,216.88 37.71,202.65 38.73,201.64 v38.73,137.63 | 33.14,111.21 33.14,132.04 v33.65,132.55
  Route2 0.254: v38.22,242.28 v43.3,247.36 | v38.73,137.63 v33.65,132.55
  Route15 0.254: v33.65,48.22 v40.25,41.62 | v38.73,137.63 43.81,132.55 44.32,132.55 52.45,124.42 C04.D2
  Bottom 0.254: v40.25,41.62 43.3,41.62 D03.J1 | v33.65,111.72 28.06,111.72 C02.J1 | C05.D2 68.7,124.42 61.59,124.42 60.57,125.44 56.51,125.44 55.49,124.42 53.46,124.42 C04.D2
I/O_BMB_03\
  Top 0.254: D03.H1 46.35,44.67 45.33,43.65 45.33,18.25 53.97,18.25 53.97,76.67 51.94,78.7 51.94,228.56 54.48,231.1 54.48,264.12 53.46,265.14 45.33,265.14 45.33,259.04 46.35,258.03 46.35,254.47 A03.H1
I/O_BMB_04  (via drill 0.61)
  Top 0.254: v34.67,40.6 34.67,48.73 33.65,49.75 33.65,104.61 v34.16,105.12 34.67,105.63 34.67,119.85 | v49.91,237.71 50.41,237.2 50.41,165.57 v49.91,165.06 | v34.16,149.31 34.67,148.81 34.67,119.85 | 34.67,119.85 v34.16,119.85
  Route2 0.254: v49.91,165.06 v34.16,149.31
  Route15 0.254: v34.67,40.6 v42.79,32.47 | v49.91,237.71 46.35,241.26 A03.M1
  Bottom 0.254: C05.E2 71.75,121.37 64.64,121.37 63.62,122.39 59.56,122.39 58.54,121.37 56.51,121.37 C04.E2 56,121.37 50.92,121.37 49.4,119.85 v34.16,119.85 | v42.79,32.47 46.35,32.47 D03.M1 | v34.16,105.12 28.06,105.12 C02.L1
I/O_BMB_04\
  Top 0.254: D03.L1 43.3,36.03 42.29,37.05 42.29,243.29 43.3,244.31 A03.L1
I/O_BMB_05
  Top 0.254: 47.87,48.73 47.87,64.99 45.84,67.02 45.84,136.11 46.86,137.12 46.86,150.33 47.87,151.35 47.87,205.19 46.86,206.21 46.86,220.43 47.87,221.45 47.87,223.48 46.86,224.5 46.86,228.56 A03.S1 | 47.87,48.73 47.87,20.79 46.86,19.77 D03.S1 | 47.87,48.73 44.83,45.68 44.83,8.6 53.97,8.6 67.69,22.31 67.69,61.43 68.19,61.94 68.19,72.61 67.69,73.11 67.69,87.34 68.19,87.85 68.19,88.86 67.69,89.37 67.69,106.64 70.23,109.18 70.23,116.29 69.21,117.31 C05.F2
  Route2 0.254: C02.N1 28.06,99.02 29.59,99.02 36.19,105.63 36.19,106.13 36.7,106.64 41.27,106.64 52.45,117.82 C04.F2
  Bottom 0.254: C05.F2 68.7,117.31 68.19,116.8 53.97,116.8 53.46,117.31 C04.F2
I/O_BMB_05\
  Bottom 0.254: D03.P1 46.86,25.36 48.38,23.84 80.89,23.84 93.09,11.65 112.9,11.65 115.95,14.69 158.62,14.69 159.13,15.2 265.81,15.2 266.31,14.69 287.14,14.69 306.45,34 319.15,34 338.45,53.3 339.97,53.3 385.19,98.51 385.19,193 397.38,193 414.65,210.27 414.65,212.81 419.22,217.39 419.22,265.14 200.27,265.14 191.64,256.5 114.93,256.5 98.17,239.74 63.11,239.74 59.56,236.18 47.37,236.18 46.86,235.67 A03.P1
I/O_BMB_06  (via drill 0.61)
  Top 0.254: v40.25,53.81 40.25,51.78 D03.E2 | v31.62,62.45 32.13,62.95 32.13,91.91 v31.62,92.42 | v40.25,256.5 40.25,260.06 A03.E2 | v48.89,247.87 48.89,237.2 49.91,236.18 49.91,166.59 48.89,165.57 48.89,150.84 49.4,150.33 49.4,147.79 v49.91,147.28 | v58.03,139.15 58.03,119.85 56,117.82 56,115.28 C04.H2
  Route2 0.254: v31.62,92.42 33.14,92.42 50.92,110.2 50.92,111.21 54.99,115.28 56,115.28 C04.H2
  Route15 0.254: v31.62,62.45 v40.25,53.81 | v48.89,247.87 v40.25,256.5 | v49.91,147.28 v58.03,139.15
  Bottom 0.254: v31.62,92.42 28.06,92.42 C02.R1 | C05.H2 71.75,114.77 64.64,114.77 63.11,116.29 60.07,116.29 58.54,114.77 56.51,114.77 C04.H2
I/O_BMB_06\  (via drill 0.61)
  Route2 0.254: v40.76,55.33 73.27,87.85 v74.8,87.85 | v97.66,87.85 98.17,87.85 106.8,96.48 106.8,96.99 111.88,102.07 111.88,102.58 120.01,110.71 121.03,110.71 121.53,111.21 121.53,112.23 127.63,118.33 129.66,118.33 144.39,133.06 144.39,136.61 v158.11,150.33
  Route15 0.254: v158.11,150.33 153.54,154.9 153.03,154.9 143.89,164.05 143.89,165.06 127.12,181.83 126.61,181.83 111.88,196.56 111.88,198.08 92.58,217.39 91.05,217.39 80.39,228.05 80.39,229.58 69.72,240.25 66.67,240.25 59.05,247.87 59.05,248.37 52.45,254.98 48.89,254.98 40.25,263.61 37.71,263.61 A03.D2
  Bottom 0.254: v40.76,55.33 38.22,55.33 37.71,54.83 D03.D2 | v97.66,87.85 v74.8,87.85
I/O_BMB_07  (via drill 0.61)
  Top 0.254: v26.54,37.05 26.54,38.06 26.03,38.57 26.03,65.49 25.01,66.51 25.01,78.7 v25.52,79.21 | v38.73,206.21 38.22,206.72 38.22,216.37 38.73,216.88 38.73,241.26 39.24,241.77 39.24,243.8 40.25,244.82 40.25,247.36 A03.K2 | v26.03,205.7 v26.03,141.69 | v27.55,84.29 27.55,80.23 C02.V1
  Route2 0.254: v27.55,84.29 33.65,90.39 33.65,91.91 52.95,111.21 C04.J2
  Route15 0.254: v26.03,141.69 35.17,132.55 35.17,130.52 49.4,116.29 49.4,114.77 52.45,111.72 C04.J2
  Bottom 0.254: v26.54,37.05 31.62,37.05 33.14,38.57 39.75,38.57 D03.K2 | v25.52,79.21 25.52,79.72 27.05,79.72 C02.V1 | C05.J2 68.7,111.72 61.59,111.72 60.57,112.74 56.51,112.74 55.49,111.72 53.46,111.72 C04.J2 | v38.73,206.21 38.22,205.7 v26.03,205.7
I/O_BMB_07\  (via drill 0.61)
  Top 0.254: v12.82,74.13 12.82,109.69 v12.31,110.2
  Route2 0.254: v12.31,110.2 17.9,115.79 17.9,117.82 29.59,129.5 32.13,129.5 46.86,144.23 46.86,147.28 v47.87,148.3 | v2.66,205.7 3.68,206.72 4.19,206.72 12.31,214.85 12.31,216.88 18.92,223.48 18.92,227.04 34.67,242.79 34.67,246.85 38.73,250.91 38.73,252.95 39.75,253.96 A03.H2
  Route15 0.254: v12.82,74.13 14.85,72.1 14.85,71.08 30.6,55.33 32.13,55.33 40.76,46.7 40.76,45.17 D03.H2 | v47.87,148.3 36.19,159.98 36.19,161.51 35.68,162.01 35.68,163.54 18.92,180.3 18.92,188.43 16.89,190.46 16.89,191.48 v2.66,205.7
I/O_BMB_08  (via drill 0.61)
  Top 0.254: 41.78,113.25 41.78,29.93 40.25,28.41 40.25,26.38 D03.P2 | 41.78,118.83 41.78,113.25 | 41.78,118.83 41.78,229.58 40.25,231.1 40.25,234.66 A03.P2 | 41.78,118.83 v41.27,118.83 | 41.78,113.25 v41.27,113.25
  Route15 0.254: v62.1,113.25 v66.67,108.67
  Bottom 0.254: v41.27,118.83 40.76,119.34 35.17,119.34 34.67,118.83 30.09,118.83 29.08,119.85 26.03,119.85 25.01,120.87 C02.E2 | v66.67,108.67 71.75,108.67 C05.K2 | v41.27,113.25 v62.1,113.25
I/O_BMB_08\  (via drill 0.61)
  Top 0.254: v66.67,53.81 66.16,54.32 66.16,75.15 v66.67,75.65 | v57.02,85.31 57.53,85.81 57.53,105.12 56,106.64 56,108.17 C04.K2 | v34.67,236.18 v34.67,241.26 | v4.19,205.7 4.19,196.05 4.69,195.54 4.69,194.53 4.19,194.02 4.19,177.76 4.69,177.25 4.69,176.24 3.68,175.22 3.68,143.73 v4.19,143.22
  Route2 0.254: v43.81,31.46 51.94,39.59 52.45,39.59 v66.67,53.81 | v34.67,236.18 v4.19,205.7
  Route15 0.254: v66.67,75.65 v57.02,85.31 50.92,91.4 50.92,93.94 40.76,104.1 40.25,104.1 39.24,105.12 39.24,105.63 35.17,109.69 35.17,112.74 17.9,130.01 17.39,130.01 v4.19,143.22
  Bottom 0.254: v43.81,31.46 41.27,31.46 40.76,31.97 D03.M2 | v34.67,241.26 39.75,241.26 A03.M2
I/O_BMB_09
  Top 0.254: A03.S2 39.75,228.56 39.24,228.05 39.24,207.23 39.75,206.72 39.75,205.19 39.24,204.69 39.24,138.65 39.75,138.14 39.75,135.6 39.24,135.09 39.24,81.75 40.25,80.73 40.25,66 39.24,64.99 39.24,22.82 40.25,21.81 40.25,19.77 D03.S2
  Route15 0.254: C02.H2 24,114.77 22.47,114.77 19.93,117.31 19.93,118.33 12.31,125.95 11.3,125.95 1.65,116.29 1.65,71.08 4.19,68.54 4.19,51.27 16.38,39.08 16.38,38.06 30.09,24.35 33.65,24.35 36.7,21.3 37.71,21.3 39.75,19.27 D03.S2
I/O_BMB_10  (via drill 0.61)
  Top 0.254: 35.68,141.69 35.68,20.28 37.21,18.76 37.21,16.73 D03.T2 | 35.68,141.69 35.68,219.93 37.21,221.45 37.21,225.01 A03.T2 | v17.9,108.67 17.39,109.18 17.39,116.8 17.9,117.31 v17.9,122.9 | 35.68,141.69 v36.19,141.69
  Route2 0.254: v17.9,122.9 17.9,123.41 v36.19,141.69
  Bottom 0.254: v17.9,108.67 24,108.67 C02.K2
I/O_BMB_11  (via drill 0.61)
  Top 0.254: 36.19,103.59 36.19,78.7 37.21,77.69 37.21,62.95 38.22,61.94 38.22,13.68 37.21,12.66 37.21,10.63 D03.V2 | 36.19,103.59 36.19,132.04 37.21,133.06 37.21,147.28 38.22,148.3 38.22,201.13 37.21,202.15 37.21,218.91 A03.V2 | 36.19,103.59 v36.7,103.59
  Bottom 0.254: v36.7,103.59 30.09,103.59 29.59,103.09 25.52,103.09 25.01,102.58 C02.M2
I/O_BRK_RQ\
  Top 0.254: 71.24,232.63 71.24,247.36 71.75,247.87 A05.K2 | 71.24,232.63 71.24,221.45 73.27,219.42 73.27,68.03 71.24,66 71.24,39.59 71.75,39.08 D05.K2 | 71.24,232.63 74.29,229.58 74.29,215.35 76.32,213.32 76.32,194.53 75.81,194.02 B05.D1
I/O_BWC0\
  Top 0.254: A06.P2 87.5,235.17 85.97,233.64 85.97,202.15 86.48,201.64 86.48,27.39 87.5,26.38 D06.P2
  Route15 0.254: C01.F1 11.3,117.82 11.3,113.25 6.73,108.67 21.46,93.94 21.97,93.94 32.13,83.78 32.13,80.73 47.87,64.99 47.87,62.95 63.11,47.71 63.11,46.19 63.62,45.68 63.62,32.47 71.75,24.35 85.97,24.35 87.5,25.87 D06.P2
I/O_DATA_IN  (via drill 0.61)
  Top 0.254: v66.16,32.47 66.16,44.16 65.15,45.17 65.15,80.73 66.67,82.26 66.67,84.29 66.16,84.8 66.16,93.43 66.67,93.94 66.67,107.15 67.69,108.17 67.69,123.41 66.67,124.42 66.67,138.65 67.69,139.66 67.69,140.68 66.16,142.2 66.16,153.89 65.65,154.39 65.65,166.59 66.16,167.09 66.16,170.14 66.67,170.65 66.67,174.21 67.69,175.22 67.69,176.75 68.7,177.76 68.7,180.81 B05.J2 | v66.67,241.77 66.67,194.53 66.16,194.02 v66.16,183.35
  Route15 0.254: v66.16,183.35 68.7,180.81 B05.J2
  Bottom 0.254: v66.16,32.47 71.75,32.47 D05.M2 | v66.67,241.77 71.75,241.77 A05.M2
I/O_INT_RQ\  (via drill 0.61)
  Top 0.254: v56,34.51 56,32.47 D04.M2 | v65.15,43.65 64.64,44.16 64.64,81.24 66.16,82.77 66.16,83.78 65.65,84.29 65.65,93.94 66.16,94.45 66.16,95.47 64.64,96.99 64.64,108.67 65.65,109.69 65.65,153.38 65.15,153.89 65.15,167.09 65.65,167.6 65.65,170.65 66.16,171.16 v66.16,175.22 | v78.35,187.41 78.35,190.46 B05.E1 78.35,190.97 v78.35,193.51 | v56,238.21 56,241.26 A04.M2 | v65.65,228.56 65.15,228.05 65.15,219.93 64.13,218.91 64.13,207.73 v64.64,207.23
  Route2 0.254: v65.15,43.65 v56,34.51 | v78.35,187.41 v66.16,175.22
  Route15 0.254: v65.65,228.56 v56,238.21 | v78.35,193.51 v64.64,207.23
I/O_PWR_CLR
  Top 0.254: 22.47,8.6 26.54,4.53 79.88,4.53 79.88,113.25 78.86,114.26 C05.H1 | 22.47,8.6 21.46,9.61 D02.V2 | 22.47,8.6 22.47,217.89 21.46,218.91 A02.V2
I/O_SKP_RQ\  (via drill 0.61)
  Top 0.254: v66.16,46.19 65.65,46.7 65.65,80.23 67.18,81.75 v67.18,88.35 | v76.83,98.01 76.83,164.05 77.34,164.55 77.34,166.59 76.83,167.09 76.83,174.71 78.35,176.24 78.35,177.76 B05.K1 | v82.93,222.97 82.93,183.86 v82.42,183.35
  Route2 0.254: v66.16,46.19 v59.05,39.08 | v76.83,98.01 v67.18,88.35 | v82.42,183.35 80.39,181.32 80.39,179.79 78.86,178.27 B05.K1
  Route15 0.254: v82.93,222.97 v58.03,247.87
  Bottom 0.254: v59.05,39.08 56.51,39.08 D04.K2 | v58.03,247.87 56.51,247.87 A04.K2
I/O_TS03
  Top 0.254: A02.S2 25.01,228.56 25.52,228.05 25.52,206.72 25.01,206.21 25.01,205.19 25.52,204.69 25.52,142.71 25.01,142.2 25.01,135.6 25.52,135.09 25.52,80.73 24.51,79.72 24.51,66 25.52,64.99 25.52,20.28 25.01,19.77 D02.S2
  Route2 0.254: D02.S2 24,19.77 24,24.35 16.38,31.97 16.38,60.41 36.19,80.23 36.19,80.73 46.35,90.89 47.87,90.89 48.89,91.91 48.89,98.01 63.11,112.23 63.11,114.77 C04.H1
I/O_TS04
  Top 0.254: D02.T2 20.95,16.73 19.93,17.74 19.93,224.5 20.95,225.51 A02.T2
IM_00\  (via drill 0.61)
  Top 0.254: v59.05,69.05 59.05,61.43 D04.B1 | v2.15,69.05 1.65,69.56 1.65,195.54 v2.15,196.05 | v48.38,262.6 48.38,248.88 47.87,248.37 47.87,247.36 48.38,246.85 v48.38,233.13 | v44.32,229.07 44.83,228.56 44.83,198.08 43.3,196.56 43.3,194.02 B03.D1
  Route2 0.254: v48.38,262.6 v56,270.22 | v44.32,229.07 v48.38,233.13
  Bottom 0.254: B04.D1 59.05,194.02 54.99,194.02 53.97,193 51.43,193 50.41,194.02 43.81,194.02 B03.D1 43.3,194.02 40.76,194.02 40.25,194.53 38.73,194.53 37.21,196.05 v2.15,196.05 | v2.15,69.05 v59.05,69.05 | v56,270.22 59.05,270.22 A04.B1
IM_01\  (via drill 0.61)
  Top 0.254: v64.13,263.61 64.13,220.94 63.11,219.93 63.11,206.21 64.13,205.19 64.13,193.51 v64.64,193 | v47.87,66.51 47.87,68.03 48.89,69.05 48.89,129.5 v48.38,130.01 | v44.32,133.57 44.83,134.07 44.83,189.95 v44.32,190.46
  Route2 0.254: v64.64,193 62.61,190.97 B04.E1
  Route15 0.254: v47.87,66.51 48.89,66.51 59.56,55.84 59.56,54.83 D04.D1 | v48.38,130.01 47.87,130.01 v44.32,133.57
  Bottom 0.254: v64.13,263.61 59.56,263.61 A04.D1 | v44.32,190.46 46.35,190.46 B03.E1 46.86,190.46 49.4,190.46 50.41,189.45 58.03,189.45 59.56,190.97 62.1,190.97 B04.E1
IM_02\
  Top 0.254: A04.E1 63.11,260.06 63.62,259.55 63.62,221.45 62.61,220.43 62.61,205.7 63.62,204.69 63.62,179.29 63.11,178.78 B04.K1
  Bottom 0.254: D04.E1 62.61,50.76 69.21,50.76 80.39,39.59 80.39,27.39 106.29,27.39 115.44,18.25 144.39,18.25 147.44,21.3 158.62,21.3 167.76,30.44 242.44,30.44 258.69,46.7 262.25,46.7 271.39,55.84 279.01,55.84 315.08,91.91 315.08,135.09 324.23,144.23 324.23,151.35 305.94,151.35 287.14,170.14 225.67,170.14 222.63,173.19 183.51,173.19 177.41,179.29 148.97,179.29 148.46,179.79 137.28,179.79 134.74,182.33 115.44,182.33 112.9,179.79 83.94,179.79 82.93,178.78 79.88,178.78 79.37,179.29 69.72,179.29 68.19,177.76 63.11,177.76 B04.K1 62.1,177.76 59.05,177.76 58.03,176.75 55.49,176.75 54.48,177.76 46.86,177.76 B03.K1
IM_03\  (via drill 0.61)
  Top 0.254: v62.1,47.21 62.1,45.17 D04.H1 | v34.67,74.13 35.17,74.64 35.17,162.52 | 35.17,162.52 v34.67,163.03 | v43.3,171.67 43.3,174.21 B03.L1 | v49.91,240.75 v49.91,244.31 | v34.16,225.01 33.65,224.5 33.65,172.68 35.17,171.16 35.17,162.52
  Route2 0.254: v34.67,163.03 v43.3,171.67 | v49.91,244.31 v59.56,253.96 | v34.16,225.01 v49.91,240.75
  Route15 0.254: v62.1,47.21 47.87,61.43 47.37,61.43 v34.67,74.13
  Bottom 0.254: B04.L1 59.05,175.22 56.51,175.22 54.99,173.7 47.37,173.7 46.35,174.71 43.81,174.71 B03.L1 | v59.56,253.96 62.1,253.96 A04.H1
IM_04\  (via drill 0.61)
  Top 0.254: 58.03,166.59 58.03,245.83 59.56,247.36 59.56,250.41 A04.J1 | 58.03,166.59 59.56,165.06 59.56,163.03 B04.R1 | v59.05,44.16 59.05,42.13 D04.J1 | v50.41,52.79 50.41,61.94 50.92,62.45 50.92,142.71 v50.41,143.22 | 58.03,166.59 v58.03,150.84
  Route2 0.254: v58.03,150.84 v50.41,143.22
  Route15 0.254: v50.41,52.79 v59.05,44.16
  Bottom 0.254: B03.R1 43.81,162.01 50.92,162.01 51.94,161 54.48,161 56,162.52 59.05,162.52 B04.R1
IM_05\  (via drill 0.61)
  Top 0.254: v48.89,41.62 48.38,42.13 48.38,53.3 49.4,54.32 49.4,62.95 49.91,63.46 49.91,141.19 48.38,142.71 48.38,146.27 v47.87,146.77 | v50.41,239.23 50.92,238.72 50.92,163.54 v50.41,163.03
  Route2 0.254: v47.87,146.77 v52.95,151.85 60.57,159.47 62.1,159.47 B04.S1 | v50.41,239.23 v56,244.82 | v50.41,163.03 46.86,159.47 B03.S1
  Route15 0.254: v48.89,41.62 v54.99,35.52 | v52.95,151.85 46.35,158.46 B03.S1
  Bottom 0.254: v54.99,35.52 58.54,35.52 D04.L1 | v56,244.82 59.05,244.82 A04.L1
IM_06\  (via drill 0.61)
  Top 0.254: v62.1,34.51 62.1,32.47 D04.M1 | v49.4,47.21 49.4,53.3 49.91,53.81 49.91,62.45 50.41,62.95 50.41,141.69 48.89,143.22 48.89,149.82 48.38,150.33 48.38,183.35 v48.89,183.86 49.4,184.37 49.4,229.07 v48.89,229.58
  Route2 0.254: v48.89,229.58 v60.57,241.26
  Route15 0.254: v49.4,47.21 v62.1,34.51
  Bottom 0.254: B04.H2 56,184.87 54.48,184.87 53.46,183.86 v48.89,183.86 47.87,182.84 40.76,182.84 40.76,183.86 B03.H2 | v60.57,241.26 62.1,241.26 A04.M1
IM_07\
  Top 0.254: D04.P1 62.61,26.38 64.13,27.9 64.13,111.72 65.15,112.74 65.15,152.87 63.62,154.39 63.62,162.52 60.57,165.57 60.57,233.13 62.1,234.66 A04.P1
  Route2 0.254: B03.J2 37.71,181.32 39.24,181.32 42.29,184.37 42.29,184.87 43.81,186.4 44.32,186.4 47.87,189.95 47.87,193.51 57.53,203.16 57.53,205.7 79.88,228.05 79.88,230.09 91.05,241.26 91.05,242.79 95.63,247.36 95.63,248.88 97.15,250.41 97.15,251.93 100.2,254.98 100.2,255.99 96.13,260.06 95.63,259.55 88.51,259.55 85.47,256.5 83.43,256.5 62.61,235.67 A04.P1
  Bottom 0.254: B03.J2 37.71,181.32 38.73,182.33 51.94,182.33 52.45,181.83 B04.J2
IM_08\  (via drill 0.61)
  Top 0.254: v82.42,39.59 82.42,43.14 82.93,43.65 82.93,83.78 80.89,85.81 80.89,116.29 81.91,117.31 v81.91,128.49 | v67.18,142.71 66.67,142.71 v66.67,157.44 | v33.65,227.55 33.14,227.04 33.14,171.67 v33.65,171.16
  Route2 0.254: v82.42,39.59 62.61,19.77 D04.S1
  Route15 0.254: v81.91,128.49 81.4,128.49 v67.18,142.71 | v66.67,157.44 54.99,169.13 53.46,169.13 B04.N2 | v33.65,171.16 36.7,168.11 B03.N2
  Bottom 0.254: B04.N2 52.45,168.62 45.84,168.62 44.83,169.63 40.76,169.63 39.75,168.62 37.71,168.62 B03.N2 | v33.65,227.55 58.03,227.55 59.05,228.56 62.1,228.56 A04.S1
IM_09\  (via drill 0.61)
  Top 0.254: 51.43,162.01 51.43,59.4 52.95,59.4 52.95,54.83 D04.D2 | 51.43,162.01 51.43,258.03 52.95,259.55 52.95,263.11 A04.D2 | v49.91,157.44 49.4,157.95 49.4,161.51 49.91,162.01 51.43,162.01
  Route15 0.254: v49.91,157.44 43.3,164.05 42.79,164.05 41.27,165.57 40.76,165.57 B03.P2
IM_10\  (via drill 0.61)
  Top 0.254: v147.95,135.6 149.47,135.6 151,137.12 151,149.82 149.98,150.84 149.98,171.67 v148.46,173.19
  Route2 0.254: v66.67,49.75 112.9,95.97 112.9,99.02 122.04,108.17 122.04,109.18 122.55,109.69 123.57,109.69 130.17,116.29 130.17,117.82 v147.95,135.6
  Route15 0.254: v148.46,173.19 146.43,175.22 146.43,175.73 127.63,194.53 126.61,194.53 112.39,208.75 111.88,208.75 102.23,218.4 102.23,219.93 95.63,226.53 93.59,226.53 80.89,239.23 79.37,239.23 v58.03,260.57
  Bottom 0.254: v66.67,49.75 57.53,49.75 56.51,50.76 D04.E2 | v58.03,260.57 56.51,260.57 A04.E2
IM_11\  (via drill 0.61)
  Top 0.254: B04.P2 56,165.06 56,161.51 54.48,159.98 54.48,48.73 56,47.21 56,45.17 D04.H2 | v56.51,249.39 56,249.9 56,253.96 A04.H2 | v36.19,228.56 35.17,227.55 35.17,224.5 34.16,223.48 34.16,175.73 v34.67,175.22
  Route2 0.254: v56.51,249.39 56,249.39 50.92,244.31 50.92,243.29 48.89,241.26 48.89,240.75 36.7,228.56 v36.19,228.56
  Route15 0.254: v34.67,175.22 v43.3,166.59
  Bottom 0.254: v43.3,166.59 51.94,166.59 52.95,165.57 56,165.57 B04.P2
INT_RQ\  (via drill 0.61)
  Top 0.254: v75.31,208.24 75.31,200.62 B05.B1 | v191.13,214.34 191.13,243.8 189.61,245.33 189.61,247.87 A12.K1
  Route2 0.254: v123.06,210.27 v126.11,213.32
  Bottom 0.254: v75.31,208.24 86.99,208.24 87.5,208.75 90.55,208.75 91.05,209.26 97.66,209.26 98.67,210.27 v123.06,210.27 | v126.11,213.32 127.12,212.31 130.68,212.31 131.19,211.8 163.19,211.8 164.21,212.81 164.21,213.83 174.87,213.83 175.38,214.34 v191.13,214.34
IOP_1  (via drill 0.61)
  Top 0.254: v24.51,41.11 24.51,39.08 D02.K2 | v34.67,51.27 34.16,51.78 34.16,71.59 v34.67,72.1 | v56,93.43 56,95.47 C04.P2
  Route2 0.254: v34.67,51.27 v24.51,41.11 | v34.67,72.1 41.27,78.7 41.27,79.21 43.81,81.75 44.32,81.75 44.83,82.26 44.83,82.77 52.45,90.39 52.95,90.39 v56,93.43 | v119.5,156.93 v105.28,142.71 | v108.33,139.66 107.82,139.66 103.25,135.09 102.74,135.09 96.13,128.49 96.13,127.47 94.61,125.95 93.59,125.95 93.09,125.44 93.09,124.42 91.56,122.9 90.55,122.9 90.04,122.39 90.04,120.87 83.43,114.26 81.4,114.26 80.39,113.25 80.39,112.23 78.35,110.2 77.85,110.2 76.32,108.67 75.81,108.67 64.13,96.99 64.13,94.45 64.64,93.94 70.23,93.94 71.75,95.47 C05.P2
  Route15 0.254: v28.57,248.37 34.67,242.28 36.19,242.28 47.87,230.59 49.91,230.59 66.67,213.83 66.67,212.31 82.93,196.05 82.93,193.51 89.02,187.41 89.53,187.41 92.07,184.87 92.07,184.37 94.61,181.83 98.17,181.83 115.44,164.55 115.44,161 v119.5,156.93 | v105.28,142.71 v108.33,139.66
  Bottom 0.254: C05.P2 71.75,95.97 64.64,95.97 63.62,96.99 61.08,96.99 60.07,95.97 56.51,95.97 C04.P2 | v28.57,248.37 25.01,248.37 A02.K2
IOP_2
  Route2 0.254: D02.M2 25.01,32.47 25.01,37.05 32.13,44.16 32.13,45.17 34.67,47.71 34.67,49.75 35.68,50.76 35.68,57.37 48.89,70.57 48.89,72.1 68.7,91.91 C05.R2
  Route15 0.254: A02.M2 24.51,241.26 24.51,238.72 35.68,227.55 43.3,227.55 47.37,223.48 51.43,223.48 67.69,207.23 70.23,207.23 79.88,197.57 79.88,194.53 95.63,178.78 95.63,175.73 111.37,159.98 111.37,158.97 122.04,148.3 124.58,148.3 139.82,133.06 140.33,133.06 140.84,132.55 144.39,132.55 157.09,119.85 159.13,119.85 163.19,115.79 163.19,114.26 165.22,112.23 165.22,108.17 168.27,105.12 168.78,105.12 177.92,95.97 180.97,95.97 189.1,87.85 190.11,87.85 197.23,80.73 197.23,55.33 206.88,45.68 206.88,42.13 212.97,36.03 212.97,35.01 201.8,23.84 201.29,23.84 190.62,13.17 190.62,12.15 179.95,1.49 98.17,1.49 96.64,3.01 68.19,3.01 53.46,17.74 50.41,17.74 37.71,30.44 34.67,30.44 31.62,33.49 26.03,33.49 25.01,32.47 D02.M2
  Bottom 0.254: C04.R2 53.46,92.42 57.02,92.42 58.54,93.94 67.69,93.94 68.7,92.93 C05.R2
IOP_4  (via drill 0.61)
  Top 0.254: 22.98,87.85 22.98,29.93 24.51,28.41 24.51,26.38 D02.P2 | 22.98,87.85 22.98,229.58 24.51,231.1 24.51,235.17 A02.P2 | 22.98,87.85 v23.49,87.85
  Bottom 0.254: C05.S2 71.75,89.37 64.64,89.37 63.11,90.89 62.1,90.89 60.57,89.37 56.51,89.37 C04.S2 56,88.86 54.99,87.85 v23.49,87.85
LDMF  (via drill 0.61)
  Top 0.254: v80.89,117.82 80.39,117.31 80.39,82.26 v80.89,81.75 | v173.86,46.7 173.86,45.17 D11.H1
  Route2 0.254: v166.24,54.32 170.81,58.89 170.81,60.41 D11.B1
  Route15 0.254: v80.89,81.75 95.63,67.02 95.63,66.51 96.13,66 96.64,66 v97.15,65.49 | v152.01,66 163.7,54.32 D11.D2 | v166.24,54.32 v173.86,46.7
  Bottom 0.254: v80.89,117.82 75.81,117.82 C05.F1 | v97.15,65.49 97.66,66 v152.01,66 | v166.24,54.32 164.71,54.32 D11.D2
LDMF\  (via drill 0.61)
  Top 0.254: v80.89,121.37 80.39,121.88 80.39,132.04 v80.89,132.55
  Route2 0.254: v113.41,165.06 v80.89,132.55
  Bottom 0.254: v80.89,121.37 78.86,121.37 C05.E1 | v113.41,165.06 119.5,165.06 B08.P2
LPB_00  (via drill 0.61)
  Top 0.254: v126.11,55.33 126.11,51.78 D08.E1 | v113.91,67.53 113.91,76.16 112.9,77.18 112.9,100.55 113.91,101.56 v113.91,112.74 | v123.06,121.88 123.06,123.91 C08.D1 | v387.73,206.21 387.73,220.43 387.22,220.94 387.22,221.96 386.2,222.97 386.2,225.51 A25.T2
  Route2 0.254: v123.06,121.88 v113.91,112.74 | v358.77,206.21 352.17,199.61 352.17,197.57 335.91,181.32 335.91,179.29 320.16,163.54 319.65,163.54 316.61,160.49 316.1,160.49 307.97,152.36 307.97,151.85 307.46,151.35 306.95,151.35 295.27,139.66 295.27,139.15 v288.67,132.55
  Route15 0.254: v113.91,67.53 v126.11,55.33 | v119.5,129.5 123.06,125.95 123.06,124.93 C08.D1
  Bottom 0.254: v358.77,206.21 v387.73,206.21 | v288.67,132.55 242.95,132.55 242.44,132.04 220.09,132.04 219.58,132.55 197.73,132.55 196.72,133.57 192.15,133.57 191.13,132.55 178.43,132.55 177.92,132.04 163.19,132.04 162.68,131.53 162.68,131.03 161.16,129.5 v119.5,129.5
LPB_00\  (via drill 0.61)
  Top 0.254: v157.6,35.01 157.6,32.47 D10.M1
  Route15 0.254: v145.92,46.7 v157.6,35.01
  Bottom 0.254: v145.92,46.7 124.07,46.7 123.06,47.71 D08.F1
LPB_01  (via drill 0.61)
  Top 0.254: v130.68,36.03 130.68,41.11 129.15,42.63 129.15,61.43 131.19,63.46 131.19,81.24 130.68,81.75 130.68,88.86 129.66,89.88 129.66,103.09 v130.17,103.59 | v388.74,205.19 388.74,206.72 388.23,207.23 388.23,221.45 389.25,222.47 A25.U2
  Route2 0.254: v283.08,205.7 270.38,193 268.85,193 256.66,180.81 256.66,178.78 239.9,162.01 236.85,162.01 236.34,161.51 236.34,161 225.17,149.82 v224.15,149.82 | v170.3,153.38 153.54,136.61 151.51,136.61 143.89,128.99 143.89,127.47 128.65,112.23 128.65,110.71 126.61,108.67 C08.K1
  Route15 0.254: v130.17,103.59 130.17,104.1 126.11,108.17 C08.K1
  Bottom 0.254: v130.68,36.03 123.06,36.03 D08.L1 | v388.74,205.19 387.22,205.19 386.71,205.7 359.79,205.7 359.28,205.19 346.07,205.19 345.56,205.7 345.05,205.7 344.04,206.72 323.21,206.72 321.69,205.19 311.53,205.19 311.02,204.69 304.41,204.69 303.91,204.18 302.89,204.18 300.86,206.21 283.59,206.21 v283.08,205.7 | v224.15,149.82 223.64,149.31 221.61,149.31 220.09,147.79 193.67,147.79 190.11,151.35 181.99,151.35 179.95,153.38 176.4,153.38 175.89,153.89 170.81,153.89 v170.3,153.38
LPB_01\
  Bottom 0.254: D08.M1 126.61,31.97 130.68,27.9 153.54,27.9 154.05,28.41 D10.N1
LPB_02  (via drill 0.61)
  Top 0.254: v113.91,28.41 113.41,28.92 113.41,42.63 112.9,43.14 112.9,63.97 115.44,66.51 115.44,68.54 114.93,69.05 v114.93,82.26 | v122.04,89.37 123.06,90.39 123.06,91.91 C08.R1 | v384.17,3.52 384.17,183.86 383.66,184.37 383.66,213.32 386.2,215.86 386.2,218.91 A25.V2
  Route2 0.254: v114.93,82.26 v122.04,89.37
  Route15 0.254: v122.55,19.77 v113.91,28.41 | v139.82,5.55 126.11,19.27 D08.S1
  Bottom 0.254: v122.55,19.77 125.6,19.77 D08.S1 | v384.17,3.52 383.66,3.01 287.14,3.01 285.62,4.53 283.59,4.53 282.57,5.55 272.41,5.55 271.39,4.53 270.89,4.53 269.87,3.52 194.18,3.52 193.16,4.53 178.94,4.53 178.43,5.04 155.06,5.04 154.55,5.55 v139.82,5.55
LPB_02\