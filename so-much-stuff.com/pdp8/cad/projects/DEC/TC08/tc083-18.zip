# EAGLE board tc083-18 (EAGLE 4.11), part 4 of 6
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
LPB_02\ (continued)
  Route2 0.254: D08.U1 126.61,13.17 133.22,6.57 141.35,14.69 144.39,14.69 150.49,20.79 154.55,20.79 156.08,22.31 156.08,23.84 157.6,25.36 D10.P1
LPB_03  (via drill 0.61)
  Top 0.254: C08.H2 119.5,114.26 119.5,110.71 118.49,109.69 118.49,81.24 119.5,80.23 119.5,66 118.49,64.99 118.49,48.22 119.5,47.21 119.5,45.17 D08.H2 | v415.67,266.15 415.67,250.41 415.16,249.9 415.16,244.82 414.65,244.31 414.65,235.17 415.16,234.66 415.16,218.4 415.67,217.89 v415.67,211.8
  Route2 0.254: v415.67,211.8 396.87,193 395.85,193 381.63,178.78 381.63,177.76 368.42,164.55 366.39,164.55 318.13,116.29 318.13,114.26 304.92,101.05 302.89,101.05 286.63,84.8 286.63,82.77 281.55,77.69 278.51,77.69 268.35,67.53 268.35,67.02 254.63,53.3 253.11,53.3 v240.41,40.6
  Route15 0.254: v415.67,266.15 v408.05,273.77
  Bottom 0.254: v408.05,273.77 406.01,273.77 A26.A2 | v240.41,40.6 131.19,40.6 129.15,42.63 125.09,42.63 122.55,45.17 120.01,45.17 D08.H2
LPB_03\
  Route2 0.254: D08.J2 115.95,41.62 110.36,36.03 110.36,35.01 115.44,29.93 115.95,30.44 129.15,30.44 136.77,22.82 141.35,27.39 147.44,27.39 153.03,21.81 154.05,22.82 D10.R1
LPB_04  (via drill 0.61)
  Top 0.254: v112.9,25.87 112.9,42.13 112.39,42.63 112.39,64.48 114.93,67.02 114.93,68.03 114.42,68.54 114.42,76.67 113.41,77.69 113.41,95.97 v113.91,96.48 | v383.66,251.93 383.66,243.29 383.15,242.79 v383.15,241.26
  Route2 0.254: v113.91,96.48 116.45,99.02 C08.N2 | v383.66,251.93 392.3,260.57 392.81,260.57 402.46,270.22 A26.B2 | v383.15,241.26 382.65,241.26 374.52,233.13 374.52,231.61 374.01,231.1 373.5,231.1 369.95,227.55 369.95,227.04 369.44,226.53 366.39,226.53 346.58,206.72 346.58,206.21 332.86,192.49 332.35,192.49 318.13,178.27 318.13,176.24 304.92,163.03 304.92,161 295.27,151.35 291.21,151.35 276.98,137.12 276.98,136.11 272.92,132.04 272.92,129.5 253.61,110.2 252.09,110.2 242.44,100.55 240.41,100.55 237.87,98.01 237.36,98.01 226.18,86.83 226.18,84.8 v226.69,84.29
  Route15 0.254: v126.11,84.8 122.55,88.35 121.53,88.35 121.03,88.86 121.03,89.88 114.42,96.48 v113.91,96.48
  Bottom 0.254: v112.9,25.87 119.5,25.87 D08.P2 | v226.69,84.29 225.67,85.31 219.58,85.31 219.07,84.8 192.65,84.8 192.15,85.31 188.08,85.31 187.57,84.8 179.45,84.8 178.94,85.31 171.83,85.31 171.32,84.8 v126.11,84.8
LPB_04\
  Bottom 0.254: D08.R2 116.96,23.33 117.47,23.84 140.33,23.84 141.35,22.82 147.95,22.82 D10.R2
LPB_05  (via drill 0.61)
  Top 0.254: v114.42,11.65 114.42,27.39 114.93,27.9 114.93,28.92 113.91,29.93 113.91,43.14 113.41,43.65 113.41,62.45 v113.91,62.95 | v120.52,69.56 120.01,70.07 120.01,80.73 119.5,81.24 119.5,82.77 C08.U2 | v403.98,214.34 403.98,243.8 407.03,246.85 407.03,261.58 405.51,263.11 405.51,266.66 A26.C2 | v384.68,195.03 384.17,194.53 384.17,184.87 384.68,184.37 384.68,12.66 v385.19,12.15
  Route2 0.254: v113.91,62.95 113.91,63.46 120.01,69.56 v120.52,69.56 | v403.98,214.34 403.47,214.34 384.68,195.54 v384.68,195.03 | v378.07,5.04 v385.19,12.15
  Route15 0.254: v114.42,11.65 115.95,10.12 D08.V2
  Bottom 0.254: v378.07,5.04 377.57,4.53 288.67,4.53 287.14,6.06 285.11,6.06 284.09,7.07 270.89,7.07 270.38,6.57 269.87,6.57 268.35,5.04 195.7,5.04 194.69,6.06 180.46,6.06 179.95,6.57 173.35,6.57 172.33,7.58 171.32,7.58 169.79,6.06 156.08,6.06 155.57,6.57 142.36,6.57 140.33,8.6 139.31,8.6 138.81,8.09 125.6,8.09 125.09,8.6 121.03,8.6 119.5,10.12 116.96,10.12 D08.V2
LPB_05\
  Top 0.254: D10.U2 151,13.17 148.46,15.71 D10.T2 148.46,16.73 151,19.27 D10.S2
  Bottom 0.254: D08.V1 123.06,10.63 124.07,11.65 149.98,11.65 151,12.66 D10.U2
LPB_NOT_EQ_1  (via drill 0.61)
  Top 0.254: v274.44,3.01 274.44,32.47 273.93,32.98 273.93,55.84 274.44,56.35 274.44,57.37 272.92,58.89 272.92,86.83 274.44,88.35 274.44,90.39 273.93,90.89 273.93,101.56 276.98,104.61 276.98,147.28 277.49,147.79 277.49,201.64 276.47,202.65 276.47,214.85 v276.98,215.35 | v157.6,213.32 159.13,214.85 159.13,220.94 159.63,221.45 159.63,237.71 158.11,239.23 158.11,241.26 A10.M1
  Route15 0.254: v153.54,4.03 147.95,9.61 D10.V2
  Bottom 0.254: v153.54,4.03 177.41,4.03 177.92,3.52 192.15,3.52 193.16,2.5 273.93,2.5 v274.44,3.01 | v276.98,215.35 276.47,214.85 269.36,214.85 268.85,215.35 236.85,215.35 235.33,216.88 203.83,216.88 203.32,216.37 189.61,216.37 189.1,215.86 176.4,215.86 175.89,216.37 175.89,217.39 174.37,217.39 171.83,214.85 162.68,214.85 161.16,213.32 v157.6,213.32
LPB_TO_DTB  (via drill 0.61)
  Top 0.254: 117.98,102.07 117.98,90.39 116.45,88.86 116.45,86.83 C08.T2 | 117.98,102.07 117.98,112.23 116.45,113.75 116.45,117.31 C08.F2 | v117.47,102.07 117.98,102.07 | C08.C1 126.11,126.96 126.11,123.91 124.58,122.39 v124.58,113.75 v124.58,102.07 124.58,99.53 126.11,98.01 126.11,95.97 C08.P1 | v164.21,222.97 164.21,225.51 A11.T2 | v140.33,199.1 140.33,185.38 140.84,184.87 140.84,183.86 140.33,183.35 v140.33,141.69
  Route2 0.254: v124.58,113.75 123.06,112.23 C08.J1 | v140.33,199.1 v164.21,222.97 | v140.33,141.69 126.11,127.47 C08.C1
  Bottom 0.254: v117.47,102.07 119.5,102.07 C08.M2 120.01,102.07 v124.58,102.07
M-STOP\  (via drill 0.61)
  Top 0.254: B14.D1 218.05,193.51 218.05,189.45 217.04,188.43 217.04,147.79 218.05,146.77 218.05,133.06 217.04,132.04 217.04,78.7 218.05,77.69 v218.05,76.16 218.05,62.95 219.07,61.94 219.07,40.6 218.05,39.59 218.05,36.03 D14.L1 | v112.9,102.07 112.39,101.56 112.39,76.16 v112.9,75.65
  Route15 0.254: v106.8,108.67 106.8,108.17 v112.9,102.07 | v196.72,205.19 173.35,228.56 A11.S1 | v201.8,205.19 211.45,195.54 211.96,195.54 v213.48,194.02
  Bottom 0.254: v106.8,108.67 103.75,108.67 C07.K2 | v112.9,75.65 127.12,75.65 128.14,76.67 145.41,76.67 145.92,77.18 159.13,77.18 160.14,76.16 183,76.16 184.02,77.18 215.01,77.18 216.02,76.16 v218.05,76.16 | v201.8,205.19 v196.72,205.19 | v213.48,194.02 217.55,194.02 B14.D1
MB_TO_DTB\
  Top 0.254: D12.S1 190.11,19.77 190.62,20.28 190.62,37.55 190.11,38.06 D12.K1 189.1,38.57 186.56,41.11 D12.J1 186.56,42.13 189.1,44.67 D12.H1 189.1,45.17 186.56,47.71 D12.F1
MC00  (via drill 0.61)
  Top 0.254: v192.65,80.23 192.65,91.91 192.15,92.42 192.15,98.51 194.18,100.55 194.18,102.58 193.67,103.09 193.67,111.21 v194.18,111.72 | v200.78,118.83 200.78,134.58 200.27,135.09 200.27,147.79 201.29,148.81 201.29,176.75 200.78,177.25 200.78,178.27 201.29,178.78 201.29,187.92 199.26,189.95 199.26,190.46 B13.E2
  Route2 0.254: v166.24,52.79 167.25,53.81 167.25,54.32 188.08,75.15 188.08,75.65 v192.65,80.23 | v194.18,111.72 199.77,117.31 199.77,117.82 v200.78,118.83 | v407.54,229.07 407.54,228.56 391.79,212.81 v391.28,212.81 | v226.18,211.8 218.05,203.67 218.05,203.16 209.93,195.03 209.42,195.03 208.91,194.53 208.91,193.51 205.86,190.46 B13.E1
  Bottom 0.254: B13.E1 205.35,190.46 199.77,190.46 B13.E2 | v166.24,52.79 165.73,53.3 148.97,53.3 148.46,53.81 D10.D2 | v407.54,229.07 411.6,229.07 A26.S1 | v391.28,212.81 381.12,212.81 380.61,212.31 372.99,212.31 371.98,211.29 323.72,211.29 321.18,213.83 304.92,213.83 304.41,213.32 303.91,213.32 302.89,212.31 280.03,212.31 279.01,213.32 267.84,213.32 267.33,213.83 244.98,213.83 243.96,212.81 239.9,212.81 238.37,211.29 226.69,211.29 v226.18,211.8
MC00\
  Route2 0.254: B11.T2 164.71,155.92 164.71,158.46 171.32,165.06 171.83,165.06 172.33,165.57 172.33,166.59 175.38,169.63 176.91,169.63 190.62,183.35 190.62,184.37 195.19,188.94 201.29,188.94 202.31,187.92 B13.F1
  Route15 0.254: A10.R1 155.06,231.61 155.06,230.59 165.22,220.43 165.22,219.42 185.54,199.1 189.1,199.1 198.75,189.45 200.78,189.45 202.31,187.92 B13.F1
MC01  (via drill 0.61)
  Top 0.254: v176.4,123.91 175.89,124.42 175.89,135.09 176.4,135.6 176.4,149.31 175.38,150.33 175.38,166.59 v175.89,167.09 | v128.65,243.8 128.14,243.29 128.14,208.24 v129.15,207.23
  Route2 0.254: v176.4,123.91 173.86,121.37 C11.E1 | v193.16,184.37 v175.89,167.09 | v398.39,213.83 398.9,213.83 408.05,222.97 408.05,223.48 409.06,224.5 409.06,225.51 A26.T1 | v235.33,214.34 210.94,189.95 209.42,189.95 203.32,183.86 203.32,181.83 202.81,181.32 B13.J1
  Route15 0.254: v129.15,207.23 129.15,206.72 145.41,190.46 147.44,190.46 v152.01,185.89 | v193.16,184.37 v191.13,186.4 | B13.J1 202.31,180.81 199.26,183.86 B13.H2
  Bottom 0.254: v193.16,184.37 198.75,184.37 B13.H2 | v128.65,243.8 116.96,243.8 116.45,244.31 A08.L2 | v152.01,185.89 190.62,185.89 v191.13,186.4 | v398.39,213.83 390.77,213.83 390.27,213.32 380.61,213.32 380.11,212.81 372.49,212.81 371.47,211.8 324.23,211.8 321.69,214.34 304.41,214.34 303.91,213.83 303.4,213.83 302.38,212.81 280.54,212.81 279.52,213.83 268.35,213.83 267.84,214.34 v235.33,214.34
MC01\  (via drill 0.61)
  Top 0.254: v159.63,61.43 159.63,116.29 v160.14,116.8 | v170.3,126.96 170.3,130.01 C11.B1 170.3,131.03 170.3,134.07 171.83,135.6 171.83,154.39 172.33,154.9 172.33,160.49 173.86,162.01 173.86,165.06 B11.P1
  Route2 0.254: v180.46,165.57 195.7,180.81 B13.J2 | v159.63,61.43 151.51,53.3 151.51,51.78 D10.E2 | v160.14,116.8 v170.3,126.96
  Bottom 0.254: v180.46,165.57 173.86,165.57 B11.P1
MC02  (via drill 0.61)
  Top 0.254: v164.71,69.56 165.22,70.07 165.22,77.69 165.73,78.19 165.73,147.79 167.25,149.31 167.25,152.36 B11.U2
  Route2 0.254: v169.29,154.39 167.76,152.87 B11.U2 | v176.91,154.39 195.19,172.68 195.7,172.68 v197.73,174.71 | v396.36,210.27 v409.06,222.97 | v241.93,210.27 223.13,191.48 223.13,189.95 v207.89,174.71
  Route15 0.254: D12.E2 183,50.76 179.95,53.81 D12.D2 179.45,54.32 175.38,58.38 175.38,58.89 v164.71,69.56
  Bottom 0.254: v176.91,154.39 v169.29,154.39 | v197.73,174.71 202.31,174.71 B13.L1 202.81,174.71 v207.89,174.71 | v409.06,222.97 411.6,222.97 A26.U1 | v396.36,210.27 391.79,210.27 391.28,209.77 376.55,209.77 375.03,211.29 374.01,211.29 372.99,210.27 321.69,210.27 320.67,211.29 319.65,211.29 318.13,209.77 275.46,209.77 273.93,211.29 272.92,211.29 271.39,209.77 242.44,209.77 v241.93,210.27
MC02\  (via drill 0.61)
  Top 0.254: B13.C1 205.86,196.56 205.86,193 206.88,191.99 206.88,175.22 205.86,174.21 205.86,172.17 B13.M1 205.86,171.16 205.86,168.11 204.34,166.59 v204.34,161.51 | v162.17,67.02 162.68,67.53 162.68,72.61 162.17,73.11 162.17,78.19 161.16,79.21 161.16,88.86 162.17,89.88 162.17,90.89 161.16,91.91 161.16,98.51 162.68,100.04 162.68,101.05 161.67,102.07 161.67,112.23 163.7,114.26 163.7,116.29 162.68,117.31 v162.68,120.87
  Route2 0.254: v145.92,50.25 146.43,50.25 158.11,61.94 158.11,62.45 162.17,66.51 v162.17,67.02 | v162.68,120.87 163.19,120.87 169.29,126.96 169.29,127.47 176.91,135.09 176.91,136.11 194.18,153.38 194.69,153.38 195.7,154.39 197.23,154.39 v204.34,161.51
  Route15 0.254: v145.92,50.25 147.95,48.22 D10.F2
MF00  (via drill 0.61)
  Top 0.254: v229.74,72.61 229.74,84.29 230.25,84.8 230.25,85.81 229.74,86.32 229.74,144.23 v230.25,144.74
  Route2 0.254: v194.69,72.61 173.86,51.78 D11.E1 | v322.19,146.77 336.42,161 336.42,163.03 352.17,178.78 352.17,180.81 357.75,186.4 358.26,186.4 358.77,186.91 358.77,187.41 368.42,197.07 369.44,197.07 392.3,219.93 A25.V1
  Bottom 0.254: v194.69,72.61 195.19,72.1 222.63,72.1 223.13,72.61 v229.74,72.61 | v230.25,144.74 233.29,144.74 234.31,145.76 302.38,145.76 302.89,145.25 303.91,145.25 305.43,146.77 v322.19,146.77
MF00\  (via drill 0.61)
  Top 0.254: v98.17,115.28 98.17,118.33 97.15,119.34 97.15,151.35 v97.66,151.85 | v78.35,173.7 78.35,172.17 B05.M1
  Route15 0.254: v163.7,49.75 161.16,52.29 160.65,52.29 145.92,67.02 145.92,68.54 127.63,86.83 126.61,86.83 111.88,101.56 111.88,102.07 103.25,110.71 102.74,110.71 102.23,111.21 102.23,111.72 98.67,115.28 v98.17,115.28 | v97.66,151.85 78.35,171.16 B05.M1 | v56.51,195.03 64.64,186.91 65.15,186.91 v78.35,173.7
  Bottom 0.254: v163.7,49.75 166.75,49.75 167.76,48.73 170.3,48.73 D11.F1 | v56.51,195.03 56,194.53 53.46,194.53 B04.D2
MF01  (via drill 0.61)
  Top 0.254: v167.25,46.7 167.25,45.17 D11.H2 | v416.68,210.78 416.68,212.31 416.17,212.81 416.17,218.4 415.67,218.91 415.67,235.17 415.16,235.67 415.16,243.8 415.67,244.31 415.67,249.39 416.17,249.9 416.17,265.14 416.68,265.65 416.68,266.66 411.6,271.74 411.6,273.27 A26.A1
  Route2 0.254: v167.25,46.7 173.86,53.3 174.37,53.3 187.57,66.51 v187.57,67.02 | v269.87,66.51 280.54,77.18 282.06,77.18 287.14,82.26 287.14,84.29 303.4,100.55 305.43,100.55 318.64,113.75 318.64,115.79 366.9,164.05 368.93,164.05 384.17,179.29 386.2,179.29 397.89,190.97 397.89,193 415.67,210.78 v416.68,210.78
  Bottom 0.254: v187.57,67.02 188.08,67.53 194.69,67.53 196.21,69.05 220.59,69.05 221.1,68.54 227.71,68.54 228.21,68.03 229.23,68.03 229.74,67.53 250.06,67.53 250.57,67.02 266.31,67.02 266.82,66.51 v269.87,66.51
MF01\  (via drill 0.61)
  Top 0.254: v128.65,74.64 128.14,75.15 128.14,129.5 129.15,130.52 v129.15,139.15 | v56,188.43 56,190.46 B04.E2 | v75.31,170.14 75.31,168.62 B05.N1
  Route15 0.254: v158.11,42.63 145.41,55.33 145.41,57.87 139.31,63.97 139.31,64.48 129.15,74.64 v128.65,74.64 | v102.74,139.66 81.4,161 80.89,161 77.34,164.55 77.34,166.08 75.31,168.11 B05.N1 | v56,188.43 67.69,176.75 68.7,176.75 v75.31,170.14
  Bottom 0.254: v158.11,42.63 161.16,42.63 161.67,42.13 163.7,42.13 D11.J2 | v129.15,139.15 128.65,138.65 104.77,138.65 103.75,139.66 v102.74,139.66
MF02  (via drill 0.61)
  Top 0.254: v171.83,6.57 172.33,7.07 172.33,29.43 171.32,30.44 171.32,34.51 170.81,35.01 D11.L1 | v381.63,4.53 383.15,6.06 383.15,180.81 381.63,182.33 381.63,184.37 382.14,184.87 382.14,193 v381.63,193.51 | v406.52,218.4 407.03,218.91 407.03,228.05 406.52,228.56 406.52,239.74 407.54,240.75 407.54,267.17 408.55,268.19 408.55,269.71 A26.B1
  Route2 0.254: v381.63,193.51 v406.52,218.4
  Bottom 0.254: v171.83,6.57 172.33,6.06 179.45,6.06 179.95,5.55 194.18,5.55 195.19,4.53 268.85,4.53 270.38,6.06 270.89,6.06 271.39,6.57 283.59,6.57 284.6,5.55 286.63,5.55 288.16,4.03 381.12,4.03 v381.63,4.53
MF02\  (via drill 0.61)
  Route2 0.254: B05.D2 68.7,193.51 58.03,182.84 58.03,181.32 56,179.29 56,178.78 B04.K2 56,177.76 54.99,176.75 54.99,175.22 48.89,169.13 48.89,165.06 34.16,150.33 33.14,150.33 25.01,142.2 25.01,139.66 15.36,130.01 v15.36,129.5
  Route15 0.254: v131.69,30.95 113.41,49.24 113.41,51.27 103.25,61.43 102.74,61.43 v99.69,64.48 | v70.73,67.02 60.07,77.69 59.56,77.69 48.89,88.35 48.89,89.88 42.29,96.48 42.29,97.5 40.25,99.53 39.75,99.53 36.7,102.58 36.19,102.58 35.17,103.59 35.17,106.13 28.06,113.25 27.05,113.25 26.03,114.26 26.03,115.79 23.49,118.33 23.49,118.83 18.41,123.91 18.41,126.45 v15.36,129.5
  Bottom 0.254: v131.69,30.95 168.78,30.95 168.78,31.46 169.79,32.47 173.35,32.47 D11.M1 | v99.69,64.48 96.64,64.48 94.1,67.02 89.02,67.02 88.51,67.53 71.24,67.53 v70.73,67.02
MK_BLK_END
  Route15 0.254: CD18.BU1 284.6,12.66 281.55,12.66 276.98,8.09 275.46,9.61 275.46,25.87 288.67,39.08 288.67,88.86 276.47,101.05 276.47,102.07 273.93,104.61 273.93,107.66 258.19,123.41 258.19,124.42 239.39,143.22 238.88,143.22 238.37,143.73 238.37,146.77 221.61,163.54 219.58,163.54 215.01,168.11 215.01,169.63 210.43,174.21 210.43,175.73 197.23,188.94 194.18,188.94 180.97,202.15 179.45,202.15 168.78,212.81 167.76,212.81 166.75,213.83 164.71,213.83 162.17,216.37 161.16,216.37 149.98,227.55 147.44,227.55 144.39,230.59 143.38,230.59 142.87,231.1 134.23,231.1 129.15,226.02 131.19,223.99 132.2,223.99 134.74,221.45 136.77,221.45 137.79,222.47 136.27,223.99 135.25,223.99 134.74,224.5 133.73,224.5 132.71,225.51 A09.T2
MK_BLK_END\
  Bottom 0.254: CD18.BV1 282.06,10.63 283.08,11.65 290.19,11.65 306.45,27.9 319.15,27.9 337.94,46.7 349.63,46.7 400.93,98.01 400.93,195.54 415.16,209.77 417.19,209.77 419.73,212.31 419.73,282.41 360.8,282.41 360.29,281.9 122.55,281.9 118.49,277.84 10.28,277.84 4.19,271.74 4.19,265.14 139.82,265.14 141.35,266.66 A09.C1
MK_BLK_MK  (via drill 0.61)
  Top 0.254: v278.51,119.34 278.51,120.87 CD18.AE2
  Route2 0.254: D10.B1 155.06,60.92 157.6,63.46 D10.A1 158.11,64.48 v166.24,72.61 | v278.51,119.34 269.36,110.2 268.35,110.2 263.27,105.12 263.27,104.61 254.63,95.97 254.63,94.96 v230.25,70.57
  Route15 0.254: v168.78,70.57 168.27,70.57 v166.24,72.61
  Bottom 0.254: v230.25,70.57 223.13,70.57 222.63,71.08 188.08,71.08 187.57,70.57 v168.78,70.57
MK_BLK_START\  (via drill 0.61)
  Top 0.254: v281.55,122.39 281.55,118.33 CD18.AF1 | v254.12,150.84 254.63,151.35 254.63,167.6 254.12,168.11 254.12,205.7 v253.61,206.21
  Route15 0.254: v281.55,122.39 270.89,133.06 270.89,134.07 v254.12,150.84 | v204.34,205.19 198.24,211.29 198.24,211.8 189.61,220.43 188.59,220.43 178.43,230.59 178.43,232.63 169.29,241.77 169.29,243.29 163.19,249.39 163.19,250.41 160.14,253.45 160.14,254.98 141.85,273.27 A09.A1
  Bottom 0.254: v253.61,206.21 253.11,206.72 241.42,206.72 239.9,205.19 235.83,205.19 234.82,206.21 215.51,206.21 214.5,205.19 208.91,205.19 208.4,204.69 207.39,204.69 206.88,205.19 v204.34,205.19
MK_DATA\  (via drill 0.61)
  Top 0.254: v278.51,87.34 278.51,83.27 CD18.AU2 | v219.58,148.81 220.09,149.31 v220.09,200.62
  Route15 0.254: v278.51,87.34 272.41,93.43 272.41,95.47 263.27,104.61 263.27,105.63 262.76,106.13 262.25,106.13 255.65,112.74 255.65,114.26 242.44,127.47 240.91,127.47 v219.58,148.81 | v220.09,200.62 216.53,204.18 216.53,205.19 214.5,207.23 213.99,207.23 205.86,215.35 205.86,215.86 205.35,216.37 203.32,216.37 194.18,225.51 194.18,228.05 178.94,243.29 177.92,243.29 174.87,246.34 174.87,248.88 163.7,260.06 162.17,260.06 v150.49,271.74
  Bottom 0.254: v150.49,271.74 147.44,271.74 145.41,269.71 139.31,269.71 A09.B1
MK_END
  Route15 0.254: CD18.AF2 275.46,118.33 279.52,118.33 284.6,123.41 275.97,132.04 274.95,132.04 254.12,152.87 254.12,153.38 240.91,166.59 240.91,172.17 226.18,186.91 226.18,188.43 224.66,189.95 224.66,198.08 220.09,202.65 220.09,205.7 194.69,231.1 194.69,232.63 180.97,246.34 178.43,246.34 170.81,253.96 170.81,254.98 162.68,263.11 162.68,264.63 152.52,274.79 133.73,274.79 126.11,267.17 A08.C1
MK_END\
  Route15 0.254: CD18.AH2 278,114.77 276.47,114.77 273.93,117.31 273.93,126.45 267.84,132.55 267.84,134.07 242.95,158.97 241.93,158.97 236.85,164.05 236.34,164.05 226.18,174.21 226.18,177.25 210.43,193 210.43,194.53 200.27,204.69 199.26,204.69 178.94,225.01 178.94,228.56 174.37,233.13 171.83,233.13 165.22,239.74 163.19,239.74 146.43,256.5 146.43,258.53 141.35,263.61 139.82,263.61 139.31,264.12 A09.D1
MKT  (via drill 0.61)
  Top 0.254: v223.13,109.18 223.13,115.79 222.63,116.29 v222.63,123.41 | v224.15,168.62 223.64,168.11 223.64,152.36 v224.15,151.85 | v259.2,276.82 258.19,275.81 258.19,274.79 257.68,274.28 257.68,240.25 257.17,239.74 257.17,223.99 258.19,222.97 258.19,221.45 257.68,220.94 257.68,206.21 256.66,205.19 256.66,177.25 v257.17,176.75
  Route2 0.254: v230.25,174.71 v224.15,168.62 | v224.15,151.85 v208.91,136.61
  Route15 0.254: v223.13,109.18 227.2,105.12 C15.L2 | v222.63,123.41 214.5,131.53 213.99,131.53 v208.91,136.61 199.77,145.76 199.26,145.76 196.21,148.81 B13.V2 195.7,149.31 v186.05,158.97 | v403.47,254.47 397.89,260.06 397.89,261.07 v382.14,276.82
  Bottom 0.254: v186.05,158.97 183.51,158.97 B12.S2 | v230.25,174.71 233.8,174.71 B15.L1 234.31,174.71 241.42,174.71 243.45,176.75 v257.17,176.75 | v403.47,254.47 405,254.47 A26.H2 | v382.14,276.82 360.29,276.82 359.79,276.31 259.71,276.31 v259.2,276.82
MKT\  (via drill 0.61)
  Top 0.254: v196.21,153.38 196.21,155.41 B13.T2 | v151.51,47.21 151.51,45.17 D10.H2 | v216.53,77.18 216.53,98.01 v216.02,98.51 | v209.93,141.19 209.93,132.55 209.42,132.04 v209.42,105.12
  Route2 0.254: v151.51,47.21 162.68,58.38 163.7,58.38 v182.49,77.18
  Route15 0.254: v190.11,161 195.7,155.41 B13.T2 | v200.27,149.31 v196.21,153.38 | v209.93,141.19 202.31,148.81 B13.V1 | v216.02,98.51 v209.42,105.12
  Bottom 0.254: v190.11,161 156.08,161 155.57,161.51 B10.R1 | v200.27,149.31 202.31,149.31 B13.V1 | v182.49,77.18 183,77.69 216.02,77.69 v216.53,77.18 | v216.02,98.51 216.02,99.02 217.55,99.02 C14.N1
MKTK
  Bottom 0.254: A08.R2 115.95,232.63 111.37,237.2 111.37,251.93 113.41,251.93 114.42,252.95 134.74,252.95 138.3,249.39 154.55,249.39 157.6,246.34 174.87,246.34 175.38,245.83 178.43,245.83 179.45,246.85 298.32,246.85 304.92,240.25 338.45,240.25 341.5,243.29 406.01,243.29 410.59,238.72 410.59,236.69 413.13,236.69 413.13,234.15 397.38,234.15 396.36,235.17 A25.P1
MKTK\
  Route2 0.254: B04.B1 59.56,201.13 59.56,205.7 77.85,223.99 79.88,223.99 90.55,234.66 91.56,234.66 93.59,236.69 101.72,236.69 111.88,246.85 115.95,246.85 118.49,249.39 122.04,249.39 125.6,245.83 131.19,251.42 131.19,251.93 131.69,252.44 135.25,252.44 137.79,249.9 135.76,247.87 A09.K2
  Bottom 0.254: A08.P2 118.99,235.67 118.99,240.25 118.49,240.25 114.93,243.8 114.93,252.44 118.99,252.44 122.04,249.39 134.23,249.39 135.25,248.37 A09.K2
MR00  (via drill 0.61)
  Top 0.254: v392.81,267.68 392.81,264.63 A25.D1 | v271.39,226.02 v271.39,277.33
  Route2 0.254: v155.06,166.08 v158.11,169.13 | v271.39,226.02 270.89,226.02 248.53,203.67 248.53,203.16 237.87,192.49 236.85,192.49 234.82,190.46 234.82,189.95 234.31,189.45 233.8,189.45 223.13,178.78 223.13,177.76 218.05,172.68 216.02,172.68 215.01,171.67 B14.M2
  Route15 0.254: v392.81,267.68 392.3,267.68 383.15,276.82 v383.15,277.84
  Bottom 0.254: v155.06,166.08 154.55,166.59 108.83,166.59 107.82,165.57 104.26,165.57 B07.P2 | v158.11,169.13 159.63,169.13 160.14,169.63 180.97,169.63 181.48,169.13 184.53,169.13 185.54,170.14 211.96,170.14 213.48,171.67 214.5,171.67 B14.M2 | v383.15,277.84 381.63,277.84 381.12,277.33 359.79,277.33 359.28,276.82 271.9,276.82 v271.39,277.33
MR00\  (via drill 0.61)
  Top 0.254: v46.86,180.3 46.86,183.86 B03.H1
  Route15 0.254: v82.42,179.79 100.2,162.01 B07.R2
  Bottom 0.254: v82.42,179.79 64.13,179.79 63.62,180.3 v46.86,180.3
MR01  (via drill 0.61)
  Top 0.254: v103.75,99.53 103.75,95.97 C07.P2 | v186.56,137.63 186.56,131.03 C12.B1 | v395.85,256.5 395.85,260.57 A25.E1 | v303.4,205.19 303.4,180.81 302.38,179.79 302.38,173.19 301.87,172.68 301.87,150.33 301.37,149.82 v301.37,138.65
  Route2 0.254: v103.75,99.53 114.42,110.2 114.42,111.72 114.93,112.23 114.93,112.74 123.06,120.87 123.57,120.87 127.63,124.93 127.63,127.98 137.28,137.63 v137.79,137.63 | v395.85,256.5 381.63,242.28 381.63,241.26 373.5,233.13 372.99,233.13 372.49,232.63 372.49,232.12 370.45,230.09 368.42,230.09 365.88,227.55 365.88,227.04 v345.56,206.72
  Bottom 0.254: v137.79,137.63 138.3,137.12 153.03,137.12 153.54,136.61 160.65,136.61 161.67,137.63 v186.56,137.63 188.08,139.15 201.29,139.15 201.8,138.65 204.85,138.65 205.35,139.15 211.45,139.15 212.97,140.68 232.79,140.68 233.8,139.66 251.58,139.66 252.09,139.15 293.24,139.15 293.75,138.65 v301.37,138.65 | v345.56,206.72 345.05,207.23 322.7,207.23 321.18,205.7 311.02,205.7 310.51,205.19 v303.4,205.19
MR01\  (via drill 0.61)
  Top 0.254: v97.66,113.75 v97.66,94.45 | v221.1,194.02 221.1,196.56 B14.C1
  Route2 0.254: v221.1,194.02 206.37,179.29 204.85,179.29 191.13,165.57 191.13,165.06 186.05,159.98 185.54,159.98 185.03,159.47 185.03,158.46 178.43,151.85 178.43,150.84 v168.27,140.68 | v119.5,141.19 115.95,137.63 114.93,137.63 111.88,134.58 111.88,133.57 100.71,122.39 99.69,122.39 99.18,121.88 99.18,121.37 v94.61,116.8
  Route15 0.254: v97.66,94.45 99.69,92.42 C07.R2 | v97.66,113.75 v94.61,116.8 83.43,127.98 83.43,132.55 66.67,149.31 66.67,151.85 50.41,168.11 50.41,168.62 46.86,172.17 B03.M1
  Bottom 0.254: v168.27,140.68 143.38,140.68 142.87,140.17 133.22,140.17 132.2,141.19 v119.5,141.19
N$1
  Bottom 0.254: B06.S2 88.51,159.47 89.02,159.98 112.39,159.98 112.9,159.47 119.5,159.47 B08.S2
N$2
  Top 0.254: C16.N2 242.95,99.53 242.95,104.61 C16.L2 | C16.M2 246.5,102.58 246.5,108.17 C16.K2
  Route2 0.254: C17.B1 265.81,130.01 265.81,128.49 260.22,122.9 259.2,122.9 248.53,112.23 248.53,110.2 247.01,108.67 C16.K2
  Bottom 0.254: C16.L2 243.96,105.63 246.5,108.17 C16.K2
N$3
  Top 0.254: B11.S2 166.75,159.47 166.75,163.54 166.24,164.05 166.24,181.32 169.29,184.37 169.29,227.55 170.3,228.56 170.3,231.61 A11.R1
N$4
  Top 0.254: D13.R2 196.21,22.31 198.75,19.77 D13.S2
N$5  (via drill 0.61)
  Top 0.254: v251.58,89.37 251.58,142.2 255.14,145.76 255.14,168.11 254.63,168.62 254.63,236.69 254.12,236.69 253.61,237.2 253.61,239.74 254.63,240.75 v254.63,244.31 | v246.5,252.44 247.01,252.44 247.01,253.96 A16.H2
  Route2 0.254: v251.58,89.37 251.07,89.37 243.45,81.75 243.45,80.23 C16.V2
  Route15 0.254: v254.63,244.31 254.12,244.31 246.5,251.93 v246.5,252.44
N$6
  Top 0.254: D12.D1 186.56,54.83 189.1,57.37 D12.C1 189.1,57.87 186.56,60.41 D12.B1
  Bottom 0.254: D12.B1 186.56,61.43 188.59,63.46 189.1,63.46 D12.A1 | D13.F2 195.7,48.73 191.64,52.79 187.57,52.79 186.56,53.81 D12.D1
N$7
  Top 0.254: A12.J1 186.05,250.91 186.05,247.87 185.03,246.85 185.03,243.8 185.54,243.29 185.54,239.74 186.05,239.23 A12.N1 186.56,238.21 187.57,237.2 187.57,227.55 190.11,227.55 190.62,228.05 190.62,234.66 190.11,235.17 A12.P1
N$8
  Top 0.254: D17.F2 259.71,48.73 261.23,50.25 261.23,78.19 264.28,81.24 264.28,90.89 265.3,91.91 C17.R1
N$10  (via drill 0.61)
  Top 0.254: v191.13,145.25 191.13,166.59 189.61,168.11 189.61,171.16 B12.M1
  Route2 0.254: v191.13,145.25 173.86,127.98 C11.C1
N$11  (via drill 0.61)
  Top 0.254: v170.3,121.88 170.3,118.33 C11.F1 | v188.08,140.68 188.08,156.93 187.07,157.95 187.07,159.47 186.56,159.98 186.56,161.51 B12.R1
  Route2 0.254: v170.3,121.88 175.38,126.96 175.38,128.49 187.57,140.68 v188.08,140.68
N$12
  Bottom 0.254: D17.D2 259.71,53.81 261.74,51.78 262.25,51.78 D17.E2
N$13
  Top 0.254: B15.F1 234.31,187.92 235.83,189.45 235.83,213.32 236.34,213.83 236.34,220.94 235.33,221.96 235.33,246.34 225.17,256.5 215.51,256.5 215.51,254.98 A14.H2 | A14.K2 214.5,248.37 211.96,250.91 A14.J2
  Bottom 0.254: A14.J2 211.96,251.93 213.99,253.96 214.5,253.96 A14.H2
N$14
  Top 0.254: A16.D2 244.47,263.61 246.5,261.58 246.5,261.07 A16.E2
N$15
  Top 0.254: C17.C1 268.35,127.98 263.77,127.98 263.77,135.6 255.65,143.73 255.65,248.37 247.01,257.01 244.47,257.01 A16.F2
N$16  (via drill 0.61)
  Top 0.254: v239.39,144.23 239.9,144.74 239.9,180.3 239.39,180.81 v239.39,264.12
  Route2 0.254: A15.D1 234.31,264.12 236.85,266.66 A15.C1
  Route15 0.254: v239.39,144.23 259.2,124.42 C17.D2 | v239.39,264.12 236.85,266.66 A15.C1
N$17  (via drill 0.61)
  Top 0.254: v215.51,66 215.51,77.69 216.02,78.19 216.02,96.99 215.01,98.01 215.01,99.02 216.53,100.55 216.53,132.55 217.55,133.57 217.55,146.27 216.53,147.28 216.53,154.9 215.01,156.43 215.01,158.46 B14.S2 215.01,159.47 215.01,160.49 216.53,162.01 216.53,168.11 v216.02,168.62
  Route15 0.254: v215.51,66 227.2,54.32 D15.D2
  Bottom 0.254: v216.02,168.62 217.55,168.62 B14.N1
N$18
  Top 0.254: A14.P2 214.5,235.67 211.96,238.21 A14.N2 211.96,238.72 214.5,241.26 A14.M2
  Route15 0.254: B15.F2 227.2,187.92 227.2,189.95 236.85,199.61 225.17,211.29 225.17,222.97 217.04,231.1 217.04,233.64 215.51,235.17 A14.P2
N$19
  Route2 0.254: A14.L2 211.96,245.33 214.5,245.33 219.58,250.41 219.58,252.44 221.1,253.96 A14.H1
N$20
  Top 0.254: A16.R2 244.47,231.61 246.5,229.58 A16.S2
N$21
  Top 0.254: A14.E2 214.5,261.07 211.96,263.61 A14.D2
N$22  (via drill 0.61)
  Top 0.254: v167.76,211.29 167.76,222.47 A11.U2
  Route2 0.254: v197.23,211.29 211.45,225.51 A14.T2
  Bottom 0.254: v167.76,211.29 168.27,210.78 196.72,210.78 v197.23,211.29
N$23
  Route2 0.254: A11.P2 167.76,235.67 167.76,237.71 173.35,243.29 176.4,243.29 182.49,249.39 191.64,249.39 194.69,246.34 200.27,246.34 211.45,257.52 A14.F2
N$24
  Top 0.254: C16.S1 252.6,88.86 252.09,88.35 250.57,88.35 250.57,90.89 251.07,91.4 251.07,171.16 247.52,174.71 247.52,177.25 247.01,177.76 B16.K2
N$25
  Top 0.254: A14.V2 211.96,219.93 212.97,220.94 212.97,230.59 211.96,231.61 A14.R2
N$26
  Bottom 0.254: A14.S2 215.51,228.56 221.1,228.56 A14.S1
N$27
  Bottom 0.254: D15.N2 228.21,28.41 228.21,23.84 228.72,23.84 230.25,22.31 230.25,19.77 D15.S2
N$28  (via drill 0.61)
  Top 0.254: v203.32,97.5 203.32,116.29 204.34,117.31 204.34,127.47 203.83,127.98 203.83,138.65 203.32,139.15 v203.32,144.74
  Route2 0.254: v203.32,97.5 203.32,96.99 191.64,85.31 191.13,85.31 189.61,83.78 189.61,83.27 C12.U1
  Route15 0.254: v203.32,144.74 193.67,154.39 193.67,156.43 190.11,159.98 189.61,159.98 188.08,161.51 188.08,162.52 180.97,169.63 180.97,173.19 179.95,174.21 B12.L2
N$29
  Bottom 0.254: B16.E2 246.5,190.97 243.96,193.51 B16.D2
N$30
  Route15 0.254: C17.E2 262.76,120.87 266.82,120.87 267.84,119.85 270.38,119.85 275.97,114.26 276.98,114.26 278,113.25 279.01,113.25 287.65,121.88 283.59,125.95 283.59,134.58 282.06,136.11 282.06,141.19 274.44,148.81 274.44,151.35 258.19,167.6 258.19,170.65 245.49,183.35 245.49,184.87 243.45,186.91 B16.F2
N$31
  Top 0.254: C17.F2 259.71,117.82 264.28,117.82 264.28,117.31 268.35,113.25 270.38,113.25 270.38,130.01 261.23,139.15 261.23,290.54 260.73,291.05 228.72,291.05 228.72,265.14 228.21,264.63 A15.D2
  Bottom 0.254: A15.E2 230.75,261.07 230.75,263.61 228.21,263.61 A15.D2
N$32  (via drill 0.61)
  Top 0.254: v254.63,112.74 v254.63,140.68
  Route15 0.254: v254.63,112.74 v262.25,105.12 | v254.63,140.68 236.85,158.46 B15.S1
  Bottom 0.254: v262.25,105.12 265.3,105.12 C17.L1
N$33  (via drill 0.61)
  Top 0.254: v144.9,168.62 144.39,169.13 144.39,185.38 v144.9,185.89 | v119.5,211.8 119.5,222.47 A08.U2
  Route15 0.254: v144.9,168.62 v154.55,158.97 | v144.9,185.89 127.63,203.16 127.63,203.67 v119.5,211.8
  Bottom 0.254: v154.55,158.97 157.6,158.97 B10.S1
N$34
  Top 0.254: D16.T2 243.96,16.73 245.49,18.25 245.49,67.53 253.61,75.65 253.61,80.23 257.68,84.29 262.25,84.29 262.25,88.86 C17.S2
N$35  (via drill 0.61)
  Top 0.254: v141.35,187.41 140.84,187.92 140.84,198.08 141.35,198.59 141.35,201.13 140.33,202.15 140.33,221.96 140.84,222.47 140.84,223.99 141.35,224.5 141.35,225.51 139.31,227.55 139.31,230.59 139.82,231.1 139.82,239.74 139.31,240.25 139.31,242.79 140.33,243.8 140.33,251.93 138.81,253.45 138.81,257.01 A09.F1 | v134.23,179.79 134.23,148.3 v134.74,147.79
  Route2 0.254: v141.35,187.41 135.25,181.32 135.25,180.81 v134.23,179.79 | v134.74,147.79 134.74,146.77 124.07,136.11 v124.07,133.57
  Route15 0.254: v124.07,133.57 126.61,131.03 126.61,128.99 130.17,125.44 130.17,124.42 135.76,118.83 136.77,118.83 137.28,118.33 137.28,116.8 143.89,110.2 143.89,105.12 145.41,103.59 145.92,103.59 150.49,99.02 150.49,97.5 152.01,95.97 C10.P2
N$36
  Route15 0.254: C14.P1 221.1,95.97 221.1,98.01 212.47,106.64 211.45,106.64 197.73,120.36 197.73,122.39 196.21,123.91 C13.D2
N$37
  Bottom 0.254: B16.R2 243.96,161.51 245.99,159.47 246.5,159.47 B16.S2
N$38
  Top 0.254: C15.H1 237.36,115.28 238.37,116.29 238.37,125.95 237.36,126.96 C15.C1
N$39
  Top 0.254: C15.J1 233.8,112.23 233.8,117.31 C15.F1
N$40
  Top 0.254: D14.V2 211.96,10.63 213.48,12.15 213.48,31.46 213.99,31.97 D14.M2
N$41
  Top 0.254: D14.V1 218.05,10.63 219.58,12.15 219.58,24.35 220.59,25.36 D14.P1
N$42
  Top 0.254: C11.L1 170.81,105.63 173.35,108.17 C11.K1
N$43
  Top 0.254: A12.T2 179.45,226.53 178.94,227.04 178.94,237.71 179.45,238.21 A12.N2
N$44  (via drill 0.61)
  Top 0.254: v170.3,100.55 170.3,99.53 C11.N1 | v176.4,106.64 175.89,107.15 175.89,119.85 178.43,122.39 178.43,132.04 v177.41,133.06 | v183,138.65 183,152.36 B12.U2
  Route2 0.254: v170.3,100.55 v176.4,106.64 | v177.41,133.06 v183,138.65
N$45
  Top 0.254: A12.U2 183,222.97 183,228.56 A12.S2
N$46
  Bottom 0.254: A09.J1 139.31,250.91 140.33,249.9 156.08,249.9 157.6,248.37 A10.K1
N$47
  Route15 0.254: C13.C1 205.35,127.98 205.35,130.01 200.27,135.09 200.27,143.73 186.05,157.95 185.54,157.95 185.03,158.46 185.03,159.47 179.45,165.06 179.45,167.09 178.94,167.6 178.94,170.65 169.29,180.3 169.29,181.32 168.27,182.33 168.27,183.35 167.76,183.86 B11.H2
N$48  (via drill 0.61)
  Top 0.254: v178.43,100.55 178.43,113.25 179.45,114.26 179.45,116.29 179.95,116.8 181.99,116.8 v181.99,128.49 | v190.11,136.61 190.11,145.76 190.62,146.27 190.62,157.95 190.11,158.46 B12.S1
  Route2 0.254: v178.43,100.55 173.86,95.97 C11.P1 | v181.99,128.49 v190.11,136.61
N$49
  Route15 0.254: B11.E2 167.76,190.46 169.29,190.46 178.94,180.81 178.94,180.3 182.49,176.75 184.53,176.75 186.05,175.22 B12.L1
N$50  (via drill 0.61)
  Route2 0.254: v224.66,87.85 225.17,87.85 232.79,95.47 v232.79,95.97
  Bottom 0.254: v224.66,87.85 185.03,87.85 184.02,88.86 C12.S2 | v232.79,95.97 236.85,95.97 C15.P1
N$51
  Route15 0.254: C12.F1 186.56,118.33 186.56,119.34 185.54,120.36 185.54,121.37 182.49,124.42 182.49,126.45 178.94,130.01 178.94,133.06 176.91,135.09 176.91,145.76 179.95,148.81 B12.V2
N$52
  Route2 0.254: C11.S1 173.35,88.86 173.35,86.83 165.22,78.7 164.21,78.7 157.09,71.59 153.54,71.59 140.84,58.89 140.84,30.95 143.89,27.9 151.51,27.9 157.09,33.49 160.14,33.49 169.79,43.14 173.86,43.14 174.87,44.16 174.87,48.22 178.94,52.29 178.94,55.84 194.69,71.59 195.19,71.59 195.7,72.1 195.7,75.65 204.34,84.29 206.88,84.29 220.09,97.5 220.09,99.02 222.63,101.56 222.63,102.58 224.66,104.61 224.66,105.63 225.17,106.13 226.18,106.13 236.34,116.29 238.37,116.29 280.03,157.95 280.03,170.65 286.63,177.25 286.63,179.29 299.84,192.49 301.37,192.49 311.53,202.65 311.53,204.69 330.83,223.99 332.86,223.99 349.63,240.75 349.63,242.28 354.71,247.36 354.71,248.88 362.83,257.01 362.83,258.03 349.12,271.74 346.58,269.2 336.42,269.2 323.72,256.5 322.7,256.5 302.38,236.18 302.38,235.17 291.71,224.5 290.7,224.5 270.38,204.18 270.38,203.16 252.6,185.38 252.09,185.38 242.44,175.73 242.44,174.71 228.72,161 227.71,161 208.91,142.2 208.91,141.19 191.13,123.41 191.13,122.39 190.11,121.37 C12.E1
N$53
  Top 0.254: C15.R1 233.8,92.93 233.8,98.51 C15.N1
N$54  (via drill 0.61)
  Route15 0.254: v166.75,117.82 v171.32,113.25
  Bottom 0.254: v166.75,117.82 164.71,117.82 C11.F2 | v171.32,113.25 185.54,113.25 187.07,114.77 189.61,114.77 C12.H1
N$55
  Bottom 0.254: B11.D2 164.71,193.51 166.24,191.99 188.08,191.99 189.1,190.97 B12.E1
N$56
  Bottom 0.254: B11.F2 163.7,187.92 163.7,192.49 163.19,192.49 162.68,193 162.68,195.03 169.29,195.03 170.3,194.02 B11.D1
N$58
  Top 0.254: B08.V2 115.95,149.82 115.44,150.33 115.44,189.45 115.95,189.95 115.95,191.99 115.44,192.49 115.44,207.23 115.95,207.73 115.95,217.39 114.93,218.4 114.93,266.15 125.6,276.82 172.33,276.82 172.33,255.49 170.81,255.49 170.81,253.45 171.83,252.44 171.83,237.2 170.81,236.18 170.81,234.15 172.33,232.63 172.33,226.53 173.35,225.51 173.35,224.5 172.84,223.99 170.81,223.99 170.81,219.93 A11.V1
N$59
  Bottom 0.254: C11.V2 164.71,80.23 165.73,81.24 200.78,81.24 201.8,80.23 C13.V1
N$60  (via drill 0.61)
  Top 0.254: v181.99,99.53 v181.99,115.28 | v194.69,128.49 194.18,128.99 194.18,157.95 194.69,158.46 194.69,159.47 193.67,160.49 v193.67,176.75
  Route2 0.254: v181.99,115.28 186.56,119.85 187.07,119.85 187.57,120.36 187.57,121.37 v194.69,128.49
  Bottom 0.254: v181.99,99.53 183,99.53 183.51,99.02 186.05,99.02 C12.N1 | v193.67,176.75 186.56,176.75 185.54,177.76 183.51,177.76 B12.K2
N$61  (via drill 0.61)
  Top 0.254: v161.67,100.55 161.16,101.05 161.16,112.74 163.19,114.77 163.19,115.79 162.17,116.8 162.17,118.33 160.65,119.85 160.65,147.79 161.16,148.3 161.16,149.31 v161.67,149.82
  Route2 0.254: v161.67,149.82 163.7,151.85 163.7,152.36 169.79,158.46 170.3,158.46 176.91,165.06 176.91,167.09 182.49,172.68 183,172.17 B12.M2
  Route15 0.254: v166.75,100.55 178.94,88.35 180.46,88.35 187.07,81.75 187.07,80.23 C12.V1
  Bottom 0.254: v161.67,100.55 v166.75,100.55
N$62
  Top 0.254: B12.N2 180.46,168.62 180.97,169.13 180.97,173.7 181.48,174.21 181.48,179.79 180.46,180.81 B12.J2
N$63  (via drill 0.61)
  Route2 0.254: v200.27,169.13 v207.89,176.75
  Bottom 0.254: v200.27,169.13 198.75,169.13 198.24,168.62 196.72,168.62 B13.N2 | v207.89,176.75 232.79,176.75 233.8,177.76 236.85,177.76 B15.K1
N$64
  Route2 0.254: A12.K2 183.51,247.87 183.51,243.8 189.61,237.71 188.08,236.18 188.08,232.12 184.02,228.05 184.02,225.51 178.94,220.43 178.94,218.91 161.16,201.13 161.16,200.62 158.11,197.57 B10.C1
  Bottom 0.254: B10.D1 155.57,194.02 158.11,196.56 B10.C1
N$65
  Route15 0.254: C11.T2 164.71,86.32 167.25,88.86 C11.S2
N$66  (via drill 0.61)
  Top 0.254: v173.86,257.52 175.38,255.99 175.38,247.87 174.87,247.36 174.87,243.8 175.38,243.29 175.38,238.21 175.89,237.71 v175.89,220.94
  Route2 0.254: B10.B1 155.06,200.62 157.6,203.16 B10.A1 158.62,203.67 v175.89,220.94
  Bottom 0.254: v173.86,257.52 179.45,257.52 A12.F2
N$67
  Bottom 0.254: D10.P2 151,26.38 149.98,27.39 130.17,27.39 126.61,30.95 124.58,30.95 115.44,40.09 115.44,52.79 138.3,52.79 141.85,49.24 148.46,49.24 149.47,50.25 150.49,50.25 151.51,49.24 160.65,49.24 166.75,43.14 209.93,43.14 210.94,42.13 D14.J2
N$68
  Bottom 0.254: D14.H1 220.59,45.17 220.59,49.75 218.56,49.75 214.5,53.81 211.96,53.81 D14.D2
N$69
  Top 0.254: D14.C1 220.59,57.87 220.59,63.46 D14.A1
N$70
  Route15 0.254: B11.U1 173.35,152.36 169.29,152.36 157.6,164.05 157.09,164.05 156.59,164.55 156.59,171.16 148.97,178.78 148.97,179.29 148.46,179.79 146.43,179.79 143.38,182.84 141.35,182.84 131.19,193 131.19,194.53 119.5,206.21 119.5,210.27 118.49,211.29 118.49,217.89 117.47,218.91 117.47,219.93 118.99,221.45 123.57,221.45 126.11,218.91 129.66,218.91 131.69,216.88 133.22,216.88 133.73,216.37 142.36,216.37 156.59,202.15 157.6,202.15 159.63,200.11 162.17,200.11 169.79,192.49 171.83,192.49 173.35,190.97 B11.E1
N$71
  Bottom 0.254: C17.F1 265.3,117.31 265.3,112.74 264.79,112.74 264.28,112.23 264.28,110.2 287.14,110.2 301.87,124.93 303.91,124.93 323.21,144.23 323.21,148.3 316.61,148.3 314.07,150.84 283.08,150.84 269.87,164.05 266.31,164.05 263.27,167.09 243.45,167.09 242.44,166.08 238.88,166.08 236.85,168.11 234.31,168.11 B15.N1
N$72  (via drill 0.61)
  Top 0.254: v175.89,168.62 175.38,169.13 v175.38,181.83
  Route15 0.254: v175.38,181.83 173.35,183.86 B11.H1
  Bottom 0.254: v175.89,168.62 170.81,168.62 B11.N1
N$73
  Bottom 0.254: B08.N1 123.06,168.11 132.2,168.11 B09.N2
N$76  (via drill 0.61)
  Top 0.254: v211.96,101.05 211.96,104.61 C14.L2
  Route15 0.254: v223.64,89.37 v211.96,101.05
  Bottom 0.254: v223.64,89.37 230.25,89.37 C15.S2
N$77
  Route15 0.254: B10.F1 155.57,187.41 156.59,187.41 162.68,181.32 162.68,180.81 163.7,179.79 164.71,179.79 167.25,182.33 166.24,183.35 166.24,185.38 167.25,186.4 168.78,184.87 168.78,182.84 170.3,181.32 B11.J1
N$78  (via drill 0.61)
  Top 0.254: v267.84,125.95 267.84,118.83 268.85,117.82 268.85,115.28 C17.H1
  Route15 0.254: v196.72,141.69 188.59,149.82 188.59,150.33 175.38,163.54 172.33,163.54 165.73,170.14 164.21,170.14 161.67,172.68 161.67,174.21 158.11,177.76 B10.K1 | v253.11,140.68 v267.84,125.95
  Bottom 0.254: v196.72,141.69 207.89,141.69 209.42,140.17 210.43,140.17 211.96,141.69 233.8,141.69 234.82,140.68 v253.11,140.68
N$79
  Bottom 0.254: C13.N2 196.21,99.53 196.72,100.04 203.32,100.04 204.34,99.02 211.45,99.02 C14.N2
N$80  (via drill 0.61)
  Top 0.254: v319.15,198.59 319.65,198.08 319.65,186.4 319.15,185.89 319.15,152.87 v318.64,152.36
  Route15 0.254: v180.97,211.8 180.46,211.8 175.89,216.37 175.89,216.88 175.38,217.39 174.87,217.39 164.71,227.55 163.19,227.55 142.36,248.37 A09.K1 | v304.41,212.31 305.43,212.31 v319.15,198.59
  Bottom 0.254: v180.97,211.8 181.48,211.29 195.7,211.29 196.72,212.31 200.27,212.31 201.29,211.29 216.53,211.29 217.04,211.8 223.64,211.8 224.66,210.78 238.88,210.78 240.41,212.31 244.47,212.31 245.49,213.32 266.82,213.32 267.33,212.81 278.51,212.81 279.52,211.8 303.91,211.8 v304.41,212.31 | v318.64,152.36 325.75,152.36 B21.U2
N$81  (via drill 0.61)
  Top 0.254: v193.16,102.07 v193.16,114.26 | v186.56,120.87 186.56,123.91 C12.D1
  Route15 0.254: v193.16,114.26 v186.56,120.87
  Bottom 0.254: v193.16,102.07 198.75,102.07 C13.M2
N$82
  Bottom 0.254: B11.V1 170.3,149.82 168.78,151.35 132.2,151.35 131.19,150.33 131.19,146.77 155.06,146.77 159.13,142.71 298.83,142.71 302.38,139.15 302.38,125.44 286.13,125.44 272.92,112.23 266.31,112.23 C17.J1
N$83
  Route15 0.254: A08.E2 120.01,260.57 121.53,260.57 131.19,250.91 131.19,250.41 134.74,246.85 136.77,246.85 138.3,245.33 A09.L1
N$84
  Bottom 0.254: A10.D1 155.57,264.63 157.6,266.66 A10.C1
N$85  (via drill 0.61)
  Top 0.254: A10.B1 155.06,269.71 155.06,266.15 156.08,265.14 156.08,261.07 155.06,260.06 155.06,258.03 A10.F1 | v230.75,167.09 230.75,165.57 B15.P2 | v208.91,187.41 208.4,187.92 208.4,204.69 208.91,205.19 v208.91,207.73
  Route15 0.254: v230.75,167.09 227.71,170.14 225.67,170.14 208.91,186.91 v208.91,187.41 | v208.91,207.73 208.91,208.75 195.7,221.96 194.18,221.96 184.02,232.12 184.02,232.63 175.38,241.26 175.38,242.79 v160.65,257.52
  Bottom 0.254: v160.65,257.52 155.57,257.52 A10.F1
N$86
  Bottom 0.254: B11.L2 164.71,174.21 166.24,172.68 217.55,172.68 226.18,164.05 226.18,159.47 230.25,159.47 B15.S2
N$88
  Bottom 0.254: D17.R2 259.71,22.31 262.25,19.77 D17.S2
N$91
  Bottom 0.254: B08.S1 126.61,159.47 128.14,161 137.79,161 138.3,161.51 B09.R1
N$92
  Top 0.254: B08.K1 125.6,178.27 121.03,178.27 121.03,205.7 124.58,209.26 124.58,268.19 126.61,270.22 126.61,270.73 127.12,271.23 131.19,271.23 131.19,197.57 133.73,195.03 133.73,188.94 132.71,187.92 B09.F2
N$93
  Bottom 0.254: D08.D1 123.06,54.83 125.6,57.37 D08.C1 126.61,57.37 130.68,53.3 139.82,53.3 141.35,51.78 D09.E1
N$94
  Bottom 0.254: 118.49,50.25 118.99,50.76 119.5,50.76 D08.E2 | 118.49,50.25 116.96,48.73 D08.F2 | 118.49,50.25 122.55,46.19 128.14,46.19 132.2,42.13 D09.J2
N$95
  Bottom 0.254: D08.J1 123.06,41.11 125.09,39.08 125.6,39.08 D08.K1 126.61,38.06 127.63,37.05 137.28,37.05 138.3,36.03 D09.L1
N$96
  Top 0.254: D08.R1 123.06,23.33 125.6,25.87 D08.P1
  Bottom 0.254: D09.S1 141.35,19.77 139.82,21.3 124.07,21.3 123.06,22.31 D08.R1
N$97
  Bottom 0.254: B08.C1 126.61,196.56 128.14,195.03 137.28,195.03 138.3,194.02 B09.D1
N$99
  Top 0.254: D08.T2 116.96,16.22 119.5,13.68 D08.U2 120.01,12.66 122.55,12.66 124.07,11.14 124.07,10.63 132.2,10.63 D09.V2
N$100
  Bottom 0.254: 117.98,30.44 119.5,31.97 D08.M2 | 117.98,30.44 116.96,29.43 D08.N2 | 117.98,30.44 126.11,30.44 129.66,26.89 134.74,26.89 135.25,26.38 D09.P2
N$101
  Top 0.254: 117.98,34 118.49,33.49 118.49,20.79 | 117.98,34 116.96,35.01 D08.L2 | 118.49,20.79 119.5,19.77 D08.S2 | 117.98,34 117.98,52.79 116.96,53.81 D08.D2 | 118.49,20.79 115.44,17.74 115.44,4.53 140.33,4.53 140.84,5.04 172.84,5.04 181.48,13.68 181.48,49.24 187.57,49.24 192.15,44.67 192.15,8.09 250.57,8.09 254.12,11.65 254.12,13.68 263.77,23.33 263.77,60.92 268.35,65.49 268.35,82.77 C17.U1
N$103  (via drill 0.61)
  Top 0.254: D08.N1 123.06,29.43 123.06,31.46 124.07,32.47 v124.07,45.17 124.07,55.84 123.06,56.86 123.06,60.41 D08.B1 123.06,61.43 v123.06,69.05
  Route2 0.254: v231.26,69.56 231.26,70.57 259.2,98.51 C17.N2
  Bottom 0.254: v124.07,45.17 125.6,45.17 D08.H1 | v231.26,69.56 229.74,69.56 229.23,70.07 222.63,70.07 222.12,70.57 188.59,70.57 188.08,70.07 178.43,70.07 175.38,67.02 174.87,67.02 174.37,66.51 165.73,66.51 165.22,67.02 163.7,67.02 162.68,68.03 156.08,68.03 154.05,70.07 138.81,70.07 137.79,69.05 v123.06,69.05
N$104  (via drill 0.61)
  Route15 0.254: v120.52,111.72 122.55,109.69 123.57,109.69 124.07,109.18 124.07,107.15 132.2,99.02 C09.N2
  Bottom 0.254: v120.52,111.72 116.96,111.72 C08.J2
N$105
  Bottom 0.254: A09.E1 142.36,260.57 149.47,260.57 150.49,259.55 179.45,259.55 185.54,265.65 211.45,265.65 214.5,268.69 355.72,268.69 356.23,269.2 356.23,272.25 174.87,272.25 173.86,273.27 A11.A1
N$106  (via drill 0.61)
  Route2 0.254: v147.44,252.95 159.13,264.63 160.14,264.63 v165.73,270.22
  Bottom 0.254: v147.44,252.95 136.77,252.95 135.76,253.96 A09.H2 | v165.73,270.22 170.3,270.22 A11.B1
N$107
  Route2 0.254: A08.M2 120.01,241.77 121.03,242.79 124.07,242.79 132.2,250.91 A09.J2
N$108
  Route2 0.254: C10.J2 148.46,111.21 148.46,108.67 154.05,103.09 150.49,99.53 150.49,96.99 146.93,93.43 146.93,90.39 123.06,66.51 123.06,65.49 110.36,52.79 109.85,52.79 108.83,51.78 108.83,40.09 108.33,39.59 108.33,25.87 115.95,18.25 117.98,18.25 134.23,1.99 153.54,1.99 172.33,20.79 175.89,20.79 188.59,33.49 191.64,33.49 204.34,46.19 207.39,46.19 220.09,58.89 223.64,58.89 230.25,65.49 231.26,65.49 254.12,88.35 254.12,91.4 260.73,98.01 260.73,100.04 262.25,101.56 C17.M2
N$109
  Bottom 0.254: C10.V2 148.46,79.21 148.97,78.7 264.79,78.7 265.3,79.21 C17.V1
N$111
  Route15 0.254: C17.R2 259.2,91.91 259.2,90.39 267.84,81.75 271.39,81.75 274.44,78.7 276.98,78.7 285.11,86.83 273.93,98.01 273.93,101.56 268.35,107.15 267.84,107.15 258.19,116.8 258.19,118.83 231.77,145.25 231.77,148.81 224.15,156.43 224.15,157.95 212.47,169.63 211.45,169.63 198.24,182.84 198.24,183.86 180.46,201.64 178.94,201.64 168.27,212.31 167.25,212.31 166.24,213.32 164.21,213.32 161.67,215.86 160.65,215.86 149.47,227.04 146.93,227.04 143.89,230.09 142.87,230.09 142.36,230.59 134.74,230.59 130.17,226.02 131.69,224.5 132.71,224.5 133.22,223.99 134.23,223.99 135.25,222.97 A09.U2
N$112  (via drill 0.61)
  Top 0.254: v129.66,152.36 129.66,165.57 128.65,166.59 128.65,182.84 v129.15,183.35
  Route15 0.254: v129.15,183.35 v125.09,187.41
  Bottom 0.254: v129.66,152.36 135.25,152.36 B09.U2 | v125.09,187.41 123.06,187.41 B08.F1
N$113
  Route15 0.254: B08.F2 116.45,186.91 116.45,183.35 127.12,172.68 127.12,171.67 141.35,157.44 143.38,157.44 147.95,152.87 149.47,152.87 154.05,148.3 157.09,148.3 166.75,138.65 168.27,138.65 173.86,144.23 162.68,155.41 162.68,156.43 141.35,177.76 B09.K1
N$114
  Bottom 0.254: A09.V2 132.2,219.93 131.19,220.94 86.99,220.94 86.48,221.45 86.48,230.59 165.73,230.59 166.75,229.58 A11.S2
N$115
  Bottom 0.254: C15.N2 228.21,98.51 231.77,98.51 233.29,96.99 261.23,96.99 262.25,95.97 C17.P2
N$116
  Top 0.254: C13.S2 199.26,88.86 204.34,88.86 204.34,49.75 209.93,44.16 209.93,40.6 224.15,26.38 224.15,22.82 224.66,22.31 226.18,22.31 226.18,62.95 235.33,72.1 235.33,101.56 232.28,104.61 232.28,107.15 231.26,108.17 C15.K2
N$117  (via drill 0.61)
  Top 0.254: v172.33,105.12 172.33,81.75 173.35,80.73 173.35,66 172.33,64.99 v172.33,36.03
  Route2 0.254: D12.N2 180.46,29.43 183,31.97 D12.M2 | v172.33,105.12 175.38,108.17 175.38,108.67 179.95,113.25 181.48,113.25 183,114.77 C12.H2
  Route15 0.254: v172.33,36.03 179.45,28.92 D12.N2
N$118
  Route2 0.254: C11.K2 166.75,108.17 166.75,103.59 162.68,99.53 162.68,98.01 157.6,92.93 157.6,91.4 146.93,80.73 146.93,79.21 129.15,61.43 127.63,61.43 115.44,49.24 115.44,46.7 110.87,42.13 110.87,41.11 108.83,39.08 108.83,35.52 115.44,28.92 115.44,21.81 134.74,2.5 149.47,2.5 160.65,13.68 160.65,15.71 179.95,35.01 D12.L2
  Bottom 0.254: D12.K2 183,38.06 180.97,36.03 180.46,36.03 D12.L2
N$119
  Route15 0.254: C13.P2 199.26,95.47 199.77,95.47 200.27,94.96 201.8,94.96 206.88,89.88 206.88,88.86 217.04,78.7 219.07,78.7 223.64,74.13 225.17,74.13 236.85,62.45 239.9,62.45 252.6,49.75 254.12,49.75 269.36,34.51 273.43,34.51 276.98,38.06 278,37.05 279.01,37.05 287.14,45.17 287.14,51.27 270.89,67.53 269.87,67.53 258.19,79.21 258.19,81.24 250.57,88.86 250.57,89.88 242.44,98.01 242.44,101.05 229.74,113.75 229.74,115.28 227.71,117.31 C15.F2
N$123
  Top 0.254: A18.J2 274.95,251.93 273.93,252.95 273.93,262.6 274.95,263.61 A18.D2
  Bottom 0.254: AB19.AF2 290.7,258.03 286.13,262.6 276.47,262.6 275.46,263.61 A18.D2
N$124  (via drill 0.61)
  Top 0.254: v175.89,246.85 v175.89,264.12
  Route2 0.254: A10.S1 v175.89,246.85
  Route15 0.254: v175.89,264.12 173.35,266.66 A11.C1
N$125
  Bottom 0.254: A08.P1 126.11,235.67 127.63,237.2 153.54,237.2 154.55,238.21 A10.N1
N$126
  Top 0.254: A18.K2 279.01,248.37 279.52,248.88 279.52,260.06 279.01,260.57 A18.E2
  Bottom 0.254: AB19.AH2 293.75,253.96 286.63,253.96 281.05,248.37 279.01,248.37 A18.K2
N$127
  Top 0.254: B18.J2 274.95,181.32 274.44,181.83 274.44,193 274.95,193.51 B18.D2 274.95,194.02 273.43,195.54 273.43,220.94 290.7,238.21 AB19.AN2
N$128
  Top 0.254: A08.N1 123.06,239.23 124.07,240.25 124.07,268.69 126.11,270.73 126.11,271.23 129.66,274.79 160.65,274.79 160.65,267.68 163.7,264.63 A11.D2
N$129
  Bottom 0.254: C08.V2 116.96,80.23 118.49,81.75 130.68,81.75 131.69,82.77 135.25,82.77 C09.U2
N$130
  Top 0.254: 280.03,189.45 280.03,179.29 279.01,178.27 B18.K2 | 280.03,189.45 279.01,190.46 B18.E2 | 280.03,189.45 280.03,200.62 295.78,216.37 295.78,234.15 294.76,235.17 AB19.AP2
N$131
  Top 0.254: 305.94,250.41 306.45,250.91 A20.J2 | 305.94,250.41 293.24,237.71 293.24,221.45 291.71,219.93 AB19.AV2 | 305.94,250.41 305.94,263.11 306.45,263.61 A20.D2
N$132  (via drill 0.61)
  Route2 0.254: v140.33,262.6 126.11,248.37 A08.K1
  Bottom 0.254: v140.33,262.6 168.78,262.6 170.3,261.07 173.35,261.07 A11.E1
N$133
  Top 0.254: 308.99,247.87 310,247.87 A20.K2 | 308.99,247.87 307.46,247.87 305.94,246.34 305.94,244.82 299.33,238.21 299.33,218.91 295.78,215.35 295.78,194.53 293.24,194.53 AB19.BD2 | 308.99,247.87 308.99,259.55 310,260.57 A20.E2
N$134
  Bottom 0.254: 295.78,183.35 296.29,182.84 304.92,182.84 306.45,181.32 B20.J2 | 295.78,183.35 294.76,184.37 AB19.BH2 | 295.78,183.35 296.29,183.35 306.45,193.51 B20.D2
N$135
  Top 0.254: B20.E2 310,190.46 308.99,189.45 308.99,179.29 310,178.27 B20.K2
  Bottom 0.254: AB19.BJ2 293.24,180.81 294.25,179.79 308.48,179.79 310,178.27 B20.K2
N$136
  Top 0.254: 321.69,246.85 322.7,246.85 322.7,250.91 A21.J2 | 321.69,246.85 311.02,246.85 301.87,237.71 301.87,220.43 296.29,214.85 296.29,169.13 293.24,169.13 AB19.BN2 | 321.69,246.85 321.69,262.6 322.7,263.61 A21.D2
N$137
  Top 0.254: A10.V2 148.97,219.93 153.03,219.93 153.03,223.99 152.52,224.5 147.44,224.5 147.44,235.17 153.54,241.26 153.54,245.83 163.7,255.99 171.83,255.99 171.83,262.6 170.81,263.61 A11.D1
N$138
  Top 0.254: A09.S1 141.35,229.58 140.84,230.09 140.84,236.69 143.89,239.74 146.93,239.74 146.93,223.99 147.95,222.97 151.51,222.97 A10.U2
N$139
  Top 0.254: A10.T2 148.97,226.53 151.51,229.07 A10.S2
N$140
  Top 0.254: 324.73,246.34 325.75,246.34 325.75,247.87 A21.K2 | 324.73,246.34 311.53,246.34 302.38,237.2 302.38,202.15 299.33,199.1 299.33,166.08 294.76,166.08 AB19.BP2 | 324.73,246.34 324.73,259.55 325.75,260.57 A21.E2
N$142
  Bottom 0.254: C08.P2 120.01,95.47 121.53,93.94 137.28,93.94 138.3,92.93 C09.R1
N$146
  Bottom 0.254: C08.E1 126.61,121.37 128.14,122.9 137.28,122.9 138.3,123.91 C09.D1
N$147
  Bottom 0.254: C08.L1 123.06,105.63 123.06,110.2 125.09,110.2 132.2,117.31 C09.F2
N$148
  Bottom 0.254: C08.S1 126.61,89.88 128.14,91.4 140.33,91.4 144.39,95.47 144.39,104.1 145.92,104.1 146.43,104.61 146.43,108.17 142.36,108.17 C09.K1
N$150
  Top 0.254: D16.S2 247.01,19.27 252.6,19.27 D16.S1
N$151