# EAGLE board tc083-18 (EAGLE 4.11), part 2 of 6
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
C01  (via drill 0.61) (continued)
  Bottom 0.254: v160.65,181.32 155.57,181.32 B10.J1 | v160.14,164.55 160.65,164.05 196.72,164.05 197.73,165.06 198.75,165.06 B13.P2 | v177.92,241.77 183,241.77 A12.M2 | v389.25,214.34 388.74,213.83 380.11,213.83 379.6,213.32 371.98,213.32 370.96,212.31 324.73,212.31 322.19,214.85 303.91,214.85 303.4,214.34 302.89,214.34 301.87,213.32 281.05,213.32 280.03,214.34 268.85,214.34 268.35,214.85 236.34,214.85 234.82,216.37 204.34,216.37 203.83,215.86 190.11,215.86 189.61,215.35 175.38,215.35 174.87,215.86 v174.87,216.37
C01\  (via drill 0.61)
  Top 0.254: v176.4,69.56 176.4,101.05 177.41,102.07 v177.41,114.77 | v199.26,168.11 199.26,171.16 B13.M2 | v196.21,165.06 196.21,162.52 B13.R2 | v177.41,232.12 177.92,231.61 177.92,217.89 179.45,216.37 179.45,202.65 178.43,201.64 178.43,187.41 v177.92,186.91 | v192.65,132.55 193.16,133.06 193.16,157.95 192.65,158.46 v192.65,161.51
  Route2 0.254: v160.65,54.32 175.89,69.56 v176.4,69.56 | v177.41,114.77 180.46,117.82 C12.F2 179.95,118.33 179.95,119.85 v192.65,132.55 | v196.21,165.06 v199.26,168.11
  Route15 0.254: v163.19,159.98 158.11,165.06 B10.P1 | v177.92,186.91 177.92,186.4 v192.65,171.67
  Bottom 0.254: v160.65,54.32 155.06,54.32 D10.D1 | v163.19,159.98 165.22,159.98 165.73,160.49 189.1,160.49 189.61,159.98 190.62,159.98 192.15,161.51 | 192.15,161.51 192.65,162.01 195.7,162.01 B13.R2 | v177.41,232.12 179.45,232.12 A12.R2 | v192.65,171.67 198.75,171.67 B13.M2 | v192.65,161.51 192.15,161.51
CK00  (via drill 0.61)
  Top 0.254: v238.37,176.24 238.88,176.75 238.88,179.29 238.37,179.79 238.37,200.11 v237.87,200.62
  Route2 0.254: v238.37,176.24 221.61,159.47 B14.S1 | v272.92,235.67 v237.87,200.62
  Bottom 0.254: v272.92,235.67 278,235.67 A18.P2
CK00\  (via drill 0.61)
  Top 0.254: v211.96,153.89 211.96,155.41 B14.T2 | v227.2,191.48 226.69,190.97 226.69,189.95 225.67,188.94 225.67,167.6 224.66,166.59 224.66,157.44 v225.17,156.93
  Route2 0.254: v227.2,191.48 237.36,201.64 237.87,201.64 271.9,235.67 271.9,236.18 272.41,236.69 273.43,236.69 274.95,238.21 A18.N2 | v225.17,156.93 225.17,156.43 221.61,152.87 B14.U1
  Bottom 0.254: v211.96,153.89 216.02,153.89 217.04,152.87 218.05,152.87 218.56,152.36 221.1,152.36 B14.U1
CK01  (via drill 0.61)
  Top 0.254: C16.N1 250.06,98.51 250.06,92.93 C16.R1 | v213.48,154.9 213.48,153.38 211.96,151.85 211.96,149.82 B14.V2 | v221.1,162.52 221.1,165.06 B14.P1 | v224.15,123.41 224.66,123.91 224.66,132.04 224.15,132.55 v224.15,135.6
  Route2 0.254: C16.P1 252.6,95.47 250.06,92.93 C16.R1 | v213.48,154.9 v221.1,162.52
  Route15 0.254: v248.03,99.02 247.52,99.02 242.44,104.1 242.44,105.12 v224.15,123.41 | v224.15,135.6 223.64,135.6 212.97,146.27 212.97,147.28 211.45,148.81 B14.V2
  Bottom 0.254: v248.03,99.02 249.55,99.02 C16.N1
CK01\  (via drill 0.61)
  Top 0.254: C16.S2 246.5,88.86 246.5,83.27 C16.U2 | v223.13,125.95 v223.13,143.73 | v242.44,106.64 242.44,90.39 243.45,89.37 243.45,86.83 C16.T2
  Route15 0.254: C16.T2 243.45,85.81 246.5,82.77 C16.U2 | v223.13,143.73 218.05,148.81 B14.V1 | v223.13,125.95 225.17,123.91 225.17,123.41 241.93,106.64 v242.44,106.64
CLR_DF\
  Top 0.254: D11.N2 164.71,29.43 165.22,29.93 165.22,65.49 169.79,70.07 169.79,78.19 169.29,78.7 169.29,112.23 168.78,112.74 168.78,131.53 169.79,132.55 169.79,145.25 168.78,146.27 168.78,153.38 168.27,153.89 168.27,157.44 172.33,161.51 172.33,221.45 173.35,222.47 A11.U1
CLR_DTF\  (via drill 0.61)
  Top 0.254: v177.92,28.92 v177.92,21.3 | v206.88,57.37 207.39,57.87 207.39,79.21 205.35,81.24 205.35,82.77 C13.U1
  Route2 0.254: v177.92,21.3 v169.79,13.17 | v177.92,28.92 189.61,40.6 191.13,40.6 206.37,55.84 206.37,56.35 206.88,56.86 v206.88,57.37
  Bottom 0.254: v169.79,13.17 167.76,13.17 D11.U2
COMP+SH  (via drill 0.61)
  Top 0.254: v211.96,121.37 211.96,123.91 C14.D2 211.96,124.93 v211.96,128.49 | v191.64,254.47 191.64,215.35 192.65,214.34 192.65,206.72 v193.16,206.21 | v210.43,188.94 210.43,178.78 209.93,178.27 209.93,169.63 210.43,169.13 210.43,167.09 207.89,164.55 207.89,126.96 v208.4,126.45
  Route2 0.254: v211.96,128.49 v213.99,130.52
  Route15 0.254: v211.96,121.37 v218.56,114.77 | v225.17,110.2 221.1,114.26 C14.H1 | v191.64,254.47 183.51,262.6 183,262.6 181.48,264.12 180.46,264.12 A12.D2 | v210.43,188.94 v193.16,206.21 | v208.4,126.45 208.91,126.96 211.45,124.42 C14.D2
  Bottom 0.254: v218.56,114.77 221.1,114.77 C14.H1 | v225.17,110.2 232.79,110.2 234.31,108.67 236.85,108.67 C15.K1 | v213.99,130.52 217.55,130.52 C14.B1
CSTA  (via drill 0.61)
  Top 0.254: v223.64,42.13 224.15,42.63 224.15,69.56 222.63,71.08 v222.63,77.18
  Route15 0.254: v223.64,42.13 v239.9,25.87 | v222.63,77.18 222.63,77.69 210.43,89.88 210.43,92.93 207.89,95.47 207.89,95.97 200.78,103.09 200.27,103.09 199.26,104.1 199.26,106.13 197.73,107.66 197.73,111.72 194.18,115.28 193.16,115.28 187.57,120.87 187.57,121.37 187.07,121.88 186.56,121.88 v183.51,124.93
  Bottom 0.254: v239.9,25.87 246.5,25.87 D16.P2 | v183.51,124.93 181.48,122.9 178.94,122.9 176.91,124.93 172.33,124.93 171.32,125.95 166.24,125.95 165.73,126.45 163.19,126.45 162.17,127.47 160.14,127.47 158.62,125.95 155.57,125.95 155.06,125.44 154.05,125.44 153.54,125.95 118.99,125.95 117.98,126.96 111.37,126.96 110.36,125.95 101.21,125.95 100.71,125.44 99.69,125.44 99.18,125.95 87.5,125.95 86.48,126.96 79.88,126.96 78.86,125.95 77.85,125.95 77.34,125.44 74.29,125.44 72.26,123.41 70.73,123.41 70.23,122.9 67.69,122.9 67.69,123.91 61.08,123.91 60.57,124.42 59.56,124.42 C04.D1
CSTA\  (via drill 0.61)
  Top 0.254: v113.41,183.35 113.91,183.86 113.91,188.94 113.41,189.45 113.41,208.24 112.9,208.75 v112.9,214.34
  Route2 0.254: v113.41,183.35 99.18,169.13 99.18,165.57 98.67,165.06 98.17,165.06 85.97,152.87 85.97,152.36 82.93,149.31 82.93,148.81 81.4,147.28 81.4,145.25 80.89,144.74 79.37,144.74 73.78,139.15 73.78,138.14 71.75,136.11 71.24,136.11 62.61,127.47 C04.C1 | v112.9,214.34 117.47,218.91 117.47,219.93 117.98,220.43 118.99,220.43 127.63,229.07 127.63,230.09 139.82,242.28 v140.33,242.28
  Bottom 0.254: v140.33,242.28 141.35,243.29 141.35,244.82 147.95,244.82 A10.L2
DATA  (via drill 0.61)
  Top 0.254: v223.13,99.53 v223.13,94.96 | v411.6,238.72 411.6,241.26 A26.M1 | v398.39,216.88 v398.39,225.01
  Route2 0.254: v411.6,238.72 398.39,225.51 v398.39,225.01 | v299.33,215.35 286.63,202.65 286.63,202.15 279.01,194.53 278.51,194.53 270.38,186.4 268.35,186.4 254.63,172.68 254.63,171.16 243.45,159.98 241.42,159.98 230.25,148.81 230.25,146.77 216.53,133.06 216.53,131.53 207.39,122.39 207.39,120.87 205.35,118.83 203.32,118.83 202.31,117.82 C13.F1
  Route15 0.254: v223.13,94.96 237.36,80.73 237.87,80.73 254.63,63.97 254.63,61.94 278,38.57 CD18.BK2 | v223.13,99.53 222.63,99.53 222.12,100.04 221.1,100.04 213.48,107.66 213.48,108.67 212.97,109.18 211.96,109.18 207.39,113.75 207.39,114.77 204.34,117.82 202.81,117.82 C13.F1
  Bottom 0.254: v398.39,216.88 397.38,215.86 388.23,215.86 387.22,214.85 379.09,214.85 378.58,214.34 370.96,214.34 369.95,213.32 331.85,213.32 330.83,214.34 323.72,214.34 322.7,215.35 v299.33,215.35
DATA\
  Top 0.254: C13.H1 204.85,114.26 203.83,113.25 203.83,98.51 204.34,98.01 204.34,96.99 197.73,90.39 197.73,55.33 209.42,43.65 209.42,40.09 223.64,25.87 223.64,22.31 224.66,21.3 238.88,21.3 238.88,66.51 257.17,84.8 260.73,84.8 260.73,87.34 260.22,87.85 248.03,87.85 248.03,97.5 244.98,100.55 244.98,107.66 242.44,110.2 242.44,123.41 242.95,123.91 C16.D2
  Route15 0.254: B12.N1 186.56,168.11 188.59,168.11 198.24,158.46 198.24,157.95 204.85,151.35 205.86,151.35 222.63,134.58 222.63,133.57 230.25,125.95 234.82,125.95 239.9,120.87 240.91,120.87 243.96,123.91 C16.D2
  Bottom 0.254: C11.L2 164.71,105.63 166.24,107.15 175.38,107.15 177.92,109.69 190.62,109.69 194.18,113.25 203.83,113.25 204.85,114.26 C13.H1
DB_00\  (via drill 0.61)
  Top 0.254: v4.19,70.07 3.68,70.07 2.66,71.08 2.66,181.83 3.68,182.84 v3.68,195.03 | v91.05,268.19 91.05,269.71 A06.B1 | v80.89,258.03 80.89,241.26 81.4,240.75 v81.4,216.88
  Route2 0.254: v80.89,258.03 v91.05,268.19 | v47.87,216.88 28.57,197.57 28.57,195.03 28.06,194.53 B02.D1
  Route15 0.254: v77.34,71.08 v87.5,60.92
  Bottom 0.254: v87.5,60.92 90.55,60.92 D06.B1 | v77.34,71.08 73.27,71.08 72.77,70.57 58.03,70.57 57.53,70.07 41.27,70.07 39.75,71.59 39.75,72.61 38.22,72.61 35.17,69.56 4.69,69.56 v4.19,70.07 | v3.68,195.03 4.19,195.54 22.98,195.54 24.51,194.02 27.05,194.02 B02.D1 | v81.4,216.88 80.89,216.37 56,216.37 55.49,216.88 v47.87,216.88
DB_01\  (via drill 0.61)
  Top 0.254: A06.D1 91.05,263.61 91.05,260.06 92.58,258.53 v92.58,207.23 92.58,58.38 91.05,56.86 91.05,54.83 D06.D1
  Route2 0.254: v54.48,208.24 v37.21,190.97
  Bottom 0.254: v37.21,190.97 31.11,190.97 B02.E1 | v54.48,208.24 65.15,208.24 66.67,206.72 71.24,206.72 71.75,206.21 79.88,206.21 80.39,206.72 88.51,206.72 89.02,207.23 v92.58,207.23
DB_02\  (via drill 0.61)
  Top 0.254: v94.1,53.81 94.1,51.78 D06.E1 | v3.68,71.59 3.17,71.59 3.17,176.24 v3.68,176.75 | v31.11,182.84 31.11,180.81 30.6,180.3 30.6,178.78 B02.K1
  Route2 0.254: v99.18,255.49 94.61,250.91 94.1,250.91 81.4,238.21 81.4,235.67 79.37,233.64 79.37,233.13 55.49,209.26 53.97,209.26 53.46,208.75 53.46,208.24 37.21,191.99 36.7,191.99 34.67,189.95 34.67,187.92 32.13,185.38 32.13,183.86 v31.11,182.84
  Route15 0.254: v94.1,53.81 88.01,59.91 86.99,59.91 86.48,60.41 86.48,60.92 77.34,70.07 76.83,70.07 v74.8,72.1 | v99.18,255.49 94.1,260.57 A06.E1
  Bottom 0.254: v74.8,72.1 74.29,71.59 72.77,71.59 72.26,71.08 57.53,71.08 57.02,70.57 41.78,70.57 40.25,72.1 40.25,73.11 37.71,73.11 34.67,70.07 5.71,70.07 4.19,71.59 v3.68,71.59 | v3.68,176.75 25.52,176.75 27.05,178.27 30.6,178.27 B02.K1
DB_03\  (via drill 0.61)
  Top 0.254: v94.1,47.21 94.1,45.17 D06.H1 | v71.24,69.05 71.75,69.56 71.75,80.73 70.73,81.75 70.73,86.32 71.24,86.83 71.24,87.85 70.73,88.35 70.73,112.74 v71.24,113.25 | v94.1,251.93 94.1,253.96 A06.H1 | v80.39,233.13 v80.39,238.21 | v27.55,177.25 27.55,175.73 B02.L1
  Route2 0.254: v18.92,168.62 25.52,175.22 27.05,175.22 B02.L1 | v80.39,238.21 v94.1,251.93 | v80.39,233.13 55.49,208.24 55.49,207.73 54.99,207.23 54.48,207.23 38.22,190.97 38.22,190.46 32.63,184.87 32.63,182.33 v27.55,177.25
  Route15 0.254: v94.1,47.21 79.88,61.43 78.86,61.43 v71.24,69.05 | v71.24,113.25 71.24,113.75 64.13,120.87 64.13,122.9 49.91,137.12 49.91,138.14 47.87,140.17 47.87,140.68 30.6,157.95 29.59,157.95 v18.92,168.62
DB_04\  (via drill 0.61)
  Top 0.254: v81.4,47.71 81.91,48.22 81.91,71.08 v81.4,71.59 | v96.13,233.64 v96.13,250.91 | v28.06,167.09 27.05,166.08 27.05,163.03 B02.R1
  Route2 0.254: v9.77,142.2 28.06,160.49 28.06,162.01 B02.R1 | v96.13,233.64 77.34,214.85 77.34,214.34 56,193 53.46,193 35.68,175.22 35.68,174.71 v28.06,167.09
  Route15 0.254: v81.4,47.71 v87.5,41.62 | v81.4,71.59 64.13,88.86 64.13,89.88 47.87,106.13 44.83,106.13 37.71,113.25 36.7,113.25 18.92,131.03 18.92,133.06 v9.77,142.2
  Bottom 0.254: v87.5,41.62 90.55,41.62 D06.J1 | v96.13,250.91 91.56,250.91 A06.J1
DB_05\  (via drill 0.61)
  Top 0.254: A06.L1 91.05,244.31 91.05,240.75 90.04,239.74 90.04,218.4 91.05,217.39 91.05,202.15 90.04,201.13 90.04,147.79 91.05,146.77 v91.05,141.19 91.05,133.06 90.04,132.04 90.04,78.19 91.05,77.18 91.05,62.95 90.04,61.94 90.04,39.08 91.05,38.06 91.05,36.03 D06.L1
  Route15 0.254: v48.89,140.68 30.6,158.97 B02.S1
  Bottom 0.254: v48.89,140.68 65.65,140.68 66.16,141.19 v91.05,141.19
DB_06\  (via drill 0.61)
  Top 0.254: v90.04,32.47 89.53,32.98 v89.53,68.03 | v3.17,68.03 3.17,69.56 2.15,70.57 2.15,182.84 v2.66,183.35 | v90.04,241.77 90.04,240.75 89.53,240.25 v89.53,215.86 | v24.51,186.91 24.51,184.87 B02.H2
  Route2 0.254: v54.99,215.86 32.13,193 30.6,193 v24.51,186.91
  Bottom 0.254: v90.04,32.47 94.1,32.47 D06.M1 | v89.53,68.03 58.54,68.03 58.03,68.54 41.27,68.54 39.75,67.02 38.73,67.02 37.21,68.54 3.68,68.54 v3.17,68.03 | v2.66,183.35 21.97,183.35 23.49,184.87 24,184.87 B02.H2 | v90.04,241.77 94.1,241.77 A06.M1 | v54.99,215.86 v89.53,215.86
DB_07\  (via drill 0.61)
  Top 0.254: v97.15,28.92 96.64,29.43 96.64,63.46 98.17,64.99 98.17,67.02 96.13,69.05 96.13,95.47 v96.64,95.97 | v94.1,233.13 94.1,235.17 A06.P1
  Route2 0.254: v97.15,28.92 94.61,26.38 D06.P1 | v16.38,175.73 16.38,176.24 21.46,181.32 B02.J2 21.46,180.81 22.98,182.33 24.51,182.33 32.63,190.46 32.63,192.49 54.48,214.34 v54.99,214.34 | v94.1,233.13 94.1,232.63 v76.32,214.85
  Route15 0.254: v96.64,95.97 80.39,112.23 78.86,112.23 75.31,115.79 74.8,115.79 67.69,122.9 67.69,124.42 50.41,141.69 48.89,141.69 32.63,157.95 32.63,159.47 v16.38,175.73
  Bottom 0.254: v76.32,214.85 75.81,215.35 56,215.35 v54.99,214.34
DB_08\  (via drill 0.61)
  Top 0.254: 95.63,162.01 95.63,23.33 94.1,21.81 94.1,19.77 D06.S1 | 95.63,162.01 95.63,223.99 94.1,225.51 94.1,228.56 A06.S1 | v21.46,164.05 21.46,168.11 B02.N2 | v94.1,163.54 95.63,162.01
  Bottom 0.254: v21.46,164.05 93.59,164.05 v94.1,163.54
DB_09\  (via drill 0.61)
  Top 0.254: v18.92,100.04 18.92,109.18 17.9,110.2 17.9,116.29 18.92,117.31 18.92,135.09 17.9,136.11 17.9,138.65 19.43,140.17 19.43,165.06 v18.92,165.57 17.9,166.59 v17.9,187.92 | v65.15,244.31 64.64,243.8 64.64,237.2 v65.15,236.69
  Route2 0.254: v65.15,244.31 84.45,263.61 A06.D2 | v65.15,236.69 64.13,235.67 64.13,234.66 46.86,217.39 46.86,216.88 v17.9,187.92
  Route15 0.254: v67.18,72.1 67.18,71.59 70.73,68.03 71.24,68.03 78.86,60.41 78.86,59.91 84.45,54.32 D06.D2 | v47.87,71.59 47.37,71.59 43.3,75.65 43.3,76.16 32.63,86.83 31.11,86.83 19.93,98.01 19.93,99.02 v18.92,100.04
  Bottom 0.254: v67.18,72.1 66.67,71.59 57.02,71.59 56.51,71.08 48.38,71.08 v47.87,71.59 | v18.92,165.57 24,165.57 B02.P2
DB_10\  (via drill 0.61)
  Top 0.254: v80.89,51.27 81.4,51.78 81.4,69.56 v80.89,70.07 | v77.34,92.42 v77.34,73.62 | v80.39,261.07 80.39,259.04 79.88,258.53 79.88,257.52 80.39,257.01 80.39,239.74 79.37,238.72 79.37,237.2 79.88,236.69 79.88,234.15 79.37,233.64 79.37,231.61 80.89,230.09 80.89,217.89 80.39,217.39 v80.39,214.85 | v24.51,154.9 24.51,153.38 B02.U2
  Route2 0.254: v80.39,214.85 71.24,205.7 71.24,204.69 66.67,200.11 66.67,198.08 57.02,188.43 57.02,187.41 48.38,178.78 48.38,177.76 43.3,172.68 42.79,172.68 42.29,172.17 42.29,171.67 34.67,164.05 33.65,164.05 v24.51,154.9
  Route15 0.254: v77.34,73.62 v80.89,70.07 | v77.34,92.42 63.62,106.13 62.61,106.13 60.57,108.17 60.57,109.18 59.56,110.2 58.54,110.2 48.89,119.85 48.89,121.37 44.32,125.95 44.32,126.96 34.67,136.61 34.67,139.15 25.52,148.3 25.52,151.35 24.51,152.36 B02.U2
  Bottom 0.254: v80.89,51.27 87.5,51.27 D06.E2 | v80.39,261.07 87.5,261.07 A06.E2
DB_11\  (via drill 0.61)
  Top 0.254: v88.01,46.7 88.01,45.17 D06.H2 | v4.19,73.11 3.68,73.62 3.68,132.04 v4.19,132.55 | v88.01,252.44 88.01,253.96 A06.H2 | v16.89,181.32 17.39,180.81 v17.39,153.38
  Route2 0.254: v4.19,132.55 20.95,149.31 B02.V2 | v88.01,252.44 79.37,243.8 78.86,243.8 64.13,229.07 64.13,228.56 40.76,205.19 40.25,205.19 32.63,197.57 32.63,197.07 v16.89,181.32
  Route15 0.254: v88.01,46.7 79.37,55.33 78.86,55.33 v60.57,73.62 | v17.39,153.38 20.95,149.82 B02.V2
  Bottom 0.254: v60.57,73.62 37.21,73.62 36.7,73.11 v4.19,73.11
DF  (via drill 0.61)
  Top 0.254: v176.91,262.09 177.41,262.6 177.41,289.01 v176.91,289.52 | v229.23,148.81 v229.23,85.31 | v257.68,178.78 257.17,179.29 257.17,204.69 258.19,205.7 258.19,220.43 258.69,220.94 258.69,223.48 257.68,224.5 257.68,239.23 258.19,239.74 258.19,273.77 260.22,275.81 v260.22,290.03
  Route2 0.254: v153.54,235.67 154.05,235.67 160.14,241.77 160.14,244.31 169.79,253.96 169.79,254.98 v176.91,262.09 | v229.23,85.31 196.21,52.29 194.69,52.29 176.91,34.51 176.91,33.49 167.76,24.35 165.73,24.35 164.21,22.82 D11.R2 | v229.23,148.81 241.42,161 241.42,162.52 v257.68,178.78
  Route15 0.254: v384.17,290.54 412.11,262.6 412.11,261.07 A26.E1
  Bottom 0.254: v153.54,235.67 152.01,235.67 A10.P2 | v176.91,289.52 178.43,289.52 178.94,290.03 205.86,290.03 206.37,289.52 207.39,289.52 208.4,290.54 260.22,290.54 | 260.22,290.54 364.87,290.54 365.88,289.52 366.9,289.52 368.42,291.05 383.66,291.05 v384.17,290.54 | v260.22,290.03 260.22,290.54
DF\  (via drill 0.61)
  Top 0.254: v171.32,82.77 171.32,81.75 172.84,80.23 172.84,66.51 171.83,65.49 171.83,40.6 169.29,38.06 169.29,31.46 168.27,30.44 168.27,26.89 167.76,26.38 D11.P2 | v198.75,110.2 200.27,111.72 200.27,115.79 199.77,116.29 199.77,119.34 200.27,119.85 200.27,122.39 198.24,124.42 198.24,125.44 197.23,126.45 197.23,131.03 197.73,131.53 197.73,156.43 195.7,158.46 195.7,160.49 194.69,161.51 194.69,175.22 v195.7,176.24
  Route2 0.254: v171.32,82.77 178.94,90.39 180.46,90.39 192.15,102.07 192.15,103.59 v198.75,110.2
  Route15 0.254: v141.35,205.7 146.43,200.62 146.43,200.11 v163.7,182.84 | v195.7,176.24 v191.13,180.81
  Bottom 0.254: v141.35,205.7 107.82,205.7 107.31,205.19 87.5,205.19 85.97,203.67 78.86,203.67 B05.A1 | v163.7,182.84 181.48,182.84 183,181.32 186.05,181.32 B12.J1 186.56,181.32 190.62,181.32 v191.13,180.81
DTB_00  (via drill 0.61)
  Top 0.254: v132.2,56.86 132.2,54.83 D09.D2 | v143.38,68.03 143.38,78.7 143.89,79.21 143.89,88.86 143.38,89.37 143.38,116.8 141.85,118.33 141.85,120.87 C09.E1 | v272.41,280.89 272.41,276.82 271.9,276.31 271.9,229.07 v272.41,228.56
  Route2 0.254: v143.38,68.03 v132.2,56.86 | v151.51,130.52 142.36,121.37 C09.E1 | v272.41,228.56 249.04,205.19 246.5,205.19 238.88,197.57 238.88,196.56 233.8,191.48 233.29,191.48 232.79,190.97 232.79,190.46 227.2,184.87 225.67,184.87 217.55,176.75 216.53,176.75 215.51,175.73 214.5,175.73 205.86,167.09 204.85,167.09 203.83,166.08 202.31,166.08 197.23,161 196.21,161 194.69,159.47 194.69,158.46 190.62,154.39 189.61,154.39 184.02,148.81 184.02,148.3 v168.78,133.06
  Route15 0.254: v382.14,280.38 389.25,273.27 A25.A2
  Bottom 0.254: v151.51,130.52 154.05,130.52 C10.B1 155.06,130.52 158.11,130.52 160.14,132.55 168.78,132.55 v168.78,133.06 | v382.14,280.38 337.94,280.38 336.93,279.36 274.95,279.36 273.93,280.38 272.92,280.38 v272.41,280.89
DTB_00\  (via drill 0.61)
  Top 0.254: v129.15,124.93 129.66,125.44 129.66,138.14 130.17,138.65 v130.17,144.23
  Route15 0.254: v136.27,117.82 135.76,117.82 129.15,124.42 v129.15,124.93 | v90.04,143.22 89.02,143.22 80.39,151.85 80.39,153.38 65.15,168.62 65.15,169.13 64.64,169.63 63.11,169.63 62.1,170.65 61.59,170.65 60.07,172.17 60.07,172.68 59.05,173.7 58.54,173.7 49.91,182.33 49.91,185.38 45.33,189.95 45.33,190.97 44.83,191.48 42.29,191.48 30.6,203.16 B02.A1
  Bottom 0.254: v136.27,117.82 138.3,117.82 C09.F1 | v130.17,144.23 129.66,144.74 109.34,144.74 108.83,145.25 92.07,145.25 v90.04,143.22
DTB_01  (via drill 0.61)
  Top 0.254: D09.K2 135.76,39.08 135.76,41.11 134.23,42.63 134.23,64.99 135.76,66.51 135.76,80.23 136.77,81.24 136.77,109.69 135.76,110.71 135.76,114.26 C09.H2 135.76,115.28 135.76,116.8 135.25,117.31 135.25,118.33 136.77,119.85 136.77,131.03 v136.27,131.53
  Route2 0.254: v278.51,280.38 254.63,256.5 253.11,256.5 238.88,242.28 238.88,241.26 230.75,233.13 230.25,233.13 221.61,224.5 221.1,224.5 217.04,220.43 216.53,220.43 202.81,206.72 202.81,204.69 193.16,195.03 191.64,195.03 175.38,178.78 175.38,176.24 160.14,161 160.14,156.93 148.97,145.76 148.97,144.23 v136.27,131.53
  Route15 0.254: v375.03,281.39 386.2,270.22 A25.B2
  Bottom 0.254: C10.H1 157.6,114.77 155.06,114.77 154.55,115.28 153.03,115.28 152.01,116.29 140.33,116.29 138.81,114.77 135.76,114.77 C09.H2 | v375.03,281.39 374.52,280.89 337.43,280.89 336.42,279.87 279.01,279.87 v278.51,280.38
DTB_01\
  Route15 0.254: B02.B1 27.55,201.13 27.55,202.65 33.14,208.24 39.24,202.15 53.46,202.15 63.62,191.99 63.62,190.97 84.96,169.63 85.47,169.63 89.02,166.08 89.02,162.01 98.67,152.36 98.67,149.31 99.69,148.3 101.21,148.3 117.98,131.53 117.98,125.44 132.2,111.21 C09.J2
DTB_02  (via drill 0.61)
  Top 0.254: v128.65,62.45 v128.65,26.38 | v136.77,70.57 136.27,71.08 136.27,79.72 137.28,80.73 137.28,101.05 138.81,102.58 138.81,104.61 C09.L1 | v381.63,267.17 381.63,233.64 383.15,232.12 383.15,224.5 382.65,223.99 382.65,216.88 383.15,216.37 v383.15,183.35
  Route2 0.254: v136.77,70.57 v128.65,62.45 | v383.15,183.35 365.88,166.08 365.88,165.06 317.62,116.8 316.61,116.8 302.38,102.58 302.38,101.56 285.62,84.8 284.6,84.8 v267.33,67.53
  Route15 0.254: v128.65,26.38 132.2,22.82 D09.R2 | 151,99.53 v145.41,105.12 | 151,99.53 v151.51,99.02 | v179.95,68.54 179.45,68.54 159.63,88.35 159.63,89.88 151,98.51 151,99.53
  Bottom 0.254: v151.51,99.02 154.05,99.02 C10.N1 | v145.41,105.12 139.31,105.12 C09.L1 | v381.63,267.17 389.25,267.17 A25.C2 | v267.33,67.53 251.07,67.53 250.57,68.03 230.25,68.03 229.74,68.54 228.72,68.54 228.21,69.05 221.61,69.05 221.1,69.56 195.7,69.56 194.18,68.03 180.46,68.03 v179.95,68.54
DTB_02\  (via drill 0.61)
  Top 0.254: v81.4,156.93 v81.4,143.22
  Route15 0.254: v54.48,188.43 60.57,182.33 60.57,180.81 61.08,180.3 62.1,180.3 64.13,178.27 64.13,175.22 70.23,169.13 70.23,168.11 71.24,167.09 72.26,167.09 81.4,157.95 v81.4,156.93 | v81.4,143.22 82.42,143.22 92.07,133.57 92.07,133.06 99.69,125.44 101.21,125.44 105.79,120.87 106.29,120.87 108.33,118.83 108.33,117.82 112.9,113.25 112.9,112.23 115.44,109.69 115.95,109.69 v120.52,105.12
  Bottom 0.254: v54.48,188.43 53.97,188.94 49.91,188.94 49.4,189.45 35.17,189.45 34.16,188.43 28.06,188.43 B02.F1 | v120.52,105.12 121.53,104.1 129.15,104.1 129.66,104.61 130.68,104.61 131.19,104.1 136.77,104.1 138.81,102.07 141.35,102.07 C09.M1
DTB_03  (via drill 0.61)
  Top 0.254: v135.76,97.5 135.76,95.97 C09.P2 | v145.41,107.15 144.9,107.66 144.9,122.39 v145.41,122.9 | v375.53,252.95 375.53,219.42 v375.03,218.91
  Route2 0.254: v135.76,97.5 135.76,98.01 140.84,103.09 141.35,103.09 v145.41,107.15 | v375.53,252.95 386.2,263.61 A25.D2 | v375.03,218.91 374.52,218.91 363.34,207.73 363.34,206.72 353.69,197.07 352.67,197.07 336.42,180.81 336.42,178.78 320.67,163.03 320.16,163.03 318.13,161 318.13,157.95 v308.48,148.3 | v173.35,150.84 173.35,150.33 170.81,147.79 168.78,147.79 152.52,131.53 152.52,130.01 152.01,129.5 151.51,129.5 145.41,123.41 v145.41,122.9
  Route15 0.254: v145.41,122.9 145.41,123.41 141.85,126.96 C09.C1
  Bottom 0.254: v308.48,148.3 307.97,147.79 302.38,147.79 301.87,147.28 240.41,147.28 238.88,148.81 235.83,148.81 234.82,147.79 225.17,147.79 224.15,148.81 222.12,148.81 220.59,147.28 190.62,147.28 187.07,150.84 178.43,150.84 177.92,150.33 173.86,150.33 v173.35,150.84
DTB_03\  (via drill 0.61)
  Route15 0.254: v74.8,138.65 73.27,138.65 67.18,144.74 67.18,145.25 51.94,160.49 51.94,163.03 50.92,164.05 49.4,164.05 48.89,164.55 48.89,165.06 43.81,170.14 43.3,170.14 42.29,171.16 42.29,171.67 40.76,173.19 40.25,173.19 39.24,174.21 39.24,176.24 31.11,184.37 B02.H1 | v81.91,138.65 81.4,138.14 93.59,125.95 95.12,125.95 98.17,122.9 100.2,122.9 101.21,121.88 101.21,121.37 106.8,115.79 107.31,115.79 111.88,111.21 111.88,106.13 v125.6,92.42
  Bottom 0.254: v74.8,138.65 v81.91,138.65 | v125.6,92.42 132.2,92.42 C09.R2
DTB_04  (via drill 0.61)
  Top 0.254: v129.15,120.36 128.65,119.85 128.65,88.35 v129.15,87.85 | v287.65,156.93 v287.65,173.7
  Route2 0.254: v370.45,259.55 368.42,257.52 368.42,256.5 357.75,245.83 357.25,245.83 356.74,245.33 356.74,244.82 351.15,239.23 350.64,239.23 350.13,238.72 350.13,235.17 347.09,232.12 347.09,231.61 329.31,213.83 329.31,213.32 318.13,202.15 317.62,202.15 306.95,191.48 305.43,191.48 298.83,184.87 298.83,184.37 297.81,183.35 297.3,183.35 v287.65,173.7 | v287.65,156.93 253.61,122.9 252.6,122.9 238.88,109.18 238.88,108.17 226.18,95.47 224.66,95.47 224.15,94.96 224.15,94.45 v223.13,93.43
  Bottom 0.254: v129.15,120.36 129.66,120.87 131.69,120.87 132.2,121.37 135.25,121.37 C09.E2 | v129.15,87.85 136.77,87.85 138.3,89.37 141.35,89.37 C09.S1 141.35,89.88 145.92,94.45 159.13,94.45 160.14,95.47 162.68,95.47 163.19,94.96 165.22,94.96 165.73,95.47 165.73,96.48 166.24,96.99 175.38,96.99 176.91,95.47 180.97,95.47 181.99,94.45 191.13,94.45 192.15,95.47 196.72,95.47 197.73,94.45 218.56,94.45 219.58,93.43 v223.13,93.43 | v370.45,259.55 381.12,259.55 382.65,261.07 389.25,261.07 A25.E2
DTB_04\  (via drill 0.61)
  Top 0.254: v18.41,162.52 18.92,162.01 18.92,141.69 v18.41,141.19 | v4.69,127.47 4.19,126.96 4.19,75.65 v4.69,75.15
  Route2 0.254: v18.41,162.52 23.49,167.6 24.51,167.6 29.08,172.17 30.6,172.17 B02.M1 | v4.69,127.47 v18.41,141.19
  Bottom 0.254: v4.69,75.15 36.7,75.15 37.71,74.13 59.56,74.13 60.07,74.64 69.21,74.64 70.23,75.65 97.15,75.65 97.66,75.15 102.74,75.15 105.28,77.69 108.33,77.69 109.85,79.21 110.87,79.21 111.88,78.19 127.12,78.19 130.17,81.24 131.19,81.24 131.69,81.75 136.77,81.75 138.3,83.27 141.35,83.27 C09.U1
DTB_05
  Route2 0.254: 136.77,111.72 129.15,104.1 129.15,103.59 124.07,98.51 124.07,79.21 110.36,65.49 109.34,65.49 96.64,52.79 99.69,49.75 104.26,49.75 115.44,60.92 115.44,61.94 122.04,68.54 122.04,69.56 131.69,79.21 132.2,79.21 C09.V2 | 136.77,111.72 138.3,111.72 C09.J1 | 136.77,111.72 147.95,122.9 155.06,122.9 162.68,130.52 162.68,131.53 178.94,147.79 178.94,150.33 189.1,160.49 189.1,161.51 194.69,167.09 196.72,167.09 199.77,170.14 200.27,170.14 203.83,173.7 203.83,174.21 208.4,178.78 209.42,178.78 210.43,179.79 210.43,181.83 227.71,199.1 228.72,199.1 236.85,207.23 236.85,208.24 259.71,231.1 261.23,231.1 273.93,243.8 276.47,243.8 289.68,257.01 289.68,258.53 309.49,278.35 341.5,278.35 343.02,279.87 344.04,279.87 351.66,272.25 380.11,272.25 387.73,264.63 387.73,263.11 386.71,262.09 386.71,258.03 A25.F2
DTB_05\  (via drill 0.61)
  Top 0.254: v78.35,124.93 77.34,123.91 77.34,111.72 v77.85,111.21
  Route15 0.254: v33.65,169.13 34.67,168.11 34.67,167.6 50.92,151.35 51.94,151.35 52.45,150.84 53.97,150.84 58.54,146.27 58.54,145.76 60.07,144.23 61.59,144.23 62.1,143.73 62.1,141.69 71.24,132.55 71.75,132.55 72.77,131.53 72.77,130.01 77.85,124.93 v78.35,124.93 | v77.85,111.21 80.39,108.67 80.39,107.15 88.01,99.53 88.51,99.53 97.66,90.39 98.17,90.39 v110.36,78.19
  Bottom 0.254: v33.65,169.13 28.06,169.13 B02.N1 | v110.36,78.19 110.87,77.69 132.71,77.69 134.23,79.21 135.25,79.21 135.76,79.72 138.3,79.72 C09.V1
DTB_06  (via drill 0.61)
  Top 0.254: v135.76,105.63 135.76,102.58 C09.M2 | v129.66,111.72 130.17,112.23 130.17,133.06 131.19,134.07 131.19,145.76 130.17,146.77 130.17,150.33 128.14,152.36 128.14,162.01 v128.65,162.52 | v384.17,266.15 v384.17,254.47
  Route2 0.254: v128.65,162.52 146.43,180.3 146.43,181.32 v148.46,183.35 148.46,183.86 157.09,192.49 159.63,192.49 170.3,203.16 170.3,206.21 176.91,212.81 176.91,213.32 190.11,226.53 190.11,227.04 191.13,228.05 191.13,229.58 205.35,243.8 206.37,243.8 223.13,260.57 223.13,261.58 v240.91,279.36
  Route15 0.254: v129.66,111.72 v135.76,105.63 | v148.46,183.35 145.92,185.89 145.92,186.4 141.85,190.46 B09.E1 | v384.17,266.15 372.99,277.33 372.49,277.33 v370.96,278.85
  Bottom 0.254: v384.17,254.47 389.25,254.47 A25.H2 | v370.96,278.85 370.45,278.35 358.77,278.35 358.26,277.84 273.43,277.84 272.41,278.85 263.27,278.85 262.76,279.36 v240.91,279.36
DTB_06\  (via drill 0.61)
  Top 0.254: v21.46,198.59 21.46,194.53 B02.D2
  Route2 0.254: v31.62,209.26 31.62,208.75 v21.46,198.59
  Route15 0.254: v120.52,206.72 126.11,201.13 127.12,201.13 138.81,189.45 138.81,187.92 B09.F1
  Bottom 0.254: v120.52,206.72 120.01,206.21 107.31,206.21 106.8,205.7 99.18,205.7 96.64,208.24 92.07,208.24 91.56,207.73 88.51,207.73 88.01,207.23 79.88,207.23 79.37,206.72 72.26,206.72 71.75,207.23 67.18,207.23 65.65,208.75 55.49,208.75 54.99,209.26 v31.62,209.26
DTB_07  (via drill 0.61)
  Top 0.254: v145.41,135.09 144.9,134.58 144.9,124.93 146.43,123.41 146.43,122.39 145.41,121.37 145.41,108.67 146.43,107.66 v146.43,100.55 | v384.68,218.4 385.19,218.91 385.19,223.48 384.68,223.99 384.68,241.26 385.19,241.77 385.19,246.34 386.2,247.36 386.2,250.91 A25.J2 | v318.13,187.41 318.13,156.43 315.08,153.38 v315.08,147.79
  Route2 0.254: v146.43,100.55 146.43,100.04 142.36,95.97 C09.P1 | v348.1,216.37 348.1,215.86 319.65,187.41 v318.13,187.41
  Route15 0.254: v145.41,135.09 139.31,141.19 139.31,141.69 132.2,148.81 B09.V2
  Bottom 0.254: v384.68,218.4 383.15,218.4 382.65,217.89 375.53,217.89 374.52,216.88 368.42,216.88 367.41,215.86 348.61,215.86 v348.1,216.37 | v315.08,147.79 314.57,147.28 302.89,147.28 302.38,146.77 239.9,146.77 238.37,148.3 236.34,148.3 235.33,147.28 224.66,147.28 223.64,148.3 222.63,148.3 221.1,146.77 186.05,146.77 185.54,147.28 170.81,147.28 170.3,147.79 156.08,147.79 155.57,147.28 136.77,147.28 134.74,149.31 132.71,149.31 B09.V2
DTB_07\  (via drill 0.61)
  Route2 0.254: v134.23,144.74 138.81,149.31 B09.V1
  Route15 0.254: v71.24,143.22 71.24,143.73 64.64,150.33 63.11,150.33 61.08,152.36 61.08,156.43 49.91,167.6 48.89,167.6 32.63,183.86 32.63,184.87 26.54,190.97 25.01,190.97 B02.E2
  Bottom 0.254: v134.23,144.74 133.73,145.25 109.85,145.25 109.34,145.76 89.53,145.76 85.97,142.2 72.26,142.2 v71.24,143.22
DTB_08  (via drill 0.61)
  Top 0.254: v130.17,173.7 130.17,153.89 130.68,153.38 130.68,147.28 131.69,146.27 131.69,133.57 130.68,132.55 130.68,108.17 131.19,107.66 131.19,103.09 130.17,102.07 130.17,90.39 132.2,88.35 132.2,86.83 C09.T2 | v303.4,169.13 302.89,168.62 302.89,150.33 303.4,149.82 v303.4,146.27
  Route2 0.254: v382.65,248.37 373.5,239.23 372.99,239.23 370.45,236.69 368.42,236.69 366.39,234.66 366.39,233.13 361.31,228.05 360.8,228.05 354.2,221.45 354.2,220.94 319.65,186.4 319.65,184.87 306.95,172.17 306.45,172.17 v303.4,169.13
  Route15 0.254: v169.79,146.77 163.19,153.38 162.17,153.38 159.13,156.43 158.62,156.43 155.06,159.98 154.55,159.98 145.92,168.62 145.92,169.13 144.39,170.65 144.39,171.16 140.84,174.71 139.31,174.71 B09.L1
  Bottom 0.254: v130.17,173.7 134.23,173.7 135.25,174.71 138.3,174.71 B09.L1 | v382.65,248.37 389.25,248.37 A25.K2 | v303.4,146.27 233.8,146.27 233.29,146.77 224.15,146.77 223.64,146.27 185.54,146.27 185.03,146.77 v169.79,146.77
DTB_08\  (via drill 0.61)
  Route15 0.254: v67.69,170.14 67.69,170.65 v59.05,179.29
  Bottom 0.254: v67.69,170.14 72.77,170.14 73.78,171.16 75.81,171.16 76.83,170.14 90.04,170.14 93.09,173.19 120.52,173.19 121.03,172.68 137.79,172.68 138.81,171.67 141.35,171.67 B09.M1 | v59.05,179.29 58.54,179.79 47.87,179.79 47.37,179.29 46.35,179.29 45.84,179.79 29.59,179.79 28.57,178.78 26.54,178.78 26.03,178.27 25.01,178.27 B02.K2
DTB_09  (via drill 0.61)
  Top 0.254: v128.65,165.06 128.14,165.57 128.14,186.91 v128.65,187.41 | v384.17,222.97 v384.17,242.28
  Route2 0.254: v137.28,196.05 v128.65,187.41 | v384.17,242.28 386.2,244.31 A25.L2 | v384.17,222.97 384.17,222.47 377.57,215.86 v377.06,215.86 | v166.75,220.94 165.73,219.93 165.73,219.42 162.17,215.86 160.65,215.86 158.62,213.83 158.62,212.81 151,205.19 149.98,205.19 141.85,197.07 B09.C1
  Bottom 0.254: v128.65,165.06 135.25,165.06 B09.P2 | v137.28,196.05 137.79,196.56 138.81,196.56 139.31,197.07 141.35,197.07 B09.C1 | v377.06,215.86 376.55,215.35 369.95,215.35 368.93,214.34 332.86,214.34 331.85,215.35 330.83,215.35 328.8,217.39 327.78,217.39 327.27,216.88 301.37,216.88 300.86,217.39 268.85,217.39 268.35,216.88 259.2,216.88 257.68,218.4 255.65,218.4 254.12,216.88 238.37,216.88 236.85,218.4 202.31,218.4 201.8,217.89 188.08,217.89 187.57,217.39 184.53,217.39 179.95,221.96 175.38,221.96 174.87,221.45 167.25,221.45 v166.75,220.94
DTB_09\  (via drill 0.61)
  Route15 0.254: v121.53,173.7 132.71,162.52 B09.R2
  Bottom 0.254: v121.53,173.7 86.48,173.7 85.47,172.68 73.27,172.68 72.26,173.7 56,173.7 55.49,173.19 32.63,173.19 32.13,173.7 25.52,173.7 24,175.22 21.46,175.22 B02.L2
DTB_10  (via drill 0.61)
  Top 0.254: v389.76,245.83 389.76,242.28 A25.M2
  Route2 0.254: v137.79,158.97 134.23,155.41 132.71,155.41 B09.T2 | v300.35,246.34 300.35,245.83 288.67,234.15 288.16,234.15 v284.6,230.59 | v210.43,230.09 188.59,208.24 188.59,206.21 181.99,199.61 181.48,199.61 174.37,192.49 173.35,192.49 169.29,188.43 169.29,186.91 168.27,185.89 163.7,185.89 156.59,178.78 156.59,173.19 143.89,160.49 143.38,160.49 141.85,158.97 B09.S1
  Bottom 0.254: v137.79,158.97 141.35,158.97 B09.S1 | v389.76,245.83 389.25,246.34 352.67,246.34 352.17,245.83 346.58,245.83 345.56,246.85 300.86,246.85 v300.35,246.34 | v284.6,230.59 210.94,230.59 v210.43,230.09
DTB_10\
  Bottom 0.254: B09.U1 141.35,152.87 137.79,152.87 136.77,153.89 64.13,153.89 60.07,157.95 50.92,157.95 48.89,159.98 34.16,159.98 32.13,157.95 22.98,157.95 22.47,158.46 22.47,162.01 21.46,162.01 B02.R2
DTB_11
  Route2 0.254: A25.N2 386.71,238.72 388.23,238.72 390.27,240.75 390.77,240.75 393.82,243.8 393.82,250.41 397.38,253.96 397.38,263.61 403.47,269.71 403.47,271.23 402.97,271.74 384.17,271.74 375.53,280.38 280.03,280.38 268.85,291.55 251.07,291.55 228.72,269.2 227.71,269.2 210.43,251.93 210.43,249.9 190.62,230.09 190.62,228.56 187.57,225.51 187.57,225.01 171.32,208.75 171.32,208.24 170.81,207.73 169.79,207.73 162.68,200.62 162.68,199.61 158.62,195.54 152.52,195.54 149.47,192.49 148.46,192.49 140.84,184.87 140.84,182.84 139.31,181.32 B09.J1
  Bottom 0.254: B09.J1 138.3,181.32 135.76,183.86 B09.H2
DTB_11\  (via drill 0.61)
  Route2 0.254: v116.45,164.05 116.45,164.55 123.57,171.67 123.57,172.17 132.2,180.81 B09.J2
  Bottom 0.254: v116.45,164.05 113.91,164.05 110.87,161 88.51,161 85.97,163.54 64.13,163.54 63.62,163.03 62.1,163.03 60.57,161.51 60.57,161 55.49,161 54.48,159.98 49.91,159.98 49.4,160.49 29.59,160.49 28.57,159.47 25.01,159.47 B02.S2
DTF  (via drill 0.61)
  Top 0.254: v446.15,1.99 446.65,2.5 446.65,249.39 v446.15,249.9 | v193.67,245.83 193.67,256.5 191.64,258.53 191.64,288.51 v192.15,289.01
  Route2 0.254: v193.67,245.83 189.61,241.77 A12.M1
  Route15 0.254: v142.36,243.8 v136.27,249.9 | v176.91,3.01 170.3,9.61 D11.V1 | v428.37,249.9 411.6,266.66 A26.C1 | v387.22,289.01 387.22,288.51 408.55,267.17 v409.06,267.17
  Bottom 0.254: v136.27,249.9 124.07,249.9 123.06,250.91 A08.J1 | v142.36,243.8 184.53,243.8 186.56,241.77 189.1,241.77 A12.M1 | v176.91,3.01 191.64,3.01 192.65,1.99 282.06,1.99 283.08,3.01 284.09,3.01 285.62,1.49 445.64,1.49 v446.15,1.99 | v446.15,249.9 v428.37,249.9 | v192.15,289.01 192.65,289.52 205.35,289.52 205.86,289.01 207.89,289.01 208.91,290.03 258.69,290.03 259.71,289.01 260.73,289.01 261.74,290.03 364.36,290.03 365.37,289.01 v387.22,289.01 | v409.06,267.17 411.6,267.17 A26.C1
DTF\  (via drill 0.61)
  Top 0.254: v159.63,14.19 159.63,59.91 158.62,60.92 158.62,61.94 159.13,62.45 159.13,72.61 157.6,74.13 157.6,80.73 156.59,81.75 156.59,98.01 156.08,98.51 156.08,107.66 v155.57,108.17 | v185.03,148.3 185.03,195.03 185.54,195.54 189.61,195.54 189.61,196.56 B12.C1 | v52.95,170.65 52.95,174.71 B04.L2
  Route2 0.254: v151,112.74 153.03,114.77 153.54,114.77 161.67,122.9 161.67,123.91 166.75,128.99 167.25,128.99 168.27,130.01 168.27,131.03 171.32,134.07 171.32,134.58 v185.03,148.3
  Route15 0.254: v159.63,14.19 163.7,10.12 D11.V2 | v155.57,108.17 v151,112.74 150.49,113.25 147.44,113.25 130.17,130.52 130.17,132.04 v113.91,148.3 | v67.18,168.11 67.18,167.6 v82.42,152.36
  Bottom 0.254: v52.95,170.65 62.1,170.65 63.11,169.63 65.65,169.63 v67.18,168.11 | v82.42,152.36 83.43,151.35 91.56,151.35 95.63,147.28 108.83,147.28 109.34,147.79 111.88,147.79 112.39,148.3 v113.91,148.3
DTSF
  Route2 0.254: C05.B1 75.81,130.52 77.34,130.52 79.88,133.06 79.88,135.09 82.93,138.14 82.93,139.15 95.63,151.85 95.63,153.89 100.2,158.46 100.2,159.47 108.33,167.6 108.33,171.67 109.34,172.68 112.39,172.68 122.04,182.33 131.69,182.33 141.35,191.99 142.36,191.99 153.03,202.65 153.03,204.18 172.84,223.99 174.87,223.99 180.97,230.09 182.49,230.09 183,230.59 184.53,230.59 186.05,232.12 A12.R1
EA_00\  (via drill 0.61)
  Top 0.254: 85.97,166.08 85.97,148.3 84.96,147.28 84.96,133.06 85.97,132.04 85.97,78.19 84.96,77.18 84.96,62.95 85.97,61.94 85.97,13.68 84.96,12.66 84.96,10.63 D06.V2 | 85.97,166.08 85.97,201.13 84.96,202.15 84.96,218.91 A06.V2 | 85.97,166.08 v85.47,166.08
  Route2 0.254: v85.47,166.08 v81.4,162.01
  Bottom 0.254: v81.4,162.01 75.81,162.01 B05.R1
EA_01\
  Top 0.254: 83.43,136.61 79.37,136.61 78.86,137.12 78.86,150.84 79.88,151.85 79.88,157.44 78.86,158.46 B05.S1 | 83.43,136.61 83.43,221.96 84.45,222.97 84.45,225.51 A06.T2 | 83.43,136.61 83.43,17.74 84.45,16.73 D06.T2
EA_02\
  Top 0.254: D06.S2 88.51,19.77 89.02,20.28 89.02,67.02 88.51,67.53 88.51,81.24 89.02,81.75 89.02,205.19 86.48,207.73 86.48,227.55 87.5,228.56 A06.S2
  Route2 0.254: B05.H2 71.75,184.87 64.13,184.87 63.62,185.38 63.62,186.4 70.23,193 70.23,199.61 73.27,202.65 73.27,204.69 76.32,207.73 76.32,208.75 95.63,228.05 95.63,231.61 97.15,233.13 97.15,234.15 96.13,235.17 95.12,234.15 91.05,234.15 90.04,233.13 90.04,231.61 88.01,229.58 A06.S2
EF  (via drill 0.61)
  Top 0.254: A12.F1 186.56,257.01 186.56,253.45 187.57,252.44 187.57,248.37 186.56,247.36 186.56,245.33 A12.L1 | v397.89,238.72 397.89,245.33 398.39,245.83 398.39,259.55 397.89,260.06 v397.89,291.55 | v191.13,291.55 v191.13,257.52
  Route2 0.254: v183,257.52 v176.91,251.42
  Bottom 0.254: v397.89,238.72 393.31,238.72 A25.N1 | v397.89,291.55 397.38,292.06 191.64,292.06 v191.13,291.55 | v191.13,257.52 186.56,257.52 A12.F1 186.05,257.52 v183,257.52 | v176.91,251.42 170.81,251.42 A11.J1
EF\  (via drill 0.61)
  Top 0.254: v171.83,235.67 172.33,236.18 172.33,243.8 173.86,245.33 173.86,247.87 A11.K1
  Route2 0.254: v68.19,208.24 67.18,208.24 62.61,203.67 B04.A1 | v145.41,206.72 145.92,206.72 159.13,219.93 159.13,221.45 161.67,223.99 161.67,225.51 v171.83,235.67
  Bottom 0.254: v68.19,208.24 68.7,207.73 72.26,207.73 72.77,207.23 78.86,207.23 79.37,207.73 87.5,207.73 88.01,208.24 91.05,208.24 91.56,208.75 97.15,208.75 99.69,206.21 106.29,206.21 106.8,206.72 118.99,206.72 120.01,207.73 125.6,207.73 127.12,206.21 140.33,206.21 140.84,206.72 v145.41,206.72
END  (via drill 0.61)
  Route2 0.254: v150.49,285.46 126.11,261.07 A08.E1
  Route15 0.254: v336.93,286.98 350.13,273.77 350.13,273.27 366.9,256.5 367.41,256.5 378.58,245.33 378.58,244.82 381.63,241.77 381.63,241.26 388.74,234.15 390.27,234.15 392.3,232.12 A25.R1
  Bottom 0.254: v336.93,286.98 336.42,287.49 264.28,287.49 263.27,286.47 257.17,286.47 256.15,287.49 211.45,287.49 210.43,286.47 203.32,286.47 202.81,286.98 195.7,286.98 194.69,285.97 151,285.97 v150.49,285.46
END\  (via drill 0.61)
  Top 0.254: v59.56,189.45 59.56,188.43 B04.F1 | v121.03,245.33 121.03,252.95 v122.04,253.96 122.55,254.47 122.55,257.01 A08.F1
  Route2 0.254: v59.56,189.45 59.56,189.95 v67.69,198.08 | v75.31,198.08 75.81,198.08 113.41,235.67 113.41,237.71 v121.03,245.33
  Route15 0.254: v133.73,241.77 127.63,247.87 127.63,248.37 v122.04,253.96
  Bottom 0.254: v67.69,198.08 v75.31,198.08 | v133.73,241.77 135.25,241.77 A09.M2
ENI  (via drill 0.61)
  Top 0.254: v107.31,126.96 107.82,126.45 107.82,106.13 107.31,105.63 C07.L1 | v184.02,141.69 183.51,142.2 183.51,150.33 184.53,151.35 184.53,195.54 185.03,196.05 v185.03,227.55 185.03,241.77 184.53,242.28 184.53,247.36 185.03,247.87 v185.03,254.47
  Route2 0.254: v107.31,126.96 121.53,141.19 v121.53,142.2 | v380.61,244.31 374.52,238.21 374.52,237.71 374.01,237.2 373.5,237.2 366.39,230.09 366.39,229.07 v364.87,227.55
  Bottom 0.254: v121.53,142.2 122.04,141.69 132.71,141.69 133.73,140.68 142.36,140.68 142.87,141.19 167.25,141.19 167.76,141.69 v184.02,141.69 | v185.03,254.47 189.1,254.47 A12.H1 | v380.61,244.31 381.12,243.8 390.77,243.8 391.28,244.31 392.3,244.31 A25.L1 | v364.87,227.55 288.67,227.55 288.16,228.05 286.13,228.05 285.62,227.55 v185.03,227.55
ENI\  (via drill 0.61)
  Top 0.254: v37.21,171.16 37.21,174.21 B03.L2
  Route2 0.254: v33.65,167.6 v37.21,171.16
  Route15 0.254: v33.65,167.6 50.92,150.33 50.92,149.82 57.53,143.22 59.56,143.22 69.72,133.06 69.72,132.04 70.23,131.53 70.23,131.03 71.75,129.5 72.26,129.5 79.88,121.88 79.88,120.87 88.01,112.74 88.51,112.74 89.02,112.23 89.02,111.72 v100.2,100.55
  Bottom 0.254: v100.2,100.55 104.77,100.55 106.29,102.07 109.34,102.07 C07.M1
FR_00  (via drill 0.61)
  Top 0.254: v183.51,73.62 183.51,82.77 C12.U2 | v110.87,74.64 111.37,75.15 111.37,155.92 110.36,156.93 110.36,158.46 B07.S1 | v392.81,259.55 392.81,258.03 A25.F1 | v181.99,198.59 181.99,194.53 183,193.51 183,190.97 B12.E2
  Route2 0.254: v146.93,186.4 143.38,182.84 142.36,182.84 126.61,167.09 125.6,167.09 v113.41,154.9 | v262.25,278.35 246.5,262.6 245.99,262.6 238.88,255.49 238.88,253.96 222.12,237.2 221.1,237.2 209.42,225.51 209.42,224.5 197.23,212.31 196.72,212.31 189.61,205.19 188.59,205.19 v181.99,198.59
  Route15 0.254: v156.08,72.61 v152.52,76.16 | v113.41,154.9 109.85,158.46 B07.S1 | v392.81,259.55 381.12,271.23 380.11,271.23 v372.99,278.35
  Bottom 0.254: v183.51,73.62 183,74.13 160.65,74.13 159.63,73.11 156.59,73.11 v156.08,72.61 | v152.52,76.16 152.01,76.67 146.43,76.67 145.92,76.16 128.65,76.16 127.63,75.15 113.91,75.15 113.41,74.64 v110.87,74.64 | v146.93,186.4 149.98,186.4 150.49,186.91 152.52,186.91 153.03,186.4 175.38,186.4 179.45,190.46 183,190.46 B12.E2 | v372.99,278.35 372.49,277.84 359.28,277.84 358.77,277.33 272.92,277.33 271.9,278.35 v262.25,278.35
FR_00\  (via drill 0.61)
  Top 0.254: C12.K1 190.11,108.17 190.11,104.1 191.13,103.09 191.13,99.02 190.11,98.01 190.11,95.97 C12.P1 | v110.36,146.27 110.36,152.36 B07.U1
  Route15 0.254: v80.39,145.76 80.39,146.27 62.61,164.05 62.1,164.05 v59.05,167.09 | v162.17,136.61 175.38,123.41 175.38,119.34 182.49,112.23 183.51,112.23 185.54,110.2 187.57,110.2 189.61,108.17 C12.K1 | v120.01,136.61 v110.36,146.27
  Bottom 0.254: v110.36,146.27 80.89,146.27 v80.39,145.76 | v59.05,167.09 58.54,167.6 51.43,167.6 50.92,168.11 45.33,168.11 44.83,168.62 43.81,168.62 B03.N1 | v162.17,136.61 161.67,136.11 153.03,136.11 152.52,136.61 132.71,136.61 132.2,137.12 120.52,137.12 v120.01,136.61
FR_01
  Top 0.254: 101.72,9.11 104.26,6.57 104.26,6.06 108.33,1.99 181.99,1.99 181.99,15.71 186.05,19.77 186.05,22.31 D12.R1 | 101.72,9.11 101.21,9.61 D07.V2 | 101.72,9.11 101.72,61.94 100.71,62.95 100.71,77.69 101.72,78.7 101.72,131.53 100.71,132.55 100.71,148.81 B07.V2 | C15.D1 234.31,124.93 235.83,126.45 235.83,170.14 236.85,171.16 B15.M1 237.36,172.17 239.39,174.21 239.39,179.79 238.88,180.3 238.88,243.8 226.18,256.5 226.18,289.52 228.72,292.06 394.84,292.06 394.84,255.49 395.35,254.98 A25.H1
  Bottom 0.254: A10.H1 158.62,254.98 159.63,255.99 394.33,255.99 395.35,254.98 A25.H1 | D12.R1 186.56,22.31 186.56,18.25 242.95,18.25 258.69,34 262.25,34 274.95,46.7 278,46.7 290.7,59.4 298.32,59.4 327.27,88.35 327.27,164.05 299.84,164.05 291.21,172.68 270.89,172.68 270.38,173.19 238.37,173.19 237.36,172.17 B15.M1
FR_01\  (via drill 0.61)
  Top 0.254: v102.23,149.31 102.23,150.84 101.72,151.35 101.72,165.57 v101.21,166.08 | v181.48,229.07 181.99,229.58 181.99,251.93 183,252.95 183,253.96 A12.H2
  Route2 0.254: v181.48,229.07 175.38,222.97 175.38,221.96 174.87,221.45 174.87,220.94 166.24,212.31 v165.73,212.31 | v97.66,210.78 79.37,192.49 77.85,192.49 v76.32,190.97
  Route15 0.254: v101.21,166.08 96.64,170.65 96.64,171.16 84.96,182.84 84.45,182.84 v76.32,190.97
  Bottom 0.254: B03.D2 37.71,194.02 39.75,194.02 41.27,192.49 63.11,192.49 65.15,190.46 71.75,190.46 B05.E2 72.26,190.46 74.29,190.46 74.8,190.97 v76.32,190.97 | v102.23,149.31 106.8,149.31 B07.V1 | v165.73,212.31 164.21,210.78 130.17,210.78 129.66,211.29 120.52,211.29 120.01,210.78 v97.66,210.78
FR_02  (via drill 0.61)
  Top 0.254: v104.77,75.65 105.28,75.15 105.28,14.69 104.26,13.68 D07.U2 103.75,12.66 103.75,8.09 v105.28,6.57 | v114.93,85.81 113.91,86.83 113.91,94.96 114.93,95.97 114.93,103.09 114.42,103.59 114.42,111.72 114.93,112.23 114.93,120.36 v114.42,120.87 | v392.81,246.85 392.81,250.91 A25.J1 | v380.61,233.64 381.12,233.13 381.12,225.01 381.63,224.5 381.63,216.88 381.12,216.37 381.12,215.35 382.65,213.83 382.65,184.37 382.14,183.86 382.14,182.84 383.66,181.32 383.66,5.04 v383.15,4.53
  Route2 0.254: v104.77,75.65 v114.93,85.81 | v392.81,246.85 381.63,235.67 381.63,234.66 v380.61,233.64
  Bottom 0.254: v114.42,120.87 113.91,121.37 110.36,121.37 C07.E1 | v383.15,4.53 383.15,3.52 287.65,3.52 286.13,5.04 284.09,5.04 283.08,6.06 271.9,6.06 270.89,5.04 270.38,5.04 269.36,4.03 194.69,4.03 193.67,5.04 179.45,5.04 178.94,5.55 155.57,5.55 155.06,6.06 140.84,6.06 140.33,6.57 139.31,6.57 138.81,7.07 125.6,7.07 125.09,6.57 v105.28,6.57
FR_02\  (via drill 0.61)
  Top 0.254: v106.8,121.88 106.8,118.33 C07.F1
  Route15 0.254: v106.8,121.88 96.13,132.55 96.13,134.07 89.02,141.19 88.01,141.19 82.93,146.27 82.42,146.27 64.13,164.55 64.13,165.57 60.57,169.13 60.57,169.63 59.05,171.16 58.54,171.16 58.03,171.67 58.03,173.19 47.87,183.35 47.87,184.87 41.78,190.97 40.76,190.97 B03.E2
FR_03  (via drill 0.61)
  Top 0.254: D07.V1 106.8,10.63 106.8,14.19 105.79,15.2 105.79,78.19 105.28,78.7 105.28,109.69 104.26,110.71 104.26,112.23 103.75,112.74 103.75,114.26 C07.H2 | v113.41,140.17 112.9,139.66 112.9,119.34 v113.41,118.83
  Route2 0.254: v202.31,139.66 203.32,140.68 206.37,140.68 219.07,153.38 219.07,153.89 221.1,155.92 221.61,155.92 227.71,162.01 B15.R2 | v109.34,118.83 104.77,114.26 103.75,114.26 C07.H2 | v351.66,246.85 351.15,246.85 339.47,235.17 v339.47,234.66 | v334.39,234.66 334.39,234.15 312.03,211.8 311.53,211.8 302.38,202.65 302.38,201.64 286.63,185.89 284.6,185.89 270.89,172.17 270.89,171.67 v263.27,164.05
  Bottom 0.254: v202.31,139.66 180.97,139.66 179.95,138.65 160.65,138.65 159.63,137.63 154.55,137.63 154.05,138.14 147.95,138.14 145.92,140.17 143.89,140.17 143.38,139.66 132.71,139.66 131.69,140.68 128.14,140.68 127.12,139.66 113.91,139.66 v113.41,140.17 | v113.41,118.83 v109.34,118.83 | v351.66,246.85 391.28,246.85 392.81,248.37 395.35,248.37 A25.K1 | v334.39,234.66 v339.47,234.66 | v263.27,164.05 232.79,164.05 230.75,162.01 228.21,162.01 B15.R2
FR_03\  (via drill 0.61)
  Top 0.254: v112.9,110.2 112.39,110.71 112.39,147.28 | 112.39,147.28 112.39,169.13 112.9,169.63 v112.9,177.76 | v112.9,147.28 112.39,147.28
  Route2 0.254: v112.9,177.76 115.95,180.81 B08.J2
  Route15 0.254: v74.8,146.77 73.78,146.77 69.21,151.35 68.19,151.35 50.92,168.62 50.92,169.13 43.3,176.75 42.79,176.75 41.27,178.27 40.76,178.27 B03.K2
  Bottom 0.254: v112.9,110.2 101.72,110.2 100.71,111.21 C07.J2 | v74.8,146.77 109.34,146.77 109.85,147.28 v112.9,147.28
GND
  Top 0.254: A23.T1 360.8,225.51 360.8,219.93 A23.V1 | 359.28,266.66 363.85,266.66 A23.C1 | 359.28,266.66 358.77,266.66 A23.C2 | 359.79,249.9 359.28,249.39 359.28,242.79 | 359.79,249.9 360.8,250.91 A23.J1 | 359.28,242.79 358.77,242.28 A23.M2 | 363.34,236.18 362.83,236.69 362.83,239.23 359.28,242.79 | 363.34,236.18 363.85,235.67 A23.P1 | 359.28,257.01 359.79,257.01 359.79,249.9 | 359.28,257.01 355.21,257.01 A23.F2 | A26.D2 401.95,263.61 398.9,260.57 398.9,238.21 398.39,237.71 395.35,237.71 395.35,241.26 A25.M1 | 359.28,257.01 359.28,266.66 | 363.34,236.18 363.34,223.48 363.85,222.97 A23.U1 | AB19.AT2 290.7,226.53 290.7,231.61 AB19.AR2 291.71,232.63 292.73,233.64 292.73,249.9 | AB19.AU2 293.75,222.97 293.75,228.56 AB19.AS2 | 292.73,249.9 293.75,248.88 293.75,248.37 AB19.AK2 | 292.73,249.9 291.71,250.91 AB19.AJ2 291.71,251.93 293.24,253.45 293.24,266.15 293.75,266.66 AB19.AC2 | AB19.BM2 293.75,172.17 293.75,174.21 293.24,174.71 AB19.BL2 292.22,175.73 291.21,176.75 291.21,186.4 292.22,187.41 AB19.BF2 293.24,188.43 293.75,188.94 293.75,190.46 AB19.BE2 | B22.V1 345.56,149.82 348.1,152.36 B22.U1 348.1,152.87 345.56,155.41 B22.T1 344.55,155.41 343.02,155.41 | 343.02,155.41 338.96,155.41 B22.T2 | 343.02,196.05 343.02,155.41 | 343.02,196.05 342.51,196.56 B22.C2 | A16.T1 249.55,225.51 248.53,224.5 248.53,199.1 247.01,197.57 B16.C2 | 343.02,196.05 343.02,213.83 354.71,225.51 A23.T2 | D11.T1 170.3,15.71 164.71,15.71 D11.T2 | D04.R2 52.45,23.33 52.45,28.41 D04.N2 52.45,29.43 52.45,35.01 D04.L2 52.45,36.03 52.45,41.11 D04.J2 52.45,42.13 52.45,47.71 D04.F2 | D04.U2 56.51,13.68 58.54,15.71 D04.T1 58.54,16.73 58.54,22.31 D04.R1 59.05,23.33 59.05,28.41 D04.N1
  Top 0.254: D02.F2 20.95,47.71 20.95,42.13 D02.J2 20.95,41.11 20.95,36.03 D02.L2 20.95,35.01 20.95,29.43 D02.N2 20.95,28.41 20.95,23.33 D02.R2 | D02.U2 25.01,13.68 27.05,15.71 D02.T1 27.05,16.73 27.05,22.31 D02.R1 27.05,23.33 27.05,28.41 D02.N1 | D03.R2 36.7,23.33 36.7,28.41 D03.N2 36.7,29.43 36.7,35.01 D03.L2 36.7,36.03 36.7,41.11 D03.J2 36.7,42.13 36.7,47.71 D03.F2 | D03.N1 43.3,28.41 43.3,23.33 D03.R1 43.3,22.31 43.3,16.73 D03.T1 | D06.R2 84.45,23.33 84.45,28.41 D06.N2 84.45,29.43 84.45,35.01 D06.L2 | D06.U2 88.51,13.68 90.55,15.71 D06.T1 90.55,16.73 90.55,22.31 D06.R1 90.55,23.33 90.55,28.41 D06.N1 | D06.F2 84.45,47.71 84.45,42.13 D06.J2 | D05.N1 75.81,29.43 78.35,31.97 D05.M1 78.35,32.47 75.81,35.01 D05.L1 | D05.J1 75.81,42.13 78.35,44.67 D05.H1 78.35,45.17 75.81,47.71 D05.F1 | D05.J2 68.7,41.11 68.7,36.03 D05.L2 68.7,35.01 68.7,29.43 D05.N2 68.7,28.41 68.7,23.33 D05.R2 | D05.T1 75.81,16.73 78.35,19.27 D05.S1 78.35,19.77 75.81,22.31 D05.R1 75.81,22.82 78.35,25.36 D05.P1 | D06.A1 94.1,63.46 94.1,57.87 D06.C1 | D02.A1 30.6,63.46 30.6,57.87 D02.C1 | D03.A1 46.35,63.46 46.35,57.87 D03.C1 | D05.D1 75.81,54.83 78.35,57.37 D05.C1 78.35,57.87 76.32,59.91 | D04.A1 61.59,63.46 61.59,57.87 D04.C1 | D05.F2 68.7,48.73 68.7,53.81 D05.D2 | 76.32,59.91 75.81,60.41 D05.B1 | 76.32,59.91 76.32,85.31 75.81,85.81 C05.T1 | A03.F2 36.7,257.01 36.7,251.42 A03.J2 36.7,250.41 36.7,244.82 A03.L2 36.7,244.31 36.7,238.72 A03.N2 36.7,237.71 36.7,232.12 A03.R2 | A03.N1 43.3,237.71 43.3,232.12 A03.R1 43.3,231.61 43.3,226.02 A03.T1 | A04.F2 52.45,257.01 52.45,251.42 A04.J2 52.45,250.41 52.45,244.82 A04.L2 52.45,244.31 52.45,238.72 A04.N2 52.45,237.71 52.45,232.12 A04.R2