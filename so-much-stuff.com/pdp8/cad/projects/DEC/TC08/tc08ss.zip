# EAGLE board tc08ss (EAGLE 4.11), part 2 of 2
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
N$135 (continued)
  Bottom 0.254: 125.97,180.81 123.94,178.78 119.36,178.78 B20.K2 | 125.97,180.81 128,180.81 AB19.BJ2 | 125.97,180.81 119.36,187.41 119.36,190.46 B20.E2
N$136
  Bottom 0.254: A21.J2 99.55,251.93 98.03,253.45 98.03,261.58 100.06,263.61 A21.D2 100.57,264.63 104.12,264.63 105.14,265.65 117.84,265.65 148.83,234.66 148.83,172.17 140.7,164.05 131.05,164.05 129.02,166.08 129.02,168.11 AB19.BN2
N$138
  Bottom 0.254: A10.U2 252.97,222.97 256.53,222.97 261.1,227.55 270.24,227.55 271.26,228.56 A09.S1
N$139
  Bottom 0.254: A10.T2 249.41,226.53 251.95,229.07 A10.S2
N$140
  Bottom 0.254: 104.63,259.55 104.63,253.96 103.62,252.95 103.62,248.37 A21.K2 | 104.63,259.55 103.62,260.57 A21.E2 | 104.63,259.55 110.22,265.14 117.33,265.14 146.29,236.18 146.29,171.16 145.78,170.65 140.7,170.65 136.13,166.08 132.07,166.08 AB19.BP2
N$142
  Bottom 0.254: C09.R1 268.72,99.53 276.34,99.53 278.37,101.56 280.4,101.56 C08.P2
N$150
  Bottom 0.254: D16.S2 173.21,25.36 178.8,25.36 D16.S1
N$151
  Bottom 0.254: D16.V2 170.17,16.73 170.17,20.79 171.18,21.81 171.18,27.39 170.17,28.41 D16.R2
N$153
  Bottom 0.254: A10.J2 248.91,251.93 248.91,257.01 A10.F2
N$161
  Bottom 0.254: A11.F1 243.32,257.01 243.32,254.98 248.91,249.39 253.48,249.39 257.03,245.83 257.03,240.25 261.61,235.67 264.65,235.67 A09.P2
N$162
  Bottom 0.254: A12.D1 229.6,264.63 229.6,269.71 A12.B1 230.62,269.71 233.16,269.71 245.86,257.01 245.86,254.98 A11.H1
NC
  Bottom 0.254: 206.74,18.76 207.25,18.25 208.27,18.25 212.33,14.19 241.29,14.19 244.84,10.63 280.91,10.63 281.42,10.12 293.1,10.12 301.23,18.25 301.23,18.76 301.74,18.76 304.28,21.3 304.28,23.84 295.64,32.47 295.64,34 292.59,37.05 292.59,61.94 291.07,63.46 291.07,64.48 289.04,66.51 289.04,73.11 278.88,83.27 278.88,89.88 279.89,90.89 281.42,90.89 282.43,89.88 282.43,84.29 283.45,83.27 284.47,83.27 285.99,81.75 298.18,81.75 318.5,61.43 318.5,57.87 D05.E2 | B20.H2 118.86,184.37 118.86,180.3 116.32,177.76 116.32,175.73 B20.L2 116.32,174.71 118.86,172.17 B20.M2 119.36,172.17 122.92,172.17 124.44,173.7 139.69,173.7 140.7,174.71 B18.L2 | B18.L2 141.72,174.71 144.26,172.17 B18.M2 | B18.H2 144.26,184.37 144.26,180.3 141.72,177.76 141.72,175.73 B18.L2 | 59.42,269.2 60.95,269.2 61.45,269.71 A24.B2 61.96,270.73 64.5,273.27 A24.A2 | 59.42,269.2 48.75,269.2 44.18,264.63 40.12,264.63 A26.D1 | 59.42,269.2 59.42,258.03 61.45,255.99 61.45,251.93 A24.J2
PC+ES
  Bottom 0.254: A11.H2 239.25,254.98 239.25,258.53 233.67,264.12 233.67,266.66 A12.C1
PWR_CLR\
  Bottom 0.254: C14.R1 201.15,98.51 201.15,96.99 214.36,83.78 230.62,83.78 235.19,88.35 239.76,88.35 240.27,88.86 C11.U2
RD_EN
  Bottom 0.254: C11.N2 236.71,105.63 236.71,108.17 242.3,113.75 242.3,117.31 C11.J1
RD_EN_LPB_00-02
  Bottom 0.254: D09.R1 268.72,29.43 268.72,33.49 272.78,37.55 272.78,43.65 271.76,44.67 D09.K1
RD_EN_LPB_03-05
  Bottom 0.254: D09.N2 261.61,36.03 260.08,37.55 260.08,39.59 249.92,49.75 245.35,49.75 241.29,53.81 241.29,58.38 240.78,58.89 238.24,58.89 238.24,54.83 244.84,48.22 244.84,42.13 260.08,26.89 260.08,21.3 261.61,19.77 264.65,19.77 D09.U2
RDD_00
  Bottom 0.254: D09.F2 262.11,54.83 262.11,58.38 267.19,63.46 267.19,68.54 269.23,68.54 271.26,66.51 271.26,64.48 D09.C1
RDD_01
  Bottom 0.254: D09.M2 265.67,39.08 265.67,42.13 267.7,44.16 267.7,47.71 D09.J1
RDD_02
  Bottom 0.254: D09.T2 262.11,23.33 264.65,23.33 271.26,29.93 271.26,31.97 D09.P1
RDMK
  Bottom 0.254: CD18.AS2 144.26,95.97 144.26,100.04 143.24,101.05 143.24,151.35 144.26,152.36 B18.U2
RSTA\
  Bottom 0.254: 350.5,179.29 350.5,180.81 B03.J1 351.01,180.81 354.57,180.81 355.59,179.79 355.59,164.05 | 350.5,179.29 350.5,178.78 347.97,176.24 347.97,172.17 B03.M2 | 350.5,179.29 347.97,181.83 | 347.97,181.83 344.92,184.87 344.92,187.41 B03.F2 | 347.97,181.83 355.08,188.94 355.08,191.99 354.57,192.49 354.57,197.07 B03.C1 | 355.59,164.05 355.59,157.44 341.87,143.73 341.87,140.68 C04.A1 | 355.59,164.05 354.57,165.06 B03.P1
SEL\
  Bottom 0.254: A09.N2 262.11,239.23 265.67,239.23 277.35,250.91 A08.J2
SH_DTB
  Bottom 0.254: C09.B1 267.7,136.61 265.16,136.61 262.11,133.57 262.11,131.03 C09.D2 262.11,130.01 262.11,126.45 263.13,125.44 263.13,119.85 | 263.13,104.61 263.13,110.2 | 263.13,104.61 263.13,91.4 260.59,88.86 260.59,85.31 261.1,84.8 263.13,84.8 263.13,89.37 264.65,90.89 264.65,95.47 C09.S2 | 263.13,110.2 262.11,111.21 C09.L2 | 263.13,104.61 267.19,104.61 | 267.19,104.61 267.7,104.61 C09.N1 | 267.19,104.61 267.19,119.34 268.72,120.87 271.26,120.87 C09.H1 | 263.13,110.2 263.13,119.85 | 267.7,167.09 267.7,168.11 B09.N1 | 267.7,167.09 267.7,165.57 265.67,163.54 265.67,159.47 B09.S2 | 262.11,172.68 262.11,174.21 B09.L2 | 266.18,168.62 267.7,167.09 | 266.18,168.62 262.11,172.68 | 262.11,172.68 271.26,181.83 271.26,183.86 B09.H1 271.76,184.87 271.76,188.43 272.78,189.45 272.78,204.69 260.08,204.69 | B10.E1 259.06,190.97 261.61,193.51 B09.D2 262.11,194.02 262.11,196.56 265.16,199.61 | 265.16,199.61 267.7,199.61 B09.B1 | 260.08,204.69 265.16,199.61 | 260.08,204.69 247.89,216.88 247.89,227.04 248.91,228.05 248.91,231.61 A10.R2 | 263.13,119.85 257.54,119.85 257.54,122.9 258.56,123.91 258.56,124.93 260.08,126.45 260.08,155.41 257.54,157.95 257.54,159.98 266.18,168.62
SH_EN
  Bottom 0.254: C10.M1 258.56,108.67 258.56,112.74 254.49,116.8 254.49,123.41 255,123.91 C10.F1 256.02,124.93 257.03,125.95 257.03,134.58 258.56,136.11 258.56,139.66 C10.A1 | A11.N2 236.21,239.23 233.67,239.23 229.09,243.8 229.09,247.87 231.63,250.41 231.63,251.93 227.57,255.99 227.57,260.57 A12.E2
SH_EN\
  Bottom 0.254: A12.V2 224.01,219.93 227.57,219.93 240.78,233.13 240.78,239.74 239.25,241.26 A11.M2 | C10.J1 256.02,118.33 256.02,122.39 257.54,123.91 257.54,132.55 258.56,133.57 C10.C1
SH_ST
  Bottom 0.254: CD18.AM1 151.37,108.67 151.37,112.74 164.58,125.95 164.58,139.15 164.07,139.66 C17.A1
ST_DATA
  Bottom 0.254: C16.J2 170.17,117.31 173.72,117.31 178.29,112.74 187.44,112.74 197.09,122.39 209.79,122.39 210.81,121.37 C13.H2
ST_FINAL
  Bottom 0.254: C13.L1 214.87,112.23 214.87,114.77 221.98,121.88 221.98,125.44 231.63,135.09 235.7,135.09 239.76,131.03 242.3,131.03 C11.D1
ST_FINAL\
  Bottom 0.254: C13.M1 216.9,108.17 216.9,105.63 211.31,100.04 200.65,100.04 200.14,99.53 200.14,96.99 214.87,82.26 236.71,82.26 247.38,92.93 247.38,98.51 240.27,105.63 240.27,108.17 C11.M2
ST_IDLE\
  Bottom 0.254: A09.E2 264.65,260.57 264.65,256.5 257.54,249.39 257.54,245.33 260.59,242.28 260.59,237.71 261.1,237.2 266.69,237.2 267.7,238.21 A09.N1
ST_REV_CK
  Bottom 0.254: 147.81,19.27 149.34,17.74 149.34,16.73 152.89,13.17 176.26,13.17 200.14,37.05 206.23,37.05 218.93,49.75 218.93,53.3 222.49,56.86 224.01,56.86 224.52,56.35 228.08,56.35 228.59,56.86 229.6,56.86 241.29,68.54 243.83,68.54 244.33,68.03 244.84,68.54 250.43,68.54 250.94,68.03 252.97,68.03 257.03,72.1 266.69,72.1 270.75,68.03 271.76,68.03 272.78,69.05 272.78,72.1 260.08,84.8 260.08,89.37 260.59,89.88 260.59,103.59 254.49,109.69 254.49,113.75 253.99,114.26 253.99,121.88 252.46,123.41 252.46,123.91 255,126.45 255,127.47 250.43,132.04 250.43,132.55 245.86,137.12 245.86,139.66 C11.A1 | D12.F2 224.01,53.81 226.55,51.27 D12.H2
SWTM
  Bottom 0.254: C15.L1 188.45,111.21 184.9,111.21 180.83,107.15 180.83,96.99 196.07,81.75 241.79,81.75 250.94,90.89 250.94,102.58 248.91,104.61 C10.N2
SYNC-P\
  Bottom 0.254: B13.K2 211.31,178.27 213.85,178.27 219.44,183.86 219.44,193 216.39,196.05 216.39,202.65 216.9,203.16 B13.A1
T3
  Top 0.254: D12.N1 230.62,35.01 233.16,32.47 D12.P1 233.67,32.47 236.21,32.47 250.43,46.7 272.78,46.7 295.64,69.56 295.64,71.08 294.62,72.1 293.1,72.1 291.58,73.62 285.99,73.62 283.96,71.59 274.81,71.59 272.78,73.62 216.39,73.62 214.36,71.59 211.31,71.59 209.28,73.62 203.69,73.62 201.66,71.59 195.06,71.59 193.03,73.62 185.91,73.62 164.07,95.47 C17.S1
T_01\
  Bottom 0.254: A23.S1 83.8,228.56 82.79,227.55 82.79,186.91 76.69,180.81 76.69,176.75 77.2,176.24 77.2,172.17 B23.M2 78.22,171.16 79.74,169.63 79.74,152.36 78.72,151.35 70.09,151.35 64.5,156.93 61.96,156.93 53.83,165.06 53.83,224.5 56.88,227.55 56.88,236.69 59.42,239.23 59.42,244.82 60.95,246.34 62.98,246.34 64.5,244.82 64.5,242.28 A24.M2
T_03\
  Bottom 0.254: 65.52,238.21 65.52,238.72 74.15,247.36 74.15,250.91 A23.J2 | 65.52,238.21 65.52,235.67 A24.P2 | 65.52,238.21 59.93,232.63 59.93,168.11 73.64,154.39 75.68,154.39 75.68,158.97 77.2,160.49 77.2,165.06 B23.P2
T_04\
  Bottom 0.254: A24.R2 62.47,232.63 66.03,232.63 71.61,238.21 74.15,238.21 A23.N2
T_05\
  Bottom 0.254: A24.S2 65.52,229.58 69.58,229.58 75.17,235.17 77.2,235.17 A23.P2
T_06\
  Bottom 0.254: 76.19,223.99 67.55,223.99 66.03,225.51 62.47,225.51 A24.T2 | 76.19,223.99 77.2,222.97 A23.U2 | 76.19,223.99 76.19,180.3 73.14,177.25 73.14,161.51 74.15,160.49 74.15,155.92 B23.T2
T_07\
  Bottom 0.254: A24.U2 65.52,222.47 69.07,222.47 71.61,219.93 74.15,219.93 A23.V2
T_FWD\
  Bottom 0.254: B23.H2 78.22,184.87 78.22,188.94 79.74,190.46 79.74,235.17 85.33,240.75 85.33,246.85 84.31,247.87 A23.K1
T_GO\
  Bottom 0.254: A24.C2 65.52,266.66 69.58,266.66 70.6,265.65 79.74,265.65 80.76,264.63 A23.D1
T_PWR_CLR\
  Bottom 0.254: B23.K2 78.22,178.27 78.22,181.32 85.33,188.43 85.33,230.09 83.8,231.61 81.27,231.61 A23.R1
T_REV\
  Bottom 0.254: B23.J2 74.15,181.32 74.15,185.38 60.44,199.1 60.44,226.53 65.01,231.1 69.58,231.1 80.76,242.28 80.76,244.31 A23.L1
T_STOP\
  Bottom 0.254: B23.E2 78.22,190.97 78.22,195.03 79.23,196.05 79.23,239.74 82.28,242.79 82.28,245.83 81.27,246.85 76.69,246.85 76.69,250.91 83.8,258.03 83.8,260.57 A23.E1
T_WRITE_OK\
  Bottom 0.254: A24.L2 61.45,244.31 61.45,240.25 57.9,236.69 57.9,227.55 54.34,223.99 54.34,170.65 61.45,163.54 63.48,163.54 73.14,153.89 76.19,153.89 79.23,156.93 79.23,168.11 75.17,172.17 75.17,174.21 B23.L2
TIM
  Bottom 0.254: A25.U1 55.87,222.97 59.42,226.53 59.42,233.64 73.14,247.36 73.14,252.44 100.57,279.87 171.69,279.87 173.72,281.9 287,281.9 294.12,274.79 295.13,274.79 301.23,268.69 301.23,259.55 287,245.33 284.47,245.33 A08.L1
TM_EN\
  Bottom 0.254: 225.54,110.2 226.05,110.71 226.05,114.26 C12.K2 | 225.54,110.2 217.92,102.58 C13.P1 | 225.54,110.2 225.54,122.39 232.65,129.5 232.65,133.57 C12.C1 | B15.D2 182.87,193.51 188.45,193.51 B15.D1 | D15.J2 182.87,47.71 185.41,45.17 D15.K2
TP00
  Bottom 0.254: A16.P2 172.71,235.67 170.17,238.21 A16.N2 169.66,239.23 168.64,240.25 168.64,246.34 170.67,246.34 172.71,244.31 | 172.71,244.31 172.71,242.28 A16.M2 | 172.71,244.31 180.83,252.44 183.88,252.44 188.45,247.87 188.45,245.33 A15.L1 189.47,245.33 192.01,245.33 193.53,246.85 193.53,252.95 197.09,256.5 204.71,256.5 206.74,254.47 206.74,204.69 | 206.23,193.51 207.76,193.51 B13.D2 | 206.23,193.51 205.22,193.51 193.03,181.32 189.47,181.32 B15.J1 | B10.N1 255,168.62 255,172.17 253.48,173.7 253.48,183.35 252.97,183.86 B10.H2 252.97,184.87 255,184.87 257.03,186.91 257.03,187.92 256.02,188.94 248.91,188.94 | 220.46,195.03 220.46,202.65 218.43,204.69 216.39,204.69 | 220.46,195.03 220.46,171.16 194.04,144.74 194.04,133.06 192.52,131.53 192.52,127.98 C15.E1 | 216.39,204.69 214.87,203.16 214.87,200.62 B13.B1 214.87,199.61 214.87,196.56 218.93,192.49 218.93,189.95 217.92,188.94 217.92,184.87 B13.H1 | 248.91,188.94 248.91,190.46 244.33,195.03 241.29,195.03 | 248.91,188.94 248.91,187.92 B10.F2 | 241.29,195.03 220.46,195.03 | 241.29,195.03 241.29,226.53 248.4,233.64 265.67,233.64 272.78,240.75 272.78,243.29 278.88,249.39 278.88,262.09 283.96,267.17 283.96,269.71 A08.B1 | 206.23,193.51 206.23,197.57 203.69,200.11 203.69,204.69 206.74,204.69 | 216.39,204.69 206.74,204.69
TP00\
  Bottom 0.254: A15.E1 192.01,260.57 189.47,258.03 A15.F1 188.45,257.01 185.91,257.01 184.39,255.49 184.39,253.45 | A15.J1 189.47,251.93 191.5,253.96 A15.H1 | A15.K1 191.5,248.37 188.96,250.91 A15.J1 | 184.39,253.45 185.91,251.93 188.45,251.93 A15.J1 | 182.87,152.36 190.49,159.98 193.03,159.98 194.04,158.97 194.04,148.3 196.58,148.3 213.85,165.57 213.85,168.11 B13.N1 | 182.87,152.36 168.13,137.63 168.13,123.41 150.35,105.63 147.81,105.63 CD18.AN1 | 184.39,253.45 180.83,253.45 174.23,246.85 168.13,246.85 168.13,167.09 182.87,152.36
TP00_A\
  Bottom 0.254: A15.R1 189.47,232.63 192.01,235.17 A15.P1 191.5,235.67 188.96,238.21 A15.N1 | A16.L2 170.17,244.31 170.17,242.28 175.25,237.2 187.44,237.2 188.45,238.21 A15.N1 | A15.M1 191.5,241.26 189.47,239.23 A15.N1
TP0_XTLK_DY\
  Bottom 0.254: 171.69,249.39 170.17,250.91 A16.J2 | 171.69,249.39 172.71,248.37 A16.K2 | 171.69,249.39 179.31,257.01 182.36,257.01 A15.F2 182.87,258.03 185.41,258.03 193.53,266.15 193.53,267.68 190.99,270.22 190.99,274.79 193.53,274.79 218.93,249.39 218.93,247.36 233.67,232.63 236.21,232.63 A11.R2
TP01\
  Bottom 0.254: 185.41,241.77 182.87,239.23 A15.N2 | 185.41,241.77 A15.M2 185.41,241.77 | 183.88,243.29 185.41,241.77 | 183.88,243.29 182.87,244.31 A15.L2 182.87,245.33 185.41,247.87 A15.K2 185.41,248.37 182.87,250.91 A15.J2 | 183.88,243.29 192.52,243.29 193.53,242.28 193.53,227.04 181.34,214.85 181.34,186.4 187.95,179.79 199.63,179.79 204.2,175.22 207.76,175.22 B13.L2
TP01_A\
  Bottom 0.254: B16.L2 170.17,175.22 170.17,178.78 180.83,189.45 180.83,223.99 182.36,225.51 A15.T2 | A15.U2 185.41,222.97 182.87,225.51 A15.T2 | A15.T2 182.87,226.02 185.41,228.56 A15.S2 185.41,229.07 182.87,231.61 A15.R2
TP1_XTLK_DY\
  Bottom 0.254: A11.V2 236.71,219.93 236.71,223.48 241.29,228.05 241.29,247.36 244.33,250.41 244.33,251.93 243.83,252.44 233.16,252.44 231.63,253.96 231.63,258.53 220.97,269.2 200.14,269.2 194.04,275.3 190.49,275.3 189.47,274.28 189.47,270.73 A15.B1 | B16.J2 170.17,181.32 172.71,183.86 B16.H2
TS03\
  Top 0.254: D17.K2 156.96,45.17 154.42,47.71 D17.J2 154.42,48.22 156.96,50.76 D17.H2
USR_00\
  Bottom 0.254: B07.F1 297.17,186.91 301.74,186.91 302.75,185.89 317.99,185.89 328.15,196.05 333.74,196.05 337.3,192.49 351.52,192.49 352.03,193 352.03,201.64 353.55,203.16 B03.A1
USR_02\
  Bottom 0.254: B07.M1 300.21,172.17 304.79,172.17 309.36,176.75 313.93,176.75 330.69,193.51 330.69,195.54 333.23,195.54 339.33,189.45 345.93,189.45 346.95,188.43 350.5,188.43 B03.F1
UTS\
  Bottom 0.254: C16.K1 178.8,115.28 176.77,117.31 C16.J1 176.77,118.33 179.31,120.87 C16.H1 179.31,121.37 176.77,123.91 C16.F1 | 197.09,100.55 191.5,100.55 190.49,101.56 185.91,101.56 C15.P2 | 197.09,100.55 198.11,101.56 C14.P2 | 197.09,100.55 206.74,100.55 217.41,111.21 223,111.21 C12.L2 | C16.D1 176.77,131.03 179.31,133.57 C16.C1 178.8,134.07 176.26,136.61 C16.B1 176.77,137.63 178.8,139.66 C16.A1
VCC
  Top 0.635: B22.A2 90.92,203.16 93.46,203.16 96,205.7 100.57,205.7 102.6,203.67 B21.A2 103.62,203.16 104.12,203.16 106.67,205.7 110.22,205.7 111.75,204.18 118.86,204.18 B20.A2 119.36,204.18 123.43,204.18 124.95,205.7 142.73,205.7 144.26,204.18 B18.A2 144.77,204.18 146.29,205.7 164.07,205.7 | 164.07,205.7 166.1,203.67 172.71,203.67 B16.A2 | 165.59,275.81 170.67,275.81 172.71,273.77 A16.A2 173.21,273.77 175.25,275.81 179.82,275.81 181.85,273.77 185.41,273.77 A15.A2 185.91,273.77 187.95,275.81 192.52,275.81 194.55,273.77 198.11,273.77 A14.A2 198.61,273.77 202.17,273.77 204.2,275.81 208.27,275.81 209.28,276.82 218.93,276.82 222.49,273.27 226.55,273.27 A12.A2 227.57,273.77 230.62,273.77 232.65,275.81 237.22,275.81 239.25,273.77 A11.A2 240.27,273.77 242.3,275.81 246.87,275.81 248.91,273.77 251.95,273.77 A10.A2 252.97,273.77 255,275.81 259.57,275.81 261.61,273.77 264.65,273.77 A09.A2 265.67,273.77 267.7,275.81 272.27,275.81 274.31,273.77 280.4,273.77 A08.A2 281.42,273.77 284.47,273.77 286.5,275.81 291.07,275.81 293.1,273.77 A07.A2 | 165.59,275.81 150.35,275.81 148.32,273.77 144.77,273.77 A18.A2 | 164.07,205.7 164.07,220.43 165.59,221.96 165.59,229.58 | 165.59,275.81 165.59,229.58 | C05.A2 318.5,140.68 314.94,140.68 313.42,142.2 308.34,142.2 306.82,140.68 C06.A2 305.8,140.68 302.25,140.68 300.72,142.2 295.64,142.2 294.12,140.68 C07.A2 293.1,140.68 291.58,142.2 286.5,142.2 284.97,140.68 281.42,140.68 C08.A2 280.4,140.68 273.8,140.68 272.27,142.2 267.19,142.2 265.67,140.68 C09.A2 264.65,140.68 261.1,140.68 259.57,142.2 254.49,142.2 252.97,140.68 C10.A2
  Top 0.635: C14.A2 198.11,140.68 196.58,142.2 191.5,142.2 189.98,140.68 185.91,140.68 C15.A2 185.41,140.68 181.34,140.68 179.82,142.2 174.74,142.2 173.21,140.68 C16.A2 172.71,140.68 165.59,140.68 164.07,142.2 158.99,142.2 157.47,140.68 C17.A2 156.96,140.68 155.43,142.2 150.35,142.2 148.83,140.68 144.77,140.68 CD18.AA2 | C13.A2 210.81,140.68 206.74,140.68 205.22,142.2 200.14,142.2 198.61,140.68 C14.A2 | C12.A2 227.06,140.68 230.62,140.68 232.14,142.2 237.73,142.2 239.25,140.68 C11.A2 | C10.A2 251.95,140.68 248.4,140.68 246.87,142.2 241.79,142.2 240.27,140.68 C11.A2 | C14.A2 198.11,139.66 198.11,136.61 196.58,135.09 196.58,132.55 200.14,128.99 231.12,128.99 237.73,135.6 238.24,135.6 239.25,136.61 239.25,139.66 C11.A2 | B15.A2 185.91,203.16 186.93,203.16 189.47,205.7 196.07,205.7 198.11,203.67 B14.A2 198.61,203.67 200.65,205.7 203.19,205.7 | 203.19,205.7 205.22,205.7 207.25,203.67 210.81,203.67 B13.A2 211.31,203.67 214.87,203.67 216.9,205.7 224.52,205.7 226.55,203.67 B12.A2 227.57,203.67 230.62,203.67 232.65,205.7 237.22,205.7 239.25,203.67 B11.A2 240.27,203.67 242.3,205.7 246.87,205.7 248.91,203.67 251.95,203.67 B10.A2 252.97,203.67 255,205.7 259.57,205.7 261.61,203.67 264.65,203.67 B09.A2 265.67,203.67 267.7,205.7 272.27,205.7 274.31,203.67 280.4,203.67 B08.A2 281.42,203.67 284.47,203.67 286.5,205.7 291.07,205.7 293.1,203.67 B07.A2 294.12,203.67 296.15,205.7 300.72,205.7 302.75,203.67 305.8,203.67 B06.A2 306.82,203.67 308.85,205.7 313.42,205.7 315.45,203.67 318.5,203.67 B05.A2 319.52,203.67 322.56,203.67 324.6,205.7 333.23,205.7 334.76,204.18 B04.A2 335.26,204.18 339.33,204.18 340.85,205.7 345.93,205.7 347.46,204.18 B03.A2 347.97,204.18 349.49,205.7 354.57,205.7 356.09,204.18 360.16,204.18 B02.A2 360.67,204.18 364.73,204.18 366.25,205.7 371.33,205.7 372.86,204.18 AB01.BA2 373.37,203.16 375.91,200.62 AB01.BB1 376.41,200.11 378.95,197.57 AB01.BC1 378.95,197.07 376.41,194.53 AB01.BD1 376.41,193.51 378.95,190.97 AB01.BE1 379.97,190.46 386.57,183.86
  Top 0.635: 376.41,266.66 376.41,269.71 AB01.AB1 375.91,270.73 373.37,273.27 AB01.AA2 | 376.41,266.66 376.41,264.63 AB01.AD1 376.41,263.61 378.95,261.07 AB01.AE1 378.95,260.57 376.41,258.03 AB01.AF1 376.41,257.01 378.95,254.47 AB01.AH1 378.95,253.96 376.41,251.42 AB01.AJ1 376.41,250.91 378.95,248.37 AB01.AK1 378.95,247.87 377.94,246.85 | 376.41,266.66 378.95,266.66 AB01.AC1 | 377.94,246.85 376.41,245.33 AB01.AL1 | 333.23,135.09 334.76,136.61 334.76,139.66 C04.A2 | 333.23,135.09 333.23,132.55 333.74,132.04 336.28,132.04 337.3,133.06 339.33,133.06 340.35,132.04 342.38,132.04 343.39,133.06 345.43,133.06 346.44,132.04 348.98,132.04 350,133.06 350,135.09 347.97,137.12 347.97,139.66 C03.A2 347.97,140.68 349.49,142.2 354.57,142.2 356.09,140.68 360.16,140.68 C02.A2 360.16,139.66 360.16,136.61 358.63,135.09 358.63,132.55 359.14,132.04 361.68,132.04 362.7,133.06 364.73,133.06 365.75,132.04 367.78,132.04 368.79,133.06 370.82,133.06 371.84,132.04 374.38,132.04 375.4,133.06 375.4,135.09 373.37,137.12 373.37,139.66 C01.A2 373.37,140.68 386.57,153.89 386.57,183.86 | 377.94,246.85 386.57,238.21 386.57,183.86 | 333.23,135.09 330.19,132.04 317.99,132.04 316.98,133.06 314.94,133.06 313.93,132.04 311.39,132.04 310.37,133.06 308.34,133.06 307.32,132.04 305.29,132.04 304.28,133.06 302.25,133.06 301.23,132.04 298.69,132.04 297.67,133.06 295.64,133.06 294.62,132.04 292.59,132.04 291.58,133.06 289.55,133.06 288.53,132.04 285.99,132.04 284.97,133.06 282.94,133.06 281.93,132.04 279.89,132.04 278.88,133.06 276.34,133.06 275.32,132.04 270.24,132.04 269.23,133.06 267.19,133.06 266.18,132.04 264.15,132.04 263.13,133.06 261.1,133.06 260.08,132.04 257.54,132.04 256.53,133.06 254.49,133.06 253.48,132.04 251.45,132.04 250.94,132.55 250.94,135.09 251.95,136.11 251.95,139.66 C10.A2
  Top 0.635: 165.59,229.58 170.17,229.58 171.69,231.1 174.74,231.1 175.25,230.59 199.63,230.59 203.69,226.53 203.69,224.5 203.19,223.99 203.19,205.7 | D07.A2 293.1,70.57 291.07,72.61 286.5,72.61 284.47,70.57 281.42,70.57 D08.A2 280.4,70.57 274.31,70.57 272.27,72.61 262.62,72.61 | 237.22,72.61 229.6,72.61 227.57,70.57 D12.A2 226.55,70.57 224.52,72.61 216.9,72.61 214.87,70.57 211.31,70.57 D13.A2 210.81,70.57 208.77,72.61 204.2,72.61 202.17,70.57 199.12,70.57 D14.A2 198.11,70.57 194.55,70.57 192.52,72.61 187.95,72.61 | 237.22,72.61 239.25,70.57 D11.A2 | 249.92,72.61 251.95,70.57 D10.A2 | 237.22,72.61 249.92,72.61 | 262.62,72.61 264.65,70.57 D09.A2 | 249.92,72.61 262.62,72.61 | A20.A2 118.86,273.77 112.25,273.77 110.22,275.81 106.67,275.81 104.12,273.27 103.62,273.27 A21.A2 102.6,273.77 99.55,273.77 97.52,275.81 93.97,275.81 91.42,273.27 90.92,273.27 A22.A2 89.9,273.77 87.87,275.81 83.3,275.81 81.27,273.77 78.22,273.77 A23.A2 77.2,273.77 74.15,273.77 72.12,275.81 67.55,275.81 66.53,276.82 10.14,276.82 1.51,268.19 1.51,221.45 7.1,215.86 53.83,215.86 59.42,210.27 59.42,180.81 98.03,142.2 142.73,142.2 144.26,140.68 CD18.AA2 | 150.35,72.61 148.32,70.57 144.77,70.57 CD18.BA2 | 150.35,72.61 154.93,72.61 156.96,70.57 D17.A2 157.47,70.57 161.02,70.57 163.05,72.61 170.67,72.61 172.71,70.57 D16.A2 173.21,70.57 176.77,70.57 178.8,72.61 187.95,72.61 | 187.95,72.61 185.91,70.57 D15.A2 | 150.35,72.61 150.35,86.83 142.73,94.45 142.73,135.09 144.26,136.61 144.26,139.66 CD18.AA2
W01
  Bottom 0.254: A26.J2 33.01,250.91 33.01,246.85 31.48,245.33 31.48,210.78 41.13,201.13 41.13,156.93 58.41,139.66 58.41,125.44 115.3,68.54 116.83,68.54 136.64,48.73 140.7,48.73 CD18.BJ2
W02
  Bottom 0.254: A26.K2 36.05,248.37 36.05,250.91 34.53,252.44 31.99,252.44 28.94,249.39 28.94,163.54 57.39,135.09 57.39,99.53 114.79,42.13 114.79,40.09 138.16,16.73 140.7,16.73 CD18.BV2
W05
  Bottom 0.254: A26.N2 33.51,238.21 33.51,234.66 47.23,220.94 47.23,156.93 63.99,140.17 63.99,137.63 114.79,86.83 114.79,84.29 142.73,56.35 142.73,21.3 144.26,19.77 CD18.BU2
W09
  Bottom 0.254: A26.T2 33.51,225.51 36.56,225.51 44.18,217.89 44.18,201.13 41.64,198.59 41.64,157.44 60.44,138.65 60.44,134.58 123.94,71.08 123.94,68.54 137.65,54.83 140.7,54.83 CD18.BF2
W+UTS
  Bottom 0.254: A15.H2 185.91,254.98 188.96,254.98 194.04,260.06 194.04,271.74 192.52,273.27 A15.A1
W-INH\
  Bottom 0.254: B12.H1 233.67,183.86 233.67,181.32 239.76,175.22 242.3,175.22 B11.L1
WB00
  Bottom 0.254: A21.N2 100.57,238.21 102.09,236.69 102.09,207.23 107.68,201.64 107.68,107.66 115.3,100.04 124.95,100.04 151.37,73.62 268.21,73.62 271.26,70.57 D09.A1
WC
  Bottom 0.254: B10.M1 258.56,171.16 258.56,169.13 256.53,167.09 254.49,167.09 246.37,175.22 246.37,177.76 B11.K1
WC\
  Bottom 0.254: D11.U1 245.86,19.77 245.86,23.84 244.33,25.36 244.33,36.03 242.3,38.06 240.27,38.06 D11.M2
WR_EN
  Bottom 0.254: C14.U1 204.2,89.88 200.65,89.88 193.03,97.5 186.93,97.5 183.88,100.55 183.88,103.59 188.45,108.17 191.5,108.17 C15.M1 192.52,108.17 192.52,105.63 194.55,103.59 208.77,103.59 209.79,104.61 209.79,110.71 221.47,122.39 221.47,128.49 223,130.01 C12.D2 224.01,131.03 226.55,131.03 229.6,134.07 | 229.6,134.07 231.12,135.6 240.27,135.6 251.95,123.91 251.95,121.37 C10.H2 251.95,120.87 253.48,119.34 253.48,113.75 253.99,113.25 253.99,94.96 252.97,93.94 252.97,89.88 C10.U2 | 176.26,127.98 164.58,116.29 164.58,112.23 146.8,94.45 143.24,94.45 117.33,120.36 117.33,161 116.32,162.01 B20.R2 115.81,163.03 110.73,168.11 110.73,174.21 | 176.26,127.98 187.95,139.66 191.5,139.66 C15.A1 | 110.73,174.21 110.73,199.61 107.68,202.65 107.68,233.64 101.58,239.74 99.05,239.74 98.54,239.23 98.54,237.71 99.55,236.69 99.55,232.63 A21.R2 | 110.73,174.21 117.33,180.81 117.33,191.48 120.38,194.53 120.38,223.99 116.32,228.05 116.32,231.61 A20.R2 | 229.6,134.07 215.89,147.79 215.89,149.82 214.87,150.84 213.85,150.84 206.23,143.22 206.23,137.63 194.04,125.44 187.95,125.44 186.93,124.42 186.93,119.85 184.39,119.85 176.26,127.98 | D09.B1 267.7,66.51 267.7,62.95 265.67,60.92 265.67,57.87 D09.E2 264.65,57.37 264.65,54.83 260.08,50.25 260.08,43.65 261.61,42.13 D09.L2 262.11,41.11 262.11,39.59 | 265.67,28.92 265.67,30.44 267.7,32.47 267.7,35.01 D09.N1 | 265.67,28.92 265.67,26.38 D09.S2 | 262.11,39.59 262.11,37.55 263.64,36.03 263.64,30.95 265.67,28.92 | 262.11,39.59 266.18,43.65 266.18,48.22 268.72,50.76 271.26,50.76 D09.H1
WR_EN\
  Bottom 0.254: 211.82,99.02 223,110.2 224.52,110.2 225.03,110.71 225.03,116.29 224.01,117.31 C12.J2 | 211.82,99.02 208.77,95.97 205.22,95.97 C14.S1 | 211.82,99.02 216.39,94.45 221.47,94.45 234.17,107.15 234.17,113.25 237.73,116.8 237.73,119.34 239.25,120.87 C11.H2 | C15.H2 185.41,121.37 185.41,125.44 182.87,127.98 182.87,130.01 C15.D2
WRITE_ALL
  Bottom 0.254: B12.F1 229.6,186.91 229.6,182.84 229.09,182.33 229.09,173.7 230.11,172.68 245.35,172.68 245.86,172.17 B11.M1
WRITE_DATA
  Bottom 0.254: B12.P1 233.67,165.06 237.73,165.06 240.27,162.52 242.3,162.52 B11.R1
WRITE_OK+UTS
  Bottom 0.254: B12.K1 233.16,178.27 233.16,182.33 231.63,183.86 231.63,192.49 230.62,193.51 B12.D1
WRITE_OK\
  Bottom 0.254: C17.J2 153.4,118.33 152.39,119.34 152.39,139.15 161.53,148.3 161.53,180.3 164.58,183.35 164.58,218.91 158.48,225.01 158.48,253.45 168.64,263.61 168.64,265.14 179.31,275.81 200.14,275.81 204.2,271.74 232.65,271.74 245.35,259.04 250.43,259.04 255,254.47 255,251.93 A10.J1
XSTA
  Bottom 0.254: 293.1,194.02 291.07,194.02 B07.D2 | 293.1,194.02 297.17,198.08 297.17,199.61 B07.B1 | 294.12,163.54 294.12,159.47 B07.S2 | 294.12,163.54 296.66,166.08 296.66,168.11 B07.N1 | 297.17,184.37 297.67,184.87 299.71,184.87 B07.H1 | 297.17,184.37 295.64,182.84 295.64,177.76 293.1,175.22 291.07,175.22 B07.L2 290.05,174.21 289.04,173.19 289.04,167.6 293.1,163.54 294.12,163.54 | 293.1,194.02 295.64,191.48 295.64,189.45 295.13,188.94 295.13,185.89 296.66,184.37 297.17,184.37 | D13.M2 210.81,38.06 208.27,35.52 D13.N2 208.27,35.01 210.81,32.47 D13.P2 211.31,31.97 212.33,30.95 226.05,30.95 233.16,23.84 234.17,23.84 242.3,31.97 242.3,35.01 D11.N1
XSTA\
  Bottom 0.254: D13.J2 208.27,47.71 210.81,45.17 D13.K2 | D13.H2 210.81,50.76 208.27,48.22 D13.J2 | D16.N2 170.17,36.03 172.71,38.57 D16.M2 173.21,39.08 177.28,39.08 181.34,43.14 197.09,43.14 | 197.09,43.14 198.61,44.67 D14.K2 199.12,45.17 202.68,45.17 205.22,47.71 207.76,47.71 D13.J2 | 197.09,43.14 196.07,42.13 D14.L2

## Text on the board
Top: 1 | A
Bottom: A
tPlace: 28 | 27 | 26 | 25 | 24 | 23 | 22 | 21 | 20 | 19 | 18 | 17 | 16 | 15 | 14 | 13 | 12 | 11 | 10 | 9 | 8 | 7 | 6 | 5 | 4 | 3 | 2 | 1 | Rip Up NC | Add Holes? | Fix G821 connections | Fold in ECOs. | A | B | C | D
bPlace: A | B | C | D | 28 | 27 | 26 | 25 | 24 | 23 | 22 | 21 | 20 | 19 | 18 | 17 | 16 | 15 | 14 | 13 | 12 | 11 | 10 | 9 | 8 | 7 | 6 | 5 | 4 | 3 | 2 | 1