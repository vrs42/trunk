# EAGLE board tc08nh (EAGLE 4.11), part 2 of 5
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
DB_10\  (via drill 0.61) (continued)
  Top 0.254: 307.83,212.31 307.83,259.55 306.82,260.57 A06.E2 | 307.83,212.31 307.83,58.89 306.82,57.87 D06.E2 | v307.32,212.31 307.83,212.31
  Route15 0.254: v307.32,212.31 314.94,204.69 320.03,204.69 330.69,194.02 330.69,186.91 341.36,176.24 345.43,176.24 349.49,172.17 349.49,167.6 362.19,154.9 360.67,153.38 B02.U2
DB_11\  (via drill 0.61)
  Top 0.254: v372.86,82.26 374.38,83.78 374.38,117.31 v373.87,117.82 | v374.38,194.53 374.89,194.02 374.89,136.11 v376.92,134.07
  Route2 0.254: v333.23,81.75 306.31,54.83 306.31,51.78 D06.H2
  Route15 0.254: v376.92,134.07 366.25,144.74 362.19,144.74 357.62,149.31 B02.V2 | v321.55,252.95 323.07,252.95 326.63,249.39 326.63,247.36 352.54,221.45 352.54,220.43 374.38,198.59 v374.38,194.53
  Bottom 0.254: v333.23,81.75 333.74,82.26 v372.86,82.26 | v373.87,117.82 371.84,119.85 371.84,125.95 373.87,125.95 374.89,126.96 374.89,134.07 v376.92,134.07 | v321.55,252.95 307.83,252.95 306.82,253.96 A06.H2
DF  (via drill 0.61)
  Top 0.254: v49.26,214.85 44.69,214.85 44.69,230.59 | 44.69,230.59 44.69,259.04 43.16,260.57 A26.E1 | 44.69,230.59 v45.2,230.59
  Route15 0.254: v49.26,214.85 113.27,150.84 117.33,150.84 168.64,99.53 168.64,98.01 169.15,97.5 169.15,95.97 221.98,43.14 224.52,43.14 236.21,31.46 236.21,29.43 D11.R2
  Bottom 0.254: v45.2,230.59 46.72,230.59 49.77,233.64 170.67,233.64 176.77,227.55 217.92,227.55 220.97,230.59 238.24,230.59 244.33,236.69 250.94,236.69 251.95,235.67 A10.P2
DF\  (via drill 0.61)
  Route2 0.254: v147.81,127.98 162.04,142.2 163.05,142.2 168.64,147.79 171.69,147.79 175.25,151.35 176.26,151.35 184.9,159.98 188.96,159.98 202.68,173.7 202.68,174.21 203.19,174.71 205.73,174.71 207.25,176.24 217.92,176.24 222.49,180.81 222.49,181.83 226.05,185.38 227.57,185.38 229.09,183.86 | 229.09,183.86 230.62,182.33 229.6,181.32 B12.J1 | v299.2,233.64 280.91,233.64 271.26,223.99 270.75,223.99 257.03,210.27 257.03,209.77 256.53,209.26 254.49,209.26 229.09,183.86
  Route15 0.254: v147.81,127.98 168.64,107.15 168.64,104.1 223.51,49.24 225.03,49.24 239.25,35.01 239.25,32.47 D11.P2 | v299.2,233.64 299.2,233.13 316.98,215.35 317.49,215.35 325.11,207.73 325.11,203.67 B05.A1
DTB_00  (via drill 0.61)
  Top 0.254: v265.67,130.01 263.13,127.47 263.13,62.45 262.11,61.43 D09.D2 | v252.46,146.77 255.51,143.73 255.51,137.63 C10.B1
  Route15 0.254: v161.02,157.95 101.08,217.89 101.08,220.94 56.37,265.65 54.85,265.65 49.77,270.73 49.77,273.27 A25.A2 | v265.67,130.01 263.13,132.55 262.11,132.55 259.57,135.09 257.54,135.09 256.02,136.61 C10.B1
  Bottom 0.254: v265.67,130.01 267.7,127.98 271.26,127.98 C09.E1 | v161.02,157.95 168.13,150.84 176.77,150.84 181.85,145.76 242.81,145.76 243.83,146.77 v252.46,146.77
DTB_00\  (via drill 0.61)
  Route2 0.254: v246.87,147.79 247.89,148.81 247.89,150.33 254.49,156.93 258.56,156.93 263.13,161.51 263.13,165.06 270.75,172.68 273.8,172.68 287,185.89 v287.51,185.89
  Route15 0.254: v246.87,147.79 248.4,146.27 248.4,144.23 250.94,141.69 250.94,139.66 258.56,132.04 262.62,132.04 263.13,131.53 263.13,131.03 268.21,125.95 268.21,124.93 C09.F1
  Bottom 0.254: v287.51,185.89 287.51,189.45 288.53,189.45 288.53,192.49 314.94,192.49 317.99,189.45 337.81,189.45 340.85,192.49 358.12,192.49 366.25,200.62 366.25,203.16 B02.A1
DTB_01  (via drill 0.61)
  Top 0.254: D09.K2 264.65,45.17 263.64,46.19 263.64,119.85 264.65,120.87 C09.H2 | v218.93,158.46 219.44,158.97 219.44,203.67 217.92,205.19 217.92,219.42 209.79,227.55 209.79,258.53 190.99,277.33 190.99,285.46 65.01,285.46 51.29,271.74 51.29,270.73 46.21,270.73 A25.B2
  Route15 0.254: v218.93,158.46 218.93,157.95 243.32,133.57 244.33,133.57 255,122.9 257.03,122.9 258.56,121.37 C10.H1
  Bottom 0.254: C09.H2 264.65,121.37 259.06,121.37 C10.H1
DTB_01\  (via drill 0.61)
  Top 0.254: v367.27,154.9 367.78,155.41 367.78,194.53 v366.76,195.54
  Route15 0.254: v297.67,75.65 272.78,100.55 272.78,103.09 262.11,113.75 262.11,117.31 C09.J2 | v385.56,121.37 384.54,122.39 384.54,136.61 380.99,140.17 380.99,141.19 v367.27,154.9 | v366.76,195.54 366.25,195.54 365.24,196.56 365.24,198.59 363.71,200.11 B02.B1
  Bottom 0.254: v297.67,75.65 298.18,75.15 376.92,75.15 386.57,84.8 386.57,121.37 v385.56,121.37
DTB_02  (via drill 0.61)
  Top 0.254: D09.R2 261.61,29.43 260.08,30.95 260.08,98.51 256.02,102.58 256.02,104.61 C10.N1 255,105.63 253.99,106.64 v253.99,127.98
  Route15 0.254: v171.18,143.22 170.67,143.22 110.73,203.16 110.73,204.69 56.88,258.53 56.88,261.58 51.29,267.17 49.77,267.17 A25.C2 | v253.99,127.98 v239.76,142.2
  Bottom 0.254: v171.18,143.22 172.2,142.2 v239.76,142.2 | C09.L1 267.7,111.21 267.7,106.64 257.03,106.64 256.02,105.63 C10.N1
DTB_02\  (via drill 0.61)
  Route15 0.254: v306.82,78.19 290.56,94.45 286.5,94.45 278.37,102.58 276.85,102.58 271.76,107.66 271.76,108.17 C09.M1 | v385.05,84.8 385.05,90.39 386.57,91.91 386.57,163.54 383.02,167.09 383.02,169.63 382,170.65 382,171.67 367.78,185.89 365.24,185.89 363.71,187.41 B02.F1
  Bottom 0.254: v306.82,78.19 307.32,77.69 377.94,77.69 v385.05,84.8
DTB_03  (via drill 0.61)
  Top 0.254: v214.36,252.95 220.46,252.95 220.46,182.33 v221.47,181.32
  Route2 0.254: v277.35,115.79 276.85,115.79 265.16,104.1 265.16,102.58 C09.P2
  Route15 0.254: v221.47,181.32 267.19,135.6 269.73,135.6 271.26,134.07 C09.C1 271.76,133.57 276.34,128.99 276.34,117.31 277.35,116.29 v277.35,115.79
  Bottom 0.254: v214.36,252.95 213.85,252.44 178.8,252.44 166.1,265.14 120.89,265.14 118.35,262.6 47.23,262.6 46.21,263.61 A25.D2
DTB_03\  (via drill 0.61)
  Top 0.254: v372.35,129.5 371.84,130.01 371.84,168.11 374.38,170.65 374.38,173.19 v373.87,173.7
  Route2 0.254: v366.76,119.34 367.27,119.34 367.78,119.85 367.78,126.45 368.29,126.96 369.81,126.96 v372.35,129.5
  Route15 0.254: v284.47,82.77 272.78,94.45 270.75,94.45 266.69,98.51 262.11,98.51 C09.R2 | v383.02,99.53 384.54,101.05 377.94,107.66 377.43,107.66 371.84,113.25 371.84,114.26 v366.76,119.34 | v373.87,173.7 373.87,175.22 368.79,180.3 368.79,182.84 367.27,184.37 B02.H1
  Bottom 0.254: v284.47,82.77 327.14,82.77 329.17,80.73 373.87,80.73 374.38,81.24 375.4,81.24 375.91,80.73 375.91,79.72 377.43,79.72 377.94,80.23 377.94,99.53 v383.02,99.53
DTB_04  (via drill 0.61)
  Top 0.254: v269.73,118.83 269.73,97.5 271.26,95.97 C09.S1
  Route15 0.254: v121.91,262.09 162.55,221.45 165.09,221.45 215.89,170.65 216.9,170.65 224.01,163.54 224.52,163.54 240.27,147.79 240.27,147.28 244.84,142.71 245.86,142.71 v261.1,127.47 v269.73,118.83
  Bottom 0.254: v121.91,262.09 50.78,262.09 49.77,261.07 A25.E2 | v261.1,127.47 264.65,127.47 C09.E2
DTB_04\  (via drill 0.61)
  Route2 0.254: v326.63,73.62 329.68,73.62 365.75,109.69 369.81,109.69 377.43,117.31 377.43,122.39 377.94,122.9 377.94,124.42 380.48,126.96 380.48,131.53 380.99,132.04 380.99,136.11 384.03,139.15 384.03,152.36 v383.02,153.38
  Route15 0.254: v291.07,74.64 276.85,88.86 271.76,88.86 C09.U1 | v383.02,153.38 368.79,167.6 368.79,170.14 367.27,171.67 B02.M1
  Bottom 0.254: v291.07,74.64 292.09,73.62 v326.63,73.62
DTB_05  (via drill 0.61)
  Top 0.254: v267.19,153.38 269.73,150.84 269.73,120.36 268.72,119.34 268.72,118.33 C09.J1
  Route2 0.254: v286.5,113.25 285.99,112.74 282.94,112.74 278.37,108.17 277.35,108.17 272.78,103.59 272.78,99.53 262.11,88.86 262.11,86.83 C09.V2
  Route15 0.254: v173.72,249.9 173.72,249.39 218.93,204.18 218.93,201.64 v267.19,153.38
  Bottom 0.254: v173.72,249.9 99.05,249.9 89.9,259.04 47.23,259.04 46.21,258.03 A25.F2 | v286.5,113.25 280.4,119.34 274.31,119.34 272.27,117.31 268.72,117.31 C09.J1
DTB_05\  (via drill 0.61)
  Top 0.254: v322.06,115.28 323.58,116.8 323.58,118.83 323.07,119.34 323.07,122.9 324.09,123.91 v324.09,137.63
  Route2 0.254: v288.02,87.85 289.04,87.85 311.39,110.2 316.98,110.2 v322.06,115.28 | v324.09,137.63 324.09,140.68 325.11,141.69 327.65,141.69 342.88,156.93 342.88,157.44 346.44,161 346.44,162.52 348.98,165.06 348.98,169.13 v350.5,170.65
  Bottom 0.254: v288.02,87.85 284.97,84.8 269.73,84.8 268.72,85.81 C09.V1 | v350.5,170.65 351.01,170.14 362.19,170.14 363.21,169.13 B02.N1
DTB_06  (via drill 0.61)
  Top 0.254: v261.1,108.67 260.59,109.18 260.59,125.44 v261.1,125.95 | v278.37,147.79 278.88,148.3 v278.88,185.38
  Route2 0.254: v261.1,108.67 264.65,108.67 C09.M2 | v261.1,125.95 262.11,126.96 262.11,128.49 272.78,139.15 272.78,142.2 v278.37,147.79
  Route15 0.254: v93.97,208.75 55.87,246.85 54.85,246.85 49.26,252.44 49.26,253.96 A25.H2 | v257.03,207.23 269.73,194.53 269.73,192.49 271.26,190.97 B09.E1
  Bottom 0.254: v93.97,208.75 94.47,208.24 183.37,208.24 184.39,209.26 212.33,209.26 213.35,208.24 237.22,208.24 238.24,209.26 244.84,209.26 246.87,207.23 v257.03,207.23 | v278.88,185.38 278.88,190.46 271.76,190.46 B09.E1
DTB_06\  (via drill 0.61)
  Route2 0.254: v285.99,206.21 271.76,191.99 270.75,191.99 268.72,189.95 268.72,187.92 B09.F1
  Route15 0.254: v342.88,209.77 343.9,209.77 355.08,198.59 355.08,196.56 357.11,194.53 B02.D2
  Bottom 0.254: v285.99,206.21 289.55,209.77 v342.88,209.77
DTB_07  (via drill 0.61)
  Top 0.254: v248.91,173.19 250.43,171.67 v250.43,164.05 | v268.72,163.54 270.24,162.01 270.24,119.85 270.75,119.34 270.75,118.33 270.24,117.82 270.24,103.59 271.26,102.58 C09.P1
  Route15 0.254: v248.91,173.19 219.44,202.65 219.44,204.69 174.74,249.39 174.74,250.41 165.59,259.55 162.55,259.55 133.08,289.01 109.71,289.01 107.17,291.55 63.99,291.55 47.23,274.79 47.23,273.77 41.64,268.19 41.64,253.45 43.67,251.42 45.7,251.42 A25.J2 | v250.43,164.05 250.43,163.03 260.08,153.38 260.08,151.35 261.61,149.82 B09.V2
  Bottom 0.254: v268.72,163.54 250.94,163.54 v250.43,164.05
DTB_07\  (via drill 0.61)
  Route2 0.254: v335.26,213.83 326.12,204.69 317.99,204.69 308.34,195.03 302.25,195.03 301.23,194.02 300.21,194.02 291.58,185.38 291.58,180.3 287,175.73 287,173.19 278.88,165.06 278.88,161.51 278.37,161 275.83,161 275.32,160.49 275.32,159.98 272.78,157.44 272.78,151.85 270.75,149.82 268.72,149.82 B09.V1
  Route15 0.254: v335.26,213.83 356.09,193 358.63,193 360.16,191.48 B02.E2
DTB_08  (via drill 0.61)
  Top 0.254: v265.16,188.94 267.19,188.94 267.19,175.73 267.7,175.22 B09.L1 | v276.85,147.79 276.34,148.3 v276.34,159.98
  Route2 0.254: v248.91,103.59 246.87,105.63 246.87,107.15 247.38,107.66 247.38,111.72 248.4,112.74 251.95,112.74 253.48,114.26 253.48,120.36 257.03,123.91 257.03,127.98 v276.85,147.79
  Route15 0.254: v74.15,249.39 74.15,248.88 101.58,221.45 101.58,218.91 v137.65,182.84 | v248.91,103.59 251.95,100.55 252.46,100.55 252.97,100.04 252.97,99.53 259.57,92.93 261.61,92.93 C09.T2 | v276.34,159.98 276.34,164.55 270.24,170.65 270.24,172.17 268.21,174.21 B09.L1
  Bottom 0.254: v74.15,249.39 50.78,249.39 49.77,248.37 A25.K2 | v137.65,182.84 213.35,182.84 216.9,186.4 252.46,186.4 255,188.94 v265.16,188.94
DTB_08\  (via drill 0.61)
  Route2 0.254: v334.76,164.05 337.3,164.05 v341.87,168.62
  Bottom 0.254: v334.76,164.05 324.09,164.05 317.99,170.14 272.78,170.14 271.76,171.16 B09.M1 | v341.87,168.62 346.95,173.7 352.03,173.7 356.09,177.76 360.16,177.76 B02.K2
DTB_09  (via drill 0.61)
  Top 0.254: v266.18,187.92 266.18,166.08 265.67,165.57 B09.P2
  Route2 0.254: v266.18,187.92 266.18,189.95 269.73,193.51 269.73,195.03 271.26,196.56 B09.C1
  Route15 0.254: v84.31,212.31 56.37,240.25 54.85,240.25 50.78,244.31 46.21,244.31 A25.L2 | v256.02,210.27 267.19,199.1 269.73,199.1 271.26,197.57 B09.C1
  Bottom 0.254: v84.31,212.31 85.33,211.29 224.52,211.29 225.54,210.27 v256.02,210.27
DTB_09\  (via drill 0.61)
  Route2 0.254: v322.56,213.32 313.93,204.69 304.79,204.69 273.29,173.19 270.24,173.19 262.11,165.06 262.11,162.52 B09.R2
  Route15 0.254: v322.56,213.32 322.56,212.81 336.28,199.1 336.28,198.08 355.08,179.29 355.08,177.76 357.11,175.73 B02.L2
DTB_10  (via drill 0.61)
  Route2 0.254: v249.41,145.25 258.05,153.89 260.08,153.89 261.61,155.41 B09.T2 | v268.72,153.89 271.26,156.43 271.26,158.46 B09.S1
  Bottom 0.254: v249.41,145.25 248.91,144.74 137.15,144.74 118.35,163.54 108.7,163.54 73.64,198.59 38.09,198.59 38.09,239.23 38.59,239.74 47.23,239.74 48.75,241.26 A25.M2 | v268.72,153.89 268.21,154.39 263.13,154.39 262.11,155.41 B09.T2
DTB_10\  (via drill 0.61)
  Route2 0.254: v285.99,173.7 272.78,160.49 272.78,158.46 271.76,157.44 271.76,152.87 B09.U1
  Route15 0.254: v341.87,161 v331.71,171.16
  Bottom 0.254: v285.99,173.7 304.79,173.7 305.29,174.21 307.83,174.21 308.85,173.19 321.55,173.19 322.06,172.68 330.19,172.68 v331.71,171.16 | v341.87,161 355.59,161 356.6,162.01 B02.R2
DTB_11  (via drill 0.61)
  Top 0.254: v266.69,206.72 269.73,203.67 269.73,182.33 268.72,181.32 B09.J1
  Bottom 0.254: v266.69,206.72 266.18,206.21 240.27,206.21 238.75,207.73 212.84,207.73 211.82,208.75 185.91,208.75 184.9,207.73 93.46,207.73 92.44,208.75 41.13,208.75 41.13,237.71 45.2,237.71 45.7,238.21 A25.N2 | B09.H2 265.67,183.86 268.21,181.32 B09.J1
DTB_11\  (via drill 0.61)
  Route2 0.254: v338.31,184.87 337.3,184.87 329.68,177.25 329.17,177.25 324.09,172.17 324.09,168.11 313.42,157.44 v309.87,157.44
  Route15 0.254: v338.31,184.87 338.31,184.37 360.16,162.52 360.16,159.47 B02.S2 | v309.87,157.44 v287.51,179.79
  Bottom 0.254: v287.51,179.79 263.13,179.79 262.11,180.81 B09.J2
DTF  (via drill 0.61)
  Top 0.254: v61.96,177.25 56.88,182.33 56.88,200.11 50.28,206.72 50.28,231.61 47.23,234.66 47.23,260.57 43.16,264.63 43.16,266.66 A26.C1
  Route2 0.254: A12.M1 233.67,242.28 237.22,242.28 241.79,246.85 247.89,246.85 250.94,249.9 252.46,249.9 255,252.44 261.1,252.44 270.75,262.09 273.8,262.09 276.85,265.14 278.88,265.14 287.51,256.5 285.99,254.98 285.99,253.96 283.96,251.93 A08.J1
  Route15 0.254: v61.96,177.25 114.79,124.42 114.79,122.9 169.15,68.54 170.67,68.54 221.47,17.74 224.52,17.74 234.17,8.09 242.3,16.22 D11.V1 | v194.55,275.81 195.57,274.79 199.63,274.79 215.38,259.04 224.52,259.04 232.14,251.42 232.14,247.36 233.16,246.34 233.16,242.28 A12.M1
  Bottom 0.254: v194.55,275.81 194.04,275.3 53.33,275.3 45.7,267.68 43.16,267.68 A26.C1
DTF\  (via drill 0.61)
  Top 0.254: v331.2,207.23 333.23,205.19 333.23,176.75 332.22,175.73 B04.L2
  Route2 0.254: v135.62,114.77 135.62,116.29 142.73,123.41 142.73,142.71 164.58,164.55 164.58,166.08 197.09,198.59 v197.6,198.59
  Route15 0.254: v135.62,114.77 178.8,71.59 180.33,71.59 222.49,29.43 222.49,28.41 234.17,16.73 236.21,16.73 D11.V2
  Bottom 0.254: 234.68,198.59 235.19,199.1 239.76,199.1 242.81,202.15 248.4,202.15 250.94,204.69 307.83,204.69 310.37,207.23 v331.2,207.23 | 234.68,198.59 233.67,197.57 B12.C1 | 234.68,198.59 v197.6,198.59
DTSF  (via drill 0.61)
  Top 0.254: v234.17,217.39 231.63,219.93 231.63,230.59 230.62,231.61 A12.R1
  Route15 0.254: v234.17,217.39 276.34,175.22 276.34,174.21 277.86,172.68 282.43,172.68 306.82,148.3 309.36,148.3 309.87,147.79 309.87,147.28 319.52,137.63 322.06,137.63 C05.B1
EA_00\  (via drill 0.61)
  Top 0.254: 304.28,160.49 304.28,213.83 303.77,214.34 303.77,218.91 A06.V2 | 304.28,160.49 304.28,79.72 301.74,77.18 301.74,17.74 302.75,16.73 D06.V2 | 304.28,160.49 v303.77,160.49
  Bottom 0.254: v303.77,160.49 321.04,160.49 322.06,161.51 B05.R1
EA_01\  (via drill 0.61)
  Top 0.254: v325.61,148.81 326.63,149.82 326.63,157.44 325.61,158.46 B05.S1
  Route2 0.254: v267.7,90.89 268.72,90.89 272.78,94.96 272.78,97.5 293.1,117.82 294.62,117.82 302.25,125.44 306.31,125.44 320.53,139.66 320.53,142.2 323.07,144.74 323.07,146.27 v325.61,148.81 | v284.47,206.21 295.64,217.39 295.64,220.43 296.66,221.45 301.23,221.45 302.75,222.97 302.75,225.51 A06.T2
  Route15 0.254: v267.7,90.89 277.35,81.24 278.88,81.24 301.74,58.38 301.74,28.41 303.26,26.89 303.26,23.33 D06.T2 | v284.47,206.21 284.47,203.16 300.72,186.91 300.72,185.38 314.44,171.67 314.44,171.16 315.96,169.63 316.47,169.63 323.58,162.52 323.58,161 325.11,159.47 B05.S1
EA_02\  (via drill 0.61)
  Top 0.254: v321.55,138.65 321.04,138.14 321.04,90.89 323.58,88.35 323.58,21.3 308.34,21.3 308.34,23.84 306.82,25.36 D06.S2 | 314.44,182.33 v314.44,148.81 | 314.44,182.33 v315.45,183.35 | v314.94,222.97 314.44,222.47 314.44,193 315.96,191.48 315.96,189.95 314.44,188.43 314.44,182.33
  Route15 0.254: v321.55,138.65 321.55,141.69 v314.44,148.81 | v314.94,222.97 308.85,229.07 306.82,229.07 A06.S2
  Bottom 0.254: v315.45,183.35 315.96,183.86 318.5,183.86 B05.H2
EF
  Top 0.254: A12.F1 230.62,257.01 231.63,255.99 231.63,246.34 230.62,245.33 A12.L1
  Bottom 0.254: A25.N1 52.82,239.23 52.82,243.8 58.41,243.8 60.95,246.34 94.47,246.34 97.01,243.8 229.09,243.8 229.6,244.31 A12.L1 230.62,245.33 231.63,246.34 242.3,246.34 242.3,250.91 A11.J1
EF\  (via drill 0.61)
  Top 0.254: v340.35,249.9 339.84,249.39 339.84,241.26 342.38,238.72 342.38,221.45 341.36,220.43 341.36,204.18 B04.A1
  Bottom 0.254: v340.35,249.9 339.84,249.39 247.38,249.39 246.37,248.37 A11.K1
END  (via drill 0.61)
  Top 0.254: v246.87,290.54 246.87,291.55 64.5,291.55 44.69,271.74 44.69,269.2 50.28,263.61 50.28,234.15 51.8,232.63 A25.R1
  Route15 0.254: v246.87,290.54 256.53,290.54 272.78,274.28 272.78,273.27 283.45,262.6 285.48,262.6 287,261.07 A08.E1
END\  (via drill 0.61)
  Top 0.254: v289.55,191.48 288.53,192.49 288.53,250.91 284.47,254.98 284.47,257.01 A08.F1
  Route2 0.254: A09.M2 265.67,241.77 267.19,241.77 272.78,247.36 272.78,248.37 280.4,255.99 282.94,255.99 283.96,257.01 A08.F1
  Bottom 0.254: v289.55,191.48 292.09,188.94 337.3,188.94 337.81,188.43 B04.F1
ENI  (via drill 0.61)
  Top 0.254: v175.75,282.41 175.75,282.92 69.07,282.92 51.29,265.14 51.29,245.83 51.8,245.33 A25.L1 | v265.16,161 266.69,162.52 266.69,171.16 270.24,174.71 270.24,215.35 266.18,219.42 v266.18,226.02
  Route2 0.254: v301.74,117.82 301.23,117.82 297.67,114.26 297.67,113.25 296.66,112.23 C07.L1
  Route15 0.254: v175.75,282.41 200.14,282.41 216.9,265.65 219.95,265.65 223.51,262.09 | 223.51,262.09 229.09,256.5 231.63,256.5 233.16,254.98 A12.H1 | v301.74,117.82 301.74,122.39 290.56,133.57 289.55,133.57 275.83,147.28 275.83,150.33 v265.16,161 | v266.18,226.02 250.94,241.26 250.94,245.33 234.17,262.09 223.51,262.09
ENI\  (via drill 0.61)
  Route2 0.254: v315.45,114.26 315.96,114.26 319.01,117.31 319.52,117.31 324.6,122.39 327.65,122.39 v360.16,154.9
  Route15 0.254: v360.16,154.9 360.16,155.92 348.98,167.09 348.98,168.62 346.44,171.16 346.44,173.19 344.92,174.71 B03.L2
  Bottom 0.254: v315.45,114.26 314.44,113.25 300.21,113.25 300.21,108.67 C07.M1
FR_00  (via drill 0.61)
  Top 0.254: v294.12,144.74 294.12,150.84 295.13,151.85 295.13,156.93 v294.62,157.44
  Route2 0.254: v294.12,144.74 271.76,122.39 270.75,122.39 249.92,101.56 248.91,101.56 247.38,100.04 241.79,100.04 231.63,89.88 227.06,89.88 C12.U2 | v111.75,286.47 84.31,259.04 61.45,259.04 60.44,258.03 52.82,258.03 A25.F1
  Route15 0.254: v111.75,286.47 122.92,286.47 162.55,246.85 164.58,246.85 204.71,206.72 205.22,206.72 v221.47,190.46 222.49,189.45 222.49,186.91 247.38,162.01 247.38,159.98 261.61,145.76 v263.64,145.76
  Bottom 0.254: v294.62,157.44 295.13,157.95 299.2,157.95 299.71,158.46 B07.S1 | v221.47,190.46 226.55,190.46 B12.E2 | v294.12,144.74 293.61,144.23 268.21,144.23 266.69,145.76 v263.64,145.76
FR_00\  (via drill 0.61)
  Top 0.254: C12.P1 233.67,102.58 234.17,103.09 234.17,113.75 233.67,114.26 C12.K1 233.67,115.28 v233.67,118.83
  Route2 0.254: v233.67,118.83 234.17,118.83 v260.08,144.74
  Bottom 0.254: B03.N1 350.5,168.11 349.49,167.09 339.33,167.09 335.26,163.03 333.74,163.03 333.74,155.92 329.17,151.35 305.29,151.35 304.28,152.36 300.21,152.36 B07.U1 299.71,152.87 298.69,153.89 292.59,153.89 290.05,151.35 283.96,151.35 279.38,146.77 262.11,146.77 v260.08,144.74
FR_01  (via drill 0.61)
  Top 0.254: B07.V2 290.05,148.81 289.04,147.79 289.04,58.38 291.58,55.84 291.58,17.23 291.07,16.73 D07.V2 | v187.44,168.62 187.44,154.39 189.98,151.85 189.98,131.53 189.47,131.03 C15.D1 188.96,130.01 188.96,126.96 190.49,125.44 v190.49,63.97 | v193.53,235.17 193.53,173.19 192.52,172.17 B15.M1
  Route15 0.254: v193.53,235.17 v193.53,244.82 | v190.49,63.97 190.49,63.46 222.49,31.46 225.03,31.46 227.57,28.92 229.6,28.92 D12.R1
  Bottom 0.254: D07.V2 290.05,15.71 289.55,15.2 246.87,15.2 233.67,28.41 230.62,28.41 D12.R1 | v187.44,168.62 187.44,171.16 191.5,171.16 B15.M1 | 193.53,246.85 213.85,246.85 223,255.99 257.54,255.99 258.56,254.98 A10.H1 | 193.53,246.85 101.08,246.85 94.98,252.95 56.88,252.95 55.87,253.96 A25.H1 | v193.53,244.82 193.53,246.85
FR_01\  (via drill 0.61)
  Top 0.254: v297.67,158.97 298.18,158.46 298.18,150.84 297.17,149.82 B07.V1 | v318.5,180.3 317.99,180.81 317.99,189.95 318.5,190.46 B05.E2
  Route2 0.254: v297.67,158.97 297.67,159.47 v318.5,180.3
  Route15 0.254: v248.4,252.95 249.92,252.95 272.78,230.09 272.78,228.56 299.2,202.15 303.26,202.15 310.88,194.53 310.88,188.94 311.39,188.43 311.39,187.41 313.93,184.87 313.93,183.35 314.94,182.33 316.47,182.33 v318.5,180.3
  Bottom 0.254: B03.D2 343.9,194.53 342.88,195.54 326.63,195.54 322.06,190.97 319.52,190.97 B05.E2 | v248.4,252.95 228.59,252.95 227.57,253.96 A12.H2
FR_02  (via drill 0.61)
  Top 0.254: A25.J1 52.82,250.91 56.88,250.91 56.88,201.13 62.98,195.03 62.98,132.04 120.38,74.64 120.38,52.79 151.37,21.81 151.37,21.3 158.48,14.19 293.61,14.19 293.61,19.27 D07.U2 293.1,19.77 292.09,20.79 v292.09,78.7
  Route2 0.254: v319.01,106.13 319.01,105.63 v292.09,78.7
  Route15 0.254: v319.01,106.13 300.21,124.93 300.21,126.96 C07.E1
FR_02\  (via drill 0.61)
  Top 0.254: v319.01,146.27 317.99,147.28 317.99,154.9 v318.5,155.41
  Route2 0.254: v319.01,146.27 314.44,141.69 312.41,141.69 311.39,140.68 311.39,140.17 309.36,138.14 308.34,138.14 301.23,131.03 301.23,126.45 299.2,124.42 297.17,124.42 C07.F1 | v318.5,155.41 318.5,156.43 324.6,162.52 327.14,162.52 332.22,167.6 332.73,167.6 339.33,174.21 339.33,178.27 341.36,180.3 341.36,182.33 345.93,186.91 345.93,188.94 347.46,190.46 B03.E2
FR_03  (via drill 0.61)
  Top 0.254: v298.69,99.02 298.69,18.25 297.17,16.73 D07.V1
  Route2 0.254: v284.47,113.75 287,116.29 290.56,116.29 291.58,117.31 291.58,119.34 293.1,120.87 C07.H2
  Route15 0.254: v298.69,99.02 298.69,99.53 v284.47,113.75 | v141.72,166.08 112.25,195.54 108.7,195.54 56.37,247.87 55.87,247.87 A25.K1 | v238.24,118.33 238.24,120.36 235.19,123.41 235.19,127.47 224.52,138.14 223,138.14 v213.35,147.79
  Bottom 0.254: v141.72,166.08 143.75,164.05 155.43,164.05 158.48,161 162.04,161 | 162.04,161 163.05,161 164.07,162.01 167.62,162.01 168.64,161 181.85,161 182.36,161.51 B15.R2 | v284.47,113.75 281.42,116.8 259.06,116.8 256.53,119.34 239.25,119.34 v238.24,118.33 | v213.35,147.79 211.82,146.27 182.36,146.27 170.67,157.95 162.04,157.95 162.04,161
FR_03\  (via drill 0.61)
  Route2 0.254: 317.99,153.38 318.5,153.89 322.56,153.89 326.63,157.95 326.63,158.97 333.74,166.08 333.74,166.59 343.39,176.24 345.93,176.24 347.46,177.76 B03.K2 | 317.99,153.38 315.96,151.35 315.45,151.35 301.23,137.12 301.23,133.06 298.69,130.52 298.69,128.49 290.56,120.36 290.56,118.33 C07.J2 | 317.99,153.38 v316.47,153.38
  Route15 0.254: v316.47,153.38 313.93,155.92 313.93,159.47 309.36,164.05 308.34,163.03 308.34,161.51 310.88,158.97 310.88,153.38 308.85,151.35 305.8,151.35 298.69,158.46 298.69,159.47 297.17,161 296.15,161 289.55,167.6 288.53,167.6 278.37,177.76 278.37,180.81 B08.J2
GND  (via drill 0.61)
  Top 0.635: v187.95,143.22 182.87,143.22 182.87,137.63 C15.B2 | AB01.BH2 372.86,184.37 372.86,178.78 AB01.BK2 | v319.52,175.73 319.52,172.17 B05.M2 | A16.T1 175.75,225.51 174.74,224.5 174.74,199.1 173.21,197.57 B16.C2 | v325.11,161.51 325.11,165.06 B05.P1 | D11.T1 242.3,22.31 236.71,22.31 D11.T2 | D04.N2 331.2,36.03 331.2,41.11 D04.L2 | D04.U2 335.26,19.77 337.81,22.31 D04.T1 337.81,23.33 337.81,28.41 | 337.81,28.41 332.22,28.41 D04.R2 | 337.81,28.41 D04.R1 337.81,28.41 | D04.J2 331.2,48.73 331.2,53.81 D04.F2 | D03.N2 343.9,36.03 343.9,41.11 D03.L2 | D03.F2 343.9,53.81 343.9,48.73 D03.J2 | D02.U2 360.67,19.77 363.21,22.31 D02.T1 363.21,23.33 363.21,28.41 | 363.21,28.41 D02.R1 | D03.U2 347.97,19.77 350.5,22.31 D03.T1 350.5,23.33 350.5,28.41 D03.R1 350.5,29.43 350.5,35.01 D03.N1 | 363.21,28.41 357.62,28.41 D02.R2 | 363.21,28.41 D02.R1 | D02.L2 356.6,41.11 356.6,36.03 D02.N2 357.62,35.01 363.21,35.01 | 363.21,35.01 D02.N1 363.21,35.01 | D02.F2 356.6,53.81 356.6,48.73 D02.J2 | 363.21,35.01 363.21,29.43 D02.R1 | D05.N2 314.94,36.03 314.94,41.11 D05.L2 | D05.J2 314.94,48.73 314.94,53.81 D05.F2 314.94,54.83 314.94,60.41 D05.D2 | D06.L2 302.75,41.11 302.75,36.03 D06.N2 302.75,35.01 302.75,29.43 D06.R2 303.77,28.41 309.36,28.41 | D06.F2 302.75,53.81 302.75,48.73 D06.J2 | 309.36,28.41 D06.R1 | D05.R2 314.94,28.41 309.87,28.41 D06.R1 | 309.36,28.41 309.36,23.33 D06.T1 | 309.36,28.41 D06.R1 | D04.A1 340.85,70.07 340.85,64.48 D04.C1 | D03.A1 353.55,70.07 353.55,64.48 D03.C1 | D02.A1 366.25,70.07 366.25,64.48 D02.C1 | D06.A1 312.41,70.07 312.41,64.48 D06.C1 | C14.T1 202.17,91.91 203.19,90.89 203.19,71.59 199.12,67.53 199.12,64.48 D14.C2
  Top 0.635: AB19.BM2 131.56,172.17 129.02,174.71 AB19.BL2 128,175.73 126.98,176.75 126.98,186.4 128,187.41 AB19.BF2 | B22.V1 93.97,149.82 96.5,152.36 B22.U1 96.5,152.87 93.97,155.41 B22.T1 93.46,155.41 87.87,155.41 B22.T2 87.87,155.92 88.89,156.93 88.89,195.54 89.9,196.56 B22.C2 | 79.23,266.66 83.8,266.66 A23.C1 84.31,266.66 89.9,266.66 A22.C2 | 79.23,266.66 78.22,266.66 A23.C2 | 79.23,266.66 79.23,258.03 75.17,258.03 A23.F2 | AB19.AU2 131.56,222.97 129.02,225.51 AB19.AT2 129.02,226.02 131.56,228.56 AB19.AS2 131.56,229.07 129.02,231.61 AB19.AR2 129.02,232.63 130.03,233.64 130.03,249.9 | 130.03,249.9 129.02,250.91 AB19.AJ2 | 130.03,249.9 131.56,248.37 AB19.AK2 | 130.03,249.9 130.03,265.14 131.56,266.66 AB19.AC2 | A23.M2 78.22,242.28 79.23,243.29 79.23,249.39 80.76,250.91 A23.J1 | B23.C2 78.22,197.57 79.23,198.59 79.23,217.39 80.76,218.91 A23.V1 | A04.N1 337.81,238.21 337.81,232.63 A04.R1 337.81,231.61 337.81,226.53 A04.T1 | A04.R2 331.2,232.63 331.2,238.21 A04.N2 331.2,239.23 331.2,244.31 A04.L2 331.2,245.33 331.2,250.91 A04.J2 331.2,251.93 331.2,257.01 A04.F2 | A03.T1 350.5,226.53 350.5,231.61 A03.R1 350.5,232.63 350.5,238.21 A03.N1 | A03.N2 343.9,239.23 343.9,244.31 A03.L2 | A03.F2 343.9,257.01 343.9,251.93 A03.J2 | A02.N1 363.21,238.21 363.21,232.63 A02.R1 363.21,231.61 363.21,226.53 A02.T1 | AB01.AH2 372.86,253.96 372.86,248.37 AB01.AK2 | A02.N2 356.6,239.23 356.6,244.31 A02.L2 356.6,245.33 356.6,245.83 354.57,247.87 A03.K1 354.57,248.37 354.57,248.88 356.6,250.91 A02.J2 356.6,251.93 356.6,257.01 A02.F2 | A08.T1 283.96,225.51 278.37,225.51 A08.T2
  Top 0.635: A03.C2 347.46,266.66 341.87,266.66 A04.C1 340.85,267.68 340.85,273.27 A04.A1 | A03.A1 353.55,273.27 353.55,267.68 A03.C1 354.57,266.66 360.16,266.66 A02.C2 360.67,266.66 366.25,266.66 A02.C1 366.25,267.68 366.25,273.27 A02.A1 | A07.T1 297.17,225.51 299.71,222.97 A07.U1 | A06.N1 309.36,238.21 309.36,232.63 A06.R1 309.36,231.61 309.36,226.53 A06.T1 | A05.N2 315.45,239.23 315.45,244.31 A05.L2 315.45,245.33 312.91,247.87 A06.K1 312.91,248.37 315.45,250.91 A05.J2 315.45,251.93 315.45,257.01 A05.F2 316.47,257.01 322.06,257.01 A05.F1 322.56,258.03 325.11,260.57 A05.E1 325.11,261.07 322.56,263.61 A05.D1 | A06.N2 302.75,239.23 302.75,244.31 A06.L2 303.77,245.33 303.77,245.83 305.8,247.87 A06.K2 305.8,248.37 305.8,248.88 303.77,250.91 A06.J2 302.75,251.93 302.75,257.01 A06.F2 | A05.P1 325.11,235.67 322.56,238.21 A05.N1 | A05.L1 322.56,245.33 325.11,247.87 A05.K1 325.11,248.37 322.56,250.91 A05.J1 | A06.C2 306.82,266.66 312.41,266.66 A06.C1 312.41,267.68 312.41,273.27 A06.A1 | A05.D2 316.47,264.63 318.5,266.66 A05.C2 | A05.A1 325.11,273.27 322.56,270.73 A05.B1 | A04.C2 334.76,266.66 325.61,266.66 A05.C1
  Route2 0.635: C12.C2 227.06,134.07 230.62,134.07 232.14,135.6 235.19,135.6 236.21,136.61 C11.B2 | B02.V1 363.71,150.33 366.25,152.87 B02.U1 366.76,152.36 367.78,151.35 367.78,149.82 367.27,149.31 367.27,143.22 361.68,137.63 361.68,136.11 360.67,135.09 360.67,134.07 C02.C2 | B05.V1 322.56,149.82 325.11,152.36 B05.U1 325.61,152.87 331.71,158.97 334.25,156.43 337.81,156.43 B04.T1 | AB01.BL2 370.32,175.22 372.86,177.76 AB01.BK2 | B05.F2 315.96,187.92 315.96,189.95 316.47,190.46 316.47,191.99 317.49,193 317.49,195.03 319.01,196.56 B05.C2 | v319.52,175.73 320.53,176.75 320.53,179.29 322.06,180.81 B05.J1 | v325.11,161.51 322.56,158.97 322.56,155.92 B05.T1 | D03.R2 344.92,28.92 350.5,28.92 D03.R1 | D05.E1 324.6,57.37 322.06,54.83 D05.F1 | D05.A1 324.6,70.07 324.6,69.05 322.56,67.02 D05.B1 | D05.D2 315.96,60.92 318.5,63.46 D05.C2 | A23.V1 81.27,219.93 83.8,222.47 A23.U1 | A26.D2 33.51,263.61 36.05,263.61 56.37,243.29 55.36,242.28 A25.M1 55.36,241.26 53.83,239.74 53.83,237.2 39.61,222.97 37.07,222.97 A26.U2 | A23.T2 74.66,226.53 74.66,228.56 79.74,233.64 82.28,233.64 83.8,235.17 A23.P1 | A05.R1 322.56,232.63 325.11,235.17 A05.P1
  Route15 0.635: v187.95,143.22 190.49,140.68 190.49,139.15 195.57,134.07 198.11,134.07 C14.C2 | B05.T1 322.56,155.41 325.11,152.87 B05.U1 | C04.C2 334.76,134.07 334.76,136.61 322.56,148.81 B05.V1 | C15.B2 182.36,137.63 182.36,144.23 181.34,145.25 181.34,146.27 179.82,147.79 179.82,149.82 177.79,151.85 177.79,154.39 176.77,155.41 B16.T1 | 369.81,190.46 369.81,193.51 AB01.BD2 | 369.81,190.46 371.33,188.94 371.33,186.4 372.86,184.87 AB01.BH2 | 369.81,190.46 363.21,197.07 360.67,197.07 B02.C2 | B05.F2 315.96,186.91 315.96,184.87 317.99,182.84 320.53,182.84 322.06,181.32 B05.J1 | 245.86,28.41 245.86,31.97 D11.P1 | 245.86,28.41 241.79,24.35 242.81,23.33 D11.T1 | 245.86,28.41 251.45,22.82 255,22.82 D10.T1 | D03.L2 344.41,42.13 341.87,44.67 D04.K1 | D02.L2 357.11,42.13 354.57,44.67 D03.K1 | D05.L1 322.06,41.11 324.6,38.57 D05.M1 | D05.E1 324.6,57.87 322.06,60.41 D05.D1 321.55,60.92 319.01,63.46 D05.C2 | D05.D2 314.94,60.92 314.94,61.43 312.91,63.46 D06.C1 | A26.V1 39.61,219.93 37.07,222.47 A26.U2 | A23.P1 83.8,235.67 81.27,235.67 79.23,237.71 79.23,239.74 77.71,241.26 A23.M2 | A23.J1 80.76,251.93 78.22,251.93 76.19,253.96 76.19,255.49 74.66,257.01 A23.F2
  Bottom 0.635: C14.C2 198.61,134.07 200.14,135.6 209.28,135.6 210.81,134.07 C13.C2 211.31,134.07 212.84,135.6 220.46,135.6 221.98,134.07 226.05,134.07 C12.C2 | C15.B2 182.36,136.61 181.34,135.6 174.74,135.6 173.21,134.07 C16.C2 172.71,134.07 171.18,135.6 158.99,135.6 157.47,134.07 C17.C2 156.96,133.57 155.43,132.04 146.29,132.04 144.77,133.57 CD18.AC2 | 263.13,135.6 254.49,135.6 252.97,134.07 C10.C2 | 263.13,135.6 264.65,134.07 C09.C2 | 278.88,135.6 280.4,134.07 C08.C2 | 278.88,135.6 263.13,135.6 | 291.58,135.6 293.1,134.07 C07.C2 | 291.58,135.6 278.88,135.6 | 304.28,135.6 305.8,134.07 C06.C2 | 304.28,135.6 291.58,135.6 | 304.28,135.6 316.98,135.6 318.5,134.07 C05.C2 319.52,134.07 321.04,135.6 329.17,135.6 331.2,133.57 334.76,133.57 C04.C2 | C03.C2 347.97,134.07 348.47,134.58 352.03,134.58 353.05,135.6 358.63,135.6 360.16,134.07 C02.C2 360.67,133.57 362.19,133.57 363.71,132.04 371.33,132.04 372.86,133.57 C01.C2 | B02.T1 363.71,155.41 365.75,153.38 366.25,153.38 B02.U1 367.27,153.38 367.78,153.38 368.79,154.39 374.89,154.39 375.91,155.41 AB01.BT1 | B04.V1 338.31,150.33 340.35,152.36 340.85,152.36 B04.U1 | B04.T1 338.31,155.41 340.35,153.38 340.85,153.38 B04.U1 | 352.03,151.35 353.05,152.36 353.55,152.36 B03.U1 353.55,153.38 353.05,153.38 352.03,154.39 | 352.03,151.35 351.01,150.33 B03.V1 | 352.03,154.39 351.01,155.41 B03.T1 | 352.03,154.39 342.88,154.39 341.87,153.38 B04.U1 | 352.03,151.35 362.19,151.35 363.21,150.33 B02.V1 | B16.T1 176.77,155.92 177.28,156.43 180.33,156.43 181.34,157.44 186.42,157.44 187.95,155.92 188.45,155.92 B15.T1 189.47,155.92 190.99,157.44 199.63,157.44 201.15,155.92 B14.T1 202.17,155.92 205.22,155.92 206.74,157.44 212.33,157.44 213.85,155.92 B13.T1 214.87,155.92 215.89,156.93 221.98,156.93 222.49,157.44 232.14,157.44
  Bottom 0.635: 232.14,157.44 230.62,155.92 B12.T1 | 232.14,157.44 240.27,157.44 241.79,155.92 242.3,155.92 B11.T1 243.32,155.92 244.84,157.44 253.48,157.44 | 253.48,157.44 255,155.92 B10.T1 | 266.18,157.44 267.7,155.92 B09.T1 | 266.18,157.44 253.48,157.44 | 266.18,157.44 278.88,157.44 279.89,156.43 283.45,156.43 283.96,155.92 B08.T1 284.47,155.92 285.99,157.44 292.59,157.44 294.12,155.92 296.66,155.92 B07.T1 297.17,155.92 298.69,155.92 300.21,157.44 307.83,157.44 309.36,155.92 B06.T1 309.87,155.92 310.37,155.92 311.9,157.44 320.53,157.44 322.06,155.92 B05.T1 | B02.C2 360.16,197.07 358.63,195.54 349.49,195.54 347.97,197.07 B03.C2 347.46,197.57 345.93,199.1 336.79,199.1 335.26,197.57 B04.C2 334.76,197.07 325.61,197.07 B05.C1 325.11,197.07 319.52,197.07 B05.C2 318.5,196.56 317.49,195.54 307.83,195.54 306.82,196.56 B06.C2 305.8,196.56 304.79,195.54 295.13,195.54 294.12,196.56 B07.C2 293.1,197.57 292.09,198.59 279.38,198.59 278.37,199.61 B08.B2 277.35,200.11 270.75,200.11 268.21,197.57 265.67,197.57 B09.C2 264.65,197.57 263.64,198.59 256.53,198.59 255,197.07 252.97,197.07 B10.C2 251.95,197.57 250.94,198.59 241.29,198.59 240.27,197.57 B11.C2 239.25,196.56 238.24,195.54 225.54,195.54 | AB01.BD2 370.32,194.53 372.86,197.07 AB01.BC2 | B05.M2 319.52,171.16 320.53,170.14 323.58,170.14 325.11,168.62 325.11,165.57 B05.P1 | 187.44,224.5 177.79,224.5 176.77,225.51 A16.T1 | 187.44,224.5 188.45,225.51 A15.T1 | 187.44,224.5 200.14,224.5 201.15,225.51 A14.T1 | 209.79,195.54 199.63,195.54 198.61,196.56 B14.C2 198.11,197.07 197.09,197.07 195.57,198.59 183.88,198.59 182.87,199.61 B15.B2 182.36,199.61 181.34,199.61 180.33,198.59 174.23,198.59 173.21,197.57 B16.C2 172.71,196.56 171.69,195.54 142.73,195.54
  Bottom 0.635: 209.79,195.54 210.81,196.56 B13.C2 | 225.54,195.54 226.55,196.56 B12.C2 | 209.79,195.54 225.54,195.54 | 349.49,90.89 339.33,90.89 338.31,91.91 C04.T1 337.81,91.91 336.79,90.89 324.6,90.89 323.07,92.42 322.56,92.42 C05.T1 322.06,92.42 320.53,90.89 314.94,90.89 313.93,91.91 309.87,91.91 C06.T1 309.36,92.93 305.8,92.93 304.79,93.94 295.64,93.94 | 349.49,90.89 350.5,91.91 C03.T1 | 349.49,90.89 362.19,90.89 363.21,91.91 C02.T1 363.71,92.93 365.24,92.93 366.25,93.94 374.89,93.94 375.91,92.93 C01.T1 | 155.43,90.89 158.99,90.89 160.01,91.91 C17.T1 160.51,92.93 161.53,93.94 174.74,93.94 175.75,92.93 C16.T1 176.77,91.91 177.79,90.89 187.44,90.89 | 155.43,90.89 148.83,90.89 147.81,91.91 CD18.AT1 | 187.44,90.89 188.45,91.91 C15.T1 | 187.44,90.89 200.14,90.89 201.15,91.91 C14.T1 202.17,92.93 203.19,93.94 212.84,93.94 | 212.84,93.94 213.85,92.93 C13.T1 | 228.59,93.94 229.6,92.93 C12.T1 | 212.84,93.94 228.59,93.94 | 241.29,93.94 242.3,92.93 C11.T1 | 228.59,93.94 241.29,93.94 | 253.99,93.94 255,92.93 C10.T1 | 241.29,93.94 253.99,93.94 | 266.69,93.94 267.7,92.93 C09.T1 | 253.99,93.94 266.69,93.94 | 282.94,93.94 283.96,92.93 C08.T1 | 266.69,93.94 282.94,93.94 | 295.64,93.94 296.66,92.93 C07.T1 | 282.94,93.94 295.64,93.94 | 238.24,65.49 228.59,65.49 227.57,64.48 D12.C2 226.55,64.48 225.54,65.49 212.33,65.49 211.31,64.48 D13.C2 210.81,63.46 209.79,62.45 197.09,62.45 | 238.24,65.49 239.25,64.48 D11.C2 | 250.94,65.49 251.95,64.48 D10.C2 | 238.24,65.49 250.94,65.49 | 263.64,65.49 264.65,64.48 D09.C2 | 250.94,65.49 263.64,65.49 | 263.64,65.49 279.38,65.49 280.4,64.48 D08.C2 281.42,63.46 281.93,62.95 283.45,62.95 285.99,65.49 292.09,65.49 293.1,64.48 D07.C2 294.12,63.46 295.13,62.45 303.26,62.45 304.28,63.46 305.8,63.46 D06.C2 306.82,63.46 312.41,63.46 D06.C1
  Bottom 0.635: 155.94,62.45 145.78,62.45 144.77,63.46 CD18.BC2 | 155.94,62.45 156.96,63.46 D17.C2 | 171.69,62.45 172.71,63.46 D16.C2 | 171.69,62.45 155.94,62.45 | 184.39,62.45 185.41,63.46 D15.C2 | 184.39,62.45 171.69,62.45 | 197.09,62.45 198.11,63.46 D14.C2 | 197.09,62.45 184.39,62.45 | D11.T2 236.21,22.31 230.62,22.31 D12.T1 229.6,23.33 228.59,24.35 212.84,24.35 | D10.T1 256.02,22.31 257.03,21.3 266.69,21.3 267.7,22.31 D09.T1 268.72,23.33 269.73,24.35 282.94,24.35 283.96,23.33 D08.T1 284.47,22.31 285.48,21.3 295.64,21.3 296.66,22.31 D07.T1 297.17,22.31 299.71,19.77 D07.U1 300.21,19.27 305.8,19.27 D06.U2 306.82,19.77 309.36,22.31 D06.T1 | 212.84,24.35 203.19,24.35 202.17,23.33 D14.T1 201.66,22.31 200.65,21.3 190.49,21.3 189.47,22.31 D15.T1 188.45,23.33 187.44,24.35 174.74,24.35 | 212.84,24.35 213.85,23.33 D13.T1 | 158.99,24.35 148.83,24.35 147.81,23.33 CD18.BT1 | 158.99,24.35 160.01,23.33 D17.T1 | 174.74,24.35 175.75,23.33 D16.T1 | 174.74,24.35 158.99,24.35 | 337.81,35.01 332.22,35.01 D04.N2 331.2,36.03 329.17,38.06 325.61,38.06 D05.M1 324.6,38.06 322.56,36.03 D05.N1 322.56,35.01 325.11,32.47 D05.P1 324.6,31.97 322.06,29.43 D05.R1 322.56,28.41 324.6,26.38 D05.S1 324.6,25.36 322.56,23.33 D05.T1 321.55,22.31 319.01,19.77 D05.U2 | 337.81,35.01 D04.N1 | D03.R2 343.9,28.41 338.31,28.41 D04.R1 337.81,29.43 337.81,35.01 | 337.81,35.01 D04.N1 | D04.F2 332.22,53.81 337.81,53.81 D04.F1 338.31,53.81 343.9,53.81 D03.F2 344.92,53.81 350.5,53.81 D03.F1 | D04.K1 341.87,45.17 344.41,47.71 D03.J2 | D04.N1 338.31,35.01 343.9,35.01 D03.N2 | D02.R2 356.6,28.41 351.01,28.41 D03.R1
  Bottom 0.635: 356.09,46.7 357.11,47.71 D02.J2 | 356.09,46.7 354.57,45.17 D03.K1 | D02.F1 363.21,53.81 357.62,53.81 D02.F2 | 356.09,46.7 364.73,46.7 366.25,45.17 D02.K1 | D05.F2 314.94,53.81 309.87,53.81 D06.F1 309.36,53.81 303.77,53.81 D06.F2 | D06.N1 309.87,35.01 314.94,35.01 D05.N2 | D05.L2 315.45,42.13 312.91,44.67 D06.K1 312.41,45.17 314.94,47.71 D05.J2 | D06.J2 303.77,47.71 306.31,45.17 D06.K2 306.31,44.67 303.77,42.13 D06.L2 | D02.C1 366.25,63.46 360.67,63.46 D02.C2 360.16,63.46 354.57,63.46 D03.C1 353.55,63.46 347.97,63.46 D03.C2 347.46,63.46 341.87,63.46 D04.C1 340.85,63.46 335.26,63.46 D04.C2 334.76,63.46 325.61,63.46 D05.C1 324.6,63.46 322.56,61.43 D05.D1 | D05.L1 322.56,42.13 325.11,44.67 D05.K1 324.6,45.17 322.06,47.71 D05.J1 322.56,48.73 324.6,50.76 D05.H1 324.6,51.78 322.56,53.81 D05.F1 | D05.C2 319.01,64.48 321.04,66.51 321.55,66.51 D05.B1 | 130.03,189.45 131.05,190.46 131.56,190.46 AB19.BE2 132.07,191.48 135.11,191.48 139.18,195.54 142.73,195.54 | 130.03,189.45 129.02,188.43 AB19.BF2 | 142.73,195.54 144.26,197.07 B18.C2 | 88.89,195.54 79.23,195.54 78.22,196.56 B23.C2 | 88.89,195.54 89.9,196.56 B22.C2 | 101.58,195.54 102.6,196.56 B21.C2 | 88.89,195.54 101.58,195.54 | 101.58,195.54 117.33,195.54 118.86,197.07 B20.C2 119.36,197.07 122.41,197.07 130.03,189.45 | A23.T2 75.17,225.51 80.76,225.51 A23.T1 81.27,225.51 83.8,222.97 A23.U1 | 76.19,240.25 56.88,240.25 55.87,241.26 A25.M1 | 76.19,240.25 77.2,241.26 A23.M2 | 76.19,240.25 88.89,240.25 89.9,241.26 A22.M2 | 101.58,265.65 102.6,266.66 A21.C2 | 101.58,265.65 91.93,265.65 90.92,266.66 A22.C2 | 101.58,265.65 117.84,265.65 118.86,266.66 A20.C2 119.36,267.68 120.38,268.69 133.08,268.69
  Bottom 0.635: 133.08,268.69 143.24,268.69 144.26,267.68 A18.C2 144.77,267.68 145.78,268.69 171.69,268.69 172.71,267.68 A16.C2 173.21,266.66 174.23,265.65 184.39,265.65 | 133.08,268.69 132.07,267.68 AB19.AC2 | 184.39,265.65 185.41,266.66 A15.C2 | 184.39,265.65 197.09,265.65 198.11,266.66 A14.C2 198.61,267.68 199.63,268.69 225.03,268.69 | 241.29,268.69 240.27,267.68 A11.C2 | 241.29,268.69 247.89,268.69 | 247.89,268.69 248.91,269.71 A10.B2 | 263.64,268.69 264.65,267.68 A09.C2 | 247.89,268.69 263.64,268.69 | 279.38,268.69 280.4,267.68 A08.C2 | 263.64,268.69 279.38,268.69 | 279.38,268.69 292.09,268.69 293.1,267.68 A07.C2 294.12,266.66 295.13,265.65 304.79,265.65 305.8,266.66 A06.C2 | 225.03,268.69 224.01,269.71 A12.B2 | 241.29,268.69 225.03,268.69 | A04.U2 335.26,222.97 337.81,225.51 A04.T1 | A04.R2 332.22,231.61 337.81,231.61 A04.R1 338.31,231.61 343.9,231.61 A03.R2 | A03.U2 347.97,222.97 350.5,225.51 A03.T1 | A04.F2 332.22,257.01 337.81,257.01 A04.F1 338.31,257.01 343.9,257.01 A03.F2 344.92,257.01 350.5,257.01 A03.F1 | A03.L2 344.41,245.33 341.87,247.87 A04.K1 341.36,248.37 343.9,250.91 A03.J2 | A03.N2 344.92,238.21 350.5,238.21 A03.N1 351.01,238.21 356.6,238.21 A02.N2 357.62,238.21 363.21,238.21 A02.N1 | A02.R2 357.62,231.61 363.21,231.61 A02.R1 | 362.19,224.5 363.21,225.51 A02.T1 | 362.19,224.5 360.67,222.97 A02.U2 | 362.19,224.5 374.89,224.5 375.91,225.51 AB01.AT1 | AB01.AK2 372.86,247.87 370.32,245.33 AB01.AL2 369.81,245.33 367.27,247.87 A02.K1 366.25,247.87 364.73,246.34 358.63,246.34 357.62,245.33 A02.L2 | A02.F1 363.21,257.01 357.62,257.01 A02.F2 | A08.T2 277.35,225.51 268.72,225.51 A09.T1 267.7,225.51 266.69,224.5 253.99,224.5
  Bottom 0.635: 241.29,224.5 231.63,224.5 230.62,225.51 A12.T1 | 241.29,224.5 242.3,225.51 A11.T1 | 253.99,224.5 255,225.51 A10.T1 | 253.99,224.5 241.29,224.5 | A04.C2 335.26,266.66 340.85,266.66 A04.C1 | A03.C1 353.55,266.66 347.97,266.66 A03.C2 | AB01.AC2 372.86,266.66 367.27,266.66 A02.C1 | A06.T1 309.36,225.51 306.82,222.97 A06.U2 305.8,222.47 300.21,222.47 A07.U1 | A06.R2 303.77,231.61 309.36,231.61 A06.R1 309.87,231.61 315.45,231.61 A05.R2 316.47,232.12 322.06,232.12 A05.R1 322.56,231.61 324.6,229.58 325.11,229.58 A05.S1 325.11,228.56 324.6,228.56 322.56,226.53 A05.T1 322.06,225.51 319.52,222.97 A05.U2 | A06.F2 303.77,257.01 309.36,257.01 A06.F1 309.87,257.01 315.45,257.01 A05.F2 | A05.N1 322.56,239.23 324.6,241.26 325.11,241.26 A05.M1 | A05.L1 322.56,244.31 324.6,242.28 325.11,242.28 A05.M1 | A05.J1 322.56,251.93 324.6,253.96 325.11,253.96 A05.H1 325.11,254.98 324.6,254.98 322.56,257.01 A05.F1 | A05.B1 322.06,269.71 320.03,267.68 319.52,267.68 A05.C2 319.52,266.66 320.03,266.66 322.06,264.63 A05.D1 322.56,264.63 323.07,264.63 325.11,266.66 A05.C1 | A06.C1 312.91,266.66 314.94,264.63 315.45,264.63 A05.D2 | A08.T1 284.47,226.53 285.48,227.55 295.64,227.55 296.66,226.53 A07.T1 | A04.N2 331.2,239.23 329.17,241.26 325.61,241.26 A05.M1 | 155.43,90.89 155.43,106.64 136.64,106.64 111.24,132.04 108.19,132.04 93.97,146.27 93.97,148.81 B22.V1
I/O_0_TO_AC\  (via drill 0.61)
  Top 0.254: 333.74,174.21 v333.23,173.7 | 333.74,174.21 333.74,234.15 334.76,235.17 A04.P2 | 333.74,174.21 333.74,151.85 334.76,150.84 334.76,147.79 333.74,146.77 333.74,88.35 334.25,87.85 334.25,78.19 333.74,77.69 333.74,33.49 334.76,32.47 D04.P2
  Bottom 0.254: v333.23,173.7 323.07,173.7 322.56,174.21 B05.L1
I/O_1_TO_CA_INH\  (via drill 0.61)
  Top 0.254: v317.99,60.41 316.98,61.43 316.98,144.74 v316.47,145.25 | v301.74,181.32 301.74,233.13 304.79,236.18 304.79,240.25 305.8,241.26 A06.M2
  Route2 0.254: v316.47,145.25 316.47,145.76 v328.66,157.95
  Route15 0.254: v317.99,60.41 321.04,57.37 306.31,42.63 306.31,39.08 D06.M2 | v328.66,157.95 326.63,155.92 317.99,164.55 317.99,165.57 | 317.99,165.57 317.99,166.59 316.47,168.11 B05.N2 | v301.74,181.32 301.74,179.29 315.45,165.57 317.99,165.57
I/O_ADDR_ACC\  (via drill 0.61)
  Top 0.254: A05.S2 319.52,228.56 321.04,227.04 321.04,166.59 320.53,166.08 320.53,27.9 319.01,26.38 D05.S2
  Route2 0.254: v360.16,86.83 343.39,70.07 343.39,69.05 336.28,61.94 336.28,50.25 326.63,40.6 326.63,38.06 314.94,26.38 315.96,25.36 318.5,25.36 D05.S2
  Route15 0.254: v360.16,86.83 360.16,88.86 C02.U2
I/O_B-BRK  (via drill 0.61)
  Top 0.254: 317.49,146.77 317.49,201.13 316.98,201.64 316.98,231.1 318.5,232.63 318.5,235.17 A05.P2 | 317.49,146.77 317.49,87.34 320.03,84.8 320.03,33.49 319.01,32.47 D05.P2 | v314.44,146.77 317.49,146.77
  Bottom 0.254: v314.44,146.77 316.47,146.77 319.01,144.23 322.56,144.23 323.58,145.25 370.32,145.25 376.92,138.65 380.48,138.65 380.48,132.55 379.97,132.04 377.43,132.04 376.41,131.03 C01.D1
I/O_B-RUN  (via drill 0.61)
  Top 0.254: v371.84,65.49 371.84,75.65 375.91,79.72 375.91,83.27 377.43,84.8 377.43,104.1 380.48,107.15 380.48,123.41 379.46,124.42 379.46,125.44 380.48,126.45 380.48,139.15 379.97,139.66 C01.A1 379.97,140.68 382,142.71 382,209.77 v383.02,210.78
  Route2 0.254: v371.84,65.49 335.26,28.92 335.26,26.38 D04.S2
  Bottom 0.254: v383.02,210.78 356.6,210.78 339.84,227.55 336.28,227.55 335.26,228.56 A04.S2
I/O_BAC_00  (via drill 0.61)
  Top 0.254: v355.08,169.13 355.08,236.69 352.54,239.23 352.54,264.63 349.49,267.68 349.49,274.79 355.59,274.79 358.63,271.74 358.63,270.73 363.21,270.73 A02.B1
  Route2 0.254: v385.05,91.91 363.71,70.57 363.71,67.53 D02.B1 | v355.08,169.13 355.08,163.54 350,158.46 350,157.44 v344.41,151.85
  Route15 0.254: v385.05,91.91 385.05,103.09 383.53,104.61 383.53,106.64 368.79,121.37 368.79,122.9 356.09,135.6 356.09,137.63 354.06,139.66 C03.A1 354.06,140.68 345.93,148.81 345.93,150.33 v344.41,151.85
I/O_BAC_01  (via drill 0.61)
  Top 0.254: 362.19,119.85 v363.71,119.85 | 362.19,119.85 362.19,62.45 363.21,61.43 D02.D1 | 362.19,119.85 362.19,262.6 363.21,263.61 A02.D1
  Bottom 0.254: v363.71,119.85 364.22,119.85 365.75,118.33 367.27,118.33 368.29,119.34 371.33,119.34 371.33,124.93 366.76,129.5 351.52,129.5 351.01,130.01 C03.D1
I/O_BAC_02  (via drill 0.61)
  Top 0.254: 368.29,125.44 v368.79,125.95 | 368.29,125.44 368.29,58.89 367.27,57.87 D02.E1 | 368.29,125.44 368.29,259.55 367.27,260.57 A02.E1
  Bottom 0.254: v368.79,125.95 359.65,125.95 358.63,126.96 356.09,126.96 354.06,124.93 351.01,124.93 C03.F1
I/O_BAC_03  (via drill 0.61)
  Top 0.254: v376.92,197.57 377.43,197.07 377.43,163.54 380.48,160.49 380.48,148.81 v378.95,147.28
  Route2 0.254: v384.03,94.96 386.06,92.93 386.06,83.27 384.54,81.75 384.54,75.65 380.99,72.1 380.99,68.54 366.76,54.32 366.76,51.78 D02.H1 | v380.48,216.37 380.48,201.13 v376.92,197.57
  Route15 0.254: v380.48,216.37 377.43,219.42 377.43,220.43 374.38,223.48 374.38,236.18 368.29,242.28 368.29,248.88 366.76,250.41 366.76,253.96 A02.H1
  Bottom 0.254: v384.03,94.96 384.03,104.1 380.99,104.1 375.4,109.69 | 375.4,109.69 368.29,116.8 354.57,116.8 353.55,117.82 351.01,117.82 C03.J1 | v378.95,147.28 384.54,141.69 384.54,109.69 375.4,109.69
I/O_BAC_04  (via drill 0.61)
  Top 0.254: D02.J1 363.71,48.73 364.73,49.75 364.73,68.54 363.71,69.56 363.71,71.08 364.73,72.1 v364.73,113.25 364.73,138.14 363.71,139.15 363.71,146.77 364.73,147.79 364.73,200.11 365.24,200.62 365.24,249.39 363.71,250.91 A02.J1
  Bottom 0.254: v364.73,113.25 364.22,112.74 351.52,112.74 351.01,112.23 C03.L1
I/O_BAC_05  (via drill 0.61)
  Top 0.254: v369.3,69.05 368.79,68.54 368.79,42.13 363.71,42.13 D02.L1 | v351.01,102.07 351.01,104.61 C03.N1 | v360.67,239.74 358.63,237.71 358.63,161 v358.12,160.49
  Route2 0.254: v347.46,98.51 v351.01,102.07 | v360.67,239.74 363.71,242.79 363.71,244.31 A02.L1 | v383.53,112.23 383.53,112.74 385.05,114.26 386.06,114.26 386.57,113.75 386.57,67.02 365.24,45.68 365.24,43.65 363.71,42.13 D02.L1
  Route15 0.254: v369.3,69.05 369.3,76.16 347.46,98.01 v347.46,98.51
  Bottom 0.254: v358.12,160.49 358.12,157.44 359.65,157.44 365.75,151.35 370.32,151.35 380.99,140.68 380.99,136.11 382,136.11 384.03,134.07 384.03,116.29 383.02,116.29 382.51,115.79 382.51,112.23 v383.53,112.23
I/O_BAC_06  (via drill 0.61)
  Top 0.254: 371.84,41.11 371.84,60.41 374.38,62.95 v374.38,65.49 | 371.84,41.11 371.84,39.08 367.27,39.08 D02.M1 | v385.56,117.31 386.57,116.29 386.57,55.84 371.84,41.11
  Route2 0.254: v384.54,198.59 384.54,200.62 386.06,202.15 386.06,218.4 366.76,237.71 366.76,241.26 A02.M1 | v383.02,159.47 383.02,154.9 386.06,151.85 386.06,127.98 v382.51,124.42
  Route15 0.254: v374.38,65.49 374.38,77.69 355.08,96.99 352.54,96.99 351.01,98.51 C03.R1 | v378.44,170.14 378.44,168.11 380.48,166.08 380.48,162.01 v383.02,159.47 | v382.51,124.42 383.53,123.41 383.53,122.39 384.54,121.37 384.54,118.33 v385.56,117.31
  Bottom 0.254: v384.54,198.59 384.54,186.4 385.05,186.4 386.06,185.38 386.06,170.14 v378.44,170.14
I/O_BAC_07  (via drill 0.61)
  Top 0.254: v366.76,76.67 367.78,77.69 367.78,144.74 365.24,147.28 365.24,198.59 367.78,201.13 367.78,234.66 367.27,235.17 A02.P1
  Route15 0.254: 362.19,72.1 379.97,54.32 379.97,52.29 380.48,51.78 380.48,48.22 365.75,33.49 366.76,32.47 D02.P1 | 362.19,72.1 351.52,82.77 351.52,84.8 351.01,85.31 351.01,85.81 C03.V1 | v366.76,76.67 362.19,72.1
I/O_BAC_08  (via drill 0.61)
  Top 0.254: v353.05,149.31 352.54,148.81 v352.54,139.66
  Route2 0.254: v324.09,109.69 326.12,109.69 329.68,113.25 329.68,115.28 331.2,116.8 332.73,116.8 336.79,120.87 336.79,121.37 337.3,121.88 338.82,121.88 339.84,122.9 341.36,122.9 343.9,125.44 345.93,125.44 347.46,126.96 C03.E2 347.97,127.98 348.47,128.49 348.47,132.04 352.54,136.11 v352.54,139.66 | v383.02,212.31 385.56,209.77 385.56,202.65 384.03,201.13 384.03,199.61 383.53,199.1 383.53,179.79 v353.05,149.31
  Route15 0.254: v324.09,109.69 324.09,107.66 327.14,104.61 328.66,104.61 379.46,53.81 365.24,39.59 365.24,31.46 366.76,29.93 366.76,26.38 D02.S1 | v383.02,212.31 376.92,218.4 375.4,218.4 366.76,227.04 366.76,228.56 A02.S1
I/O_BAC_09  (via drill 0.61)
  Route2 0.254: v322.56,90.89 323.07,90.89 326.63,94.45 326.63,103.09 338.82,115.28 339.84,115.28 343.9,119.34 | 343.9,119.34 345.93,119.34 347.46,120.87 C03.H2 | 343.9,119.34 356.6,132.04 361.17,132.04 361.68,132.55 361.68,133.06 382,153.38 382,159.98 383.02,161 383.02,169.63 386.57,173.19 386.57,230.59 357.62,259.55 357.62,263.61 A02.D2
  Route15 0.254: v322.56,90.89 322.56,90.39 325.11,87.85 325.61,87.85 338.82,74.64 340.85,74.64 354.57,60.92 356.6,60.92 D02.D2
I/O_BAC_10  (via drill 0.61)
  Top 0.254: v373.37,161.51 374.38,160.49 374.38,128.49 378.95,123.91 v378.95,122.9 | v383.53,110.71 383.02,110.2 v383.02,101.05
  Route2 0.254: v376.92,80.73 368.29,72.1 368.29,69.56 360.67,61.94 360.67,57.87 D02.E2 | v384.54,176.75 384.54,174.21 382,171.67 382,170.14 v373.37,161.51
  Route15 0.254: v376.92,80.73 376.92,82.26 364.73,94.45 364.73,95.47 361.17,99.02 361.17,99.53 359.65,101.05 359.14,101.05 349.49,110.71 349.49,112.74 347.97,114.26 C03.K2 | v370.82,213.32 370.82,209.77 378.95,201.64 378.95,200.11 380.99,198.08 380.99,193 381.49,192.49 381.49,179.79 v384.54,176.75
  Bottom 0.254: v370.82,213.32 377.43,213.32 377.43,246.34 364.73,259.04 362.19,259.04 360.67,260.57 A02.E2 | v378.95,122.9 379.46,122.39 380.48,122.39 382,120.87 382,110.71 v383.53,110.71 | v383.02,101.05 382,100.04 377.43,100.04 377.43,80.73 v376.92,80.73
I/O_BAC_11  (via drill 0.61)
  Top 0.254: v340.35,73.62 339.84,74.13 339.84,98.51 | 339.84,98.51 v340.35,99.02 | v317.99,230.59 317.49,230.09 317.49,218.91 319.01,217.39 319.01,205.7 317.49,204.18 317.49,202.15 320.53,199.1 320.53,181.83 v320.03,181.32 | v341.36,125.95 339.84,124.42 339.84,98.51