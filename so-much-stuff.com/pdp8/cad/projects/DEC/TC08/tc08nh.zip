# EAGLE board tc08nh (EAGLE 4.11), part 4 of 5
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
N$61  (via drill 0.61) (continued)
  Route2 0.254: v204.71,157.44 205.22,157.44 206.23,158.46 206.23,162.52 211.31,167.6 211.82,167.6 212.84,168.62 212.84,169.13 v221.47,177.76
  Route15 0.254: v203.69,111.21 204.2,111.21 221.98,93.43 221.98,91.91 227.06,86.83 229.6,86.83 C12.V1 | v221.47,177.76 223,177.76 225.03,175.73 225.03,174.21 227.06,172.17 B12.M2
N$62
  Top 0.254: B12.N2 223.51,168.62 222.49,169.63 222.49,179.79 223.51,180.81 B12.J2
N$63
  Route15 0.254: B15.K1 192.52,177.76 195.06,177.76 195.57,177.25 197.09,177.25 204.2,170.14 206.23,170.14 207.76,168.62 B13.N2
N$64  (via drill 0.61)
  Top 0.254: v256.02,208.24 256.02,202.65 258.56,200.11 258.56,197.57 B10.C1
  Route2 0.254: B10.D1 256.02,194.02 258.56,196.56 B10.C1
  Route15 0.254: v256.02,208.24 244.84,219.42 244.84,220.94 234.68,231.1 234.68,236.18 229.6,241.26 229.6,242.79 227.57,244.82 227.57,247.87 A12.K2
N$65
  Route2 0.254: C11.T2 236.71,92.93 239.25,95.47 C11.S2
N$66
  Route2 0.254: B10.B1 256.02,200.62 258.56,203.16 B10.A1
  Route15 0.254: A12.F2 224.01,257.01 224.01,253.45 220.97,250.41 229.09,242.28 229.09,235.67 244.33,220.43 244.33,218.4 259.06,203.67 B10.A1
N$67  (via drill 0.61)
  Route15 0.254: v211.82,34 199.63,46.19 197.6,46.19 196.07,47.71 D14.J2
  Bottom 0.254: v211.82,34 250.43,34 251.95,32.47 D10.P2
N$68
  Bottom 0.254: D14.H1 204.71,51.78 204.71,56.35 202.68,56.35 198.61,60.41 196.07,60.41 D14.D2
N$69
  Top 0.254: D14.C1 204.71,64.48 204.71,70.07 D14.A1
N$70
  Top 0.254: B11.U1 246.37,152.87 247.38,153.89 247.38,189.45 246.37,190.46 B11.E1
N$71  (via drill 0.61)
  Top 0.254: v162.04,145.76 162.04,126.45 160.51,124.93 C17.F1
  Route2 0.254: v162.04,145.76 163.05,145.76 172.71,155.41 173.72,155.41 184.9,166.59 186.93,166.59 188.45,168.11 B15.N1
N$72
  Top 0.254: B11.N1 243.32,168.62 244.33,169.63 244.33,182.33 245.86,183.86 B11.H1
N$73
  Bottom 0.254: B09.N2 262.11,168.11 263.13,167.09 282.94,167.09 283.96,168.11 B08.N1
N$76
  Route2 0.254: C15.S2 185.91,95.97 185.91,100.04 193.53,107.66 193.53,109.69 195.06,111.21 C14.L2
N$77
  Bottom 0.254: B11.J1 243.32,181.32 244.84,182.84 252.97,182.84 255,184.87 255,186.91 B10.F1
N$78  (via drill 0.61)
  Route2 0.254: v187.44,147.28 181.85,141.69 179.31,141.69 175.75,138.14 174.74,138.14 165.09,128.49 165.09,124.42 164.07,123.41 164.07,121.37 C17.H1 | v211.82,149.31 212.33,149.31 213.85,150.84 221.47,150.84 228.08,157.44 229.09,157.44 252.97,181.32 253.99,181.32 255,182.33 258.05,182.33 260.59,179.79 259.06,178.27 B10.K1
  Bottom 0.254: v187.44,147.28 188.45,148.3 210.81,148.3 v211.82,149.31
N$79
  Bottom 0.254: C14.N2 195.57,104.61 196.07,104.1 207.25,104.1 207.76,104.61 C13.N2
N$80  (via drill 0.61)
  Top 0.254: v213.85,278.35 272.78,278.35 272.78,258.03 270.24,255.49 270.24,249.39 271.26,248.37 A09.K1
  Route2 0.254: v213.85,278.35 164.58,229.07 164.58,228.05 110.73,174.21 110.73,170.65 104.63,164.55 104.63,158.46 103.62,157.44 103.62,152.87 B21.U2
N$81
  Route2 0.254: C13.M2 211.31,108.67 213.35,108.67 218.93,114.26 218.93,118.33 223.51,122.9 224.01,122.9 228.08,126.96 228.08,128.49 229.6,130.01 C12.D1
N$82  (via drill 0.61)
  Top 0.254: v162.04,109.18 162.04,115.79 160.51,117.31 C17.J1
  Route2 0.254: v162.04,109.18 169.66,116.8 170.67,116.8 202.68,148.81 202.68,152.36 v204.71,154.39
  Bottom 0.254: v204.71,154.39 205.22,153.89 205.73,153.89 208.77,150.84 241.29,150.84 242.3,149.82 B11.V1
N$83
  Route2 0.254: A09.L1 268.72,245.33 268.72,247.36 277.86,256.5 278.37,256.5 278.88,257.01 278.88,259.04 280.4,260.57 A08.E2
N$84
  Top 0.254: A10.D1 256.02,264.63 258.56,267.17 A10.C1
N$85  (via drill 0.61)
  Top 0.254: v183.88,253.45 183.88,167.09 185.41,165.57 B15.P2 | A10.B1 255,269.71 254.49,269.2 254.49,258.53 255,258.03 A10.F1
  Bottom 0.254: v183.88,253.45 183.88,256.5 254.49,256.5 255,257.01 A10.F1
N$86  (via drill 0.61)
  Route2 0.254: v203.69,173.7 189.47,159.47 185.91,159.47 B15.S2
  Bottom 0.254: v203.69,173.7 227.06,173.7 229.6,176.24 235.19,176.24 236.21,175.22 B11.L2
N$88
  Bottom 0.254: D17.S2 156.96,26.38 154.93,28.41 154.42,28.41 D17.R2
N$91
  Bottom 0.254: B09.R1 268.72,161.51 270.24,159.98 274.81,159.98 276.34,158.46 279.38,158.46 280.4,157.44 281.93,157.44 283.45,158.97 287,158.97 B08.S1
N$92
  Bottom 0.254: B09.F2 262.11,186.91 263.64,185.38 277.35,185.38 280.4,182.33 286.5,182.33 288.53,180.3 288.53,178.27 287.51,178.27 B08.K1
N$93
  Bottom 0.254: D09.E1 271.76,57.87 273.29,59.4 282.94,59.4 283.96,60.41 D08.D1 284.47,61.43 284.97,61.43 287,63.46 D08.C1
N$94
  Route15 0.254: D08.E2 280.4,57.37 277.86,54.83 D08.F2
  Bottom 0.254: D09.J2 262.11,48.73 263.13,49.75 273.29,49.75 277.35,53.81 D08.F2
N$95
  Bottom 0.254: D09.L1 268.72,42.13 269.73,43.14 276.85,43.14 281.42,47.71 283.96,47.71 D08.J1 284.47,47.71 287,45.17 D08.K1
N$96
  Top 0.254: D08.P1 287,31.97 284.47,29.43 D08.R1
  Bottom 0.254: D09.S1 271.76,26.38 272.78,27.39 282.94,27.39 283.96,28.41 D08.R1
N$97
  Bottom 0.254: B09.D1 268.72,194.02 270.24,195.54 285.99,195.54 287,196.56 B08.C1
N$99
  Route2 0.254: D09.V2 262.11,15.71 266.18,11.65 277.35,22.82 D08.T2
  Bottom 0.254: D08.U2 280.4,19.77 277.86,22.31 D08.T2
N$100
  Route2 0.254: D08.M2 280.91,38.06 278.37,35.52 D08.N2
  Bottom 0.254: D09.P2 265.67,32.47 267.19,34 276.34,34 277.35,35.01 D08.N2
N$101
  Top 0.254: 278.88,40.6 279.89,39.59 279.89,26.89 280.4,26.38 D08.S2 | 278.88,40.6 278.37,41.11 D08.L2 | 278.88,40.6 278.88,59.91 278.37,60.41 D08.D2
  Route15 0.254: C17.U1 163.56,88.86 164.07,88.86 221.98,30.95 224.52,30.95 227.06,28.41 229.09,28.41 229.6,27.9 234.68,27.9 241.79,20.79 254.49,20.79 257.54,17.74 287,17.74 289.55,15.2 291.07,15.2 292.59,16.73 284.97,24.35 282.94,24.35 281.42,25.87 D08.S2
N$103  (via drill 0.61)
  Top 0.254: D08.N1 284.47,36.03 285.99,37.55 285.99,49.75 287,50.76 D08.H1 287,51.78 285.48,53.3 285.48,65.49 284.47,66.51 D08.B1
  Route15 0.254: v264.65,87.85 264.65,86.83 272.78,78.7 274.81,78.7 282.43,71.08 282.43,69.05 283.96,67.53 D08.B1
  Bottom 0.254: v264.65,87.85 146.29,87.85 146.29,93.94 152.39,100.04 153.4,100.04 153.4,104.61 C17.N2
N$104
  Route2 0.254: C09.N2 261.61,105.12 259.57,105.12 257.54,103.09 257.54,100.55 259.06,99.02 277.86,117.82 C08.J2
N$105
  Top 0.254: A11.A1 246.37,273.27 250.94,273.27 250.94,272.25 251.45,271.74 269.73,271.74 269.73,262.6 271.26,261.07 A09.E1
N$106
  Route15 0.254: A11.B1 243.32,270.22 246.87,270.22 260.59,256.5 262.62,256.5 264.65,254.47 A09.H2
N$107  (via drill 0.61)
  Route15 0.254: v275.83,241.26 266.18,250.91 262.11,250.91 A09.J2
  Bottom 0.254: v275.83,241.26 280.4,241.26 A08.M2
N$108  (via drill 0.61)
  Route2 0.254: v242.81,109.18 242.81,109.69 247.38,114.26 247.38,115.28 249.41,117.31 C10.J2
  Route15 0.254: v163.05,100.55 157.47,106.13 157.47,108.17 C17.M2
  Bottom 0.254: v163.05,100.55 213.85,100.55 220.46,107.15 240.78,107.15 v242.81,109.18
N$109
  Bottom 0.254: C17.V1 160.51,85.81 162.04,84.29 247.38,84.29 248.91,85.81 C10.V2
N$111  (via drill 0.61)
  Top 0.254: v154.42,173.19 155.43,172.17 155.43,100.55 154.42,99.53 C17.R2
  Route2 0.254: v154.42,173.19 164.58,183.35 164.58,186.4 180.83,202.65 180.83,204.69 v192.52,216.37
  Bottom 0.254: v192.52,216.37 193.03,216.88 225.03,216.88 229.09,220.94 263.13,220.94 264.65,222.47 A09.U2
N$112  (via drill 0.61)
  Top 0.254: v284.97,177.76 285.48,178.27 285.48,185.38 284.47,186.4 284.47,186.91 B08.F1
  Route2 0.254: v284.97,177.76 282.94,175.73 282.94,175.22 278.88,171.16 278.88,167.6 271.26,159.98 270.24,159.98 265.67,155.41 265.67,152.87 B09.U2
N$113
  Route2 0.254: B09.K1 271.76,178.27 271.76,181.83 277.35,187.41 B08.F2
N$114  (via drill 0.61)
  Route2 0.254: v258.05,214.34 258.05,214.85 262.11,218.91 A09.V2
  Route15 0.254: v258.05,214.34 243.32,229.07 240.27,229.07 A11.S2
N$115
  Bottom 0.254: C17.P2 157.47,102.58 158.99,104.1 181.85,104.1 182.36,104.61 C15.N2
N$116
  Route15 0.254: C15.K2 185.91,114.26 187.44,114.26 187.95,113.75 189.98,113.75 190.99,112.74 196.07,112.74 209.28,99.53 209.28,98.51 210.3,97.5 210.3,96.48 210.81,95.97 C13.S2
N$117
  Top 0.254: 225.54,37.55 226.55,38.57 D12.M2 | 225.54,37.55 224.01,36.03 D12.N2 | 225.54,37.55 225.54,71.59 228.08,74.13 228.08,119.85 227.06,120.87 C12.H2
N$118
  Top 0.254: C11.K2 239.25,114.26 239.25,110.71 237.73,109.18 237.73,84.8 231.63,78.7 231.63,47.21 229.6,45.17 227.57,45.17 D12.K2
  Route2 0.254: D12.L2 224.01,42.13 226.55,44.67 D12.K2
N$119
  Route15 0.254: C15.F2 182.87,123.91 182.87,121.88 191.5,113.25 196.58,113.25 202.17,107.66 203.19,107.66 206.74,104.1 209.28,104.1 210.81,102.58 C13.P2
N$123
  Bottom 0.254: 135.62,254.98 138.67,251.93 140.7,251.93 A18.J2 | 135.62,254.98 134.61,255.99 130.03,255.99 129.02,257.01 AB19.AF2 | 135.62,254.98 139.69,259.04 140.7,259.04 140.7,263.61 A18.D2
N$124  (via drill 0.61)
  Top 0.254: v247.38,234.15 247.38,262.09 246.87,262.6 246.87,266.15 246.37,266.66 A11.C1
  Bottom 0.254: v247.38,234.15 247.38,231.1 257.03,231.1 258.56,229.58 A10.S1
N$125
  Bottom 0.254: A08.P1 287,235.67 285.48,237.2 257.03,237.2 256.02,238.21 A10.N1
N$126
  Route2 0.254: 139.18,257.52 140.7,259.04 142.73,259.04 144.26,260.57 A18.E2 | 139.18,257.52 136.64,254.98 132.07,254.98 AB19.AH2 | 139.18,257.52 144.26,252.44 144.26,248.37 A18.K2
N$127  (via drill 0.61)
  Top 0.254: B18.J2 140.7,181.83 140.19,182.33 140.19,193 140.7,193.51 B18.D2 141.72,194.53 142.73,195.54 142.73,222.47 v141.21,223.99
  Route15 0.254: v141.21,223.99 129.02,236.18 129.02,238.21 AB19.AN2
N$128  (via drill 0.61)
  Route15 0.254: v263.13,260.06 276.85,246.34 278.37,246.34 283.96,240.75 283.96,239.23 A08.N1
  Bottom 0.254: v263.13,260.06 260.59,262.6 239.25,262.6 238.24,263.61 236.71,263.61 A11.D2
N$129
  Bottom 0.254: C09.U2 265.67,88.86 267.19,87.34 276.85,87.34 277.35,86.83 C08.V2
N$130
  Top 0.254: 143.24,189.45 143.24,179.79 144.26,178.78 B18.K2 | 143.24,189.45 144.26,190.46 B18.E2 | 143.24,189.45 143.24,233.64 137.15,233.64 136.64,234.15 136.64,235.17 132.07,235.17 AB19.AP2
N$131  (via drill 0.61)
  Top 0.254: A20.J2 115.3,251.93 114.79,252.44 114.79,263.11 115.3,263.61 A20.D2 | v127.49,241.77 127.49,238.21 126.98,237.71 126.98,220.94 128,219.93 AB19.AV2
  Route2 0.254: v127.49,241.77 117.33,251.93 116.32,250.91 A20.J2
N$132
  Route2 0.254: A08.K1 287.51,248.37 287.51,252.44 288.53,253.45 288.53,257.01 272.78,272.76 265.67,265.65 259.06,265.65 256.02,262.6 247.89,262.6 246.37,261.07 A11.E1
N$133  (via drill 0.61)
  Top 0.254: A20.K2 118.86,248.37 117.84,249.39 117.84,259.55 118.86,260.57 A20.E2 | v126.48,238.72 126.48,196.05 128,194.53 AB19.BD2
  Route2 0.254: v126.48,238.72 118.35,246.85 119.36,247.87 A20.K2
N$134
  Top 0.254: B20.J2 115.3,181.83 114.79,182.33 114.79,193 115.3,193.51 B20.D2
  Bottom 0.254: AB19.BH2 131.56,184.37 130.03,182.84 117.33,182.84 116.32,181.83 B20.J2
N$135
  Top 0.254: B20.E2 118.86,190.46 117.84,189.45 117.84,179.79 118.86,178.78 B20.K2
  Bottom 0.254: B20.K2 119.36,178.78 120.89,180.3 127.49,180.3 128,180.81 AB19.BJ2
N$136
  Top 0.254: 101.08,262.6 101.08,263.11 100.57,263.61 A21.D2 | 101.08,262.6 101.08,252.44 100.57,251.93 A21.J2 | 101.08,262.6 107.68,269.2 107.68,271.74 116.83,271.74 123.94,264.63 123.94,169.13 128,169.13 AB19.BN2
N$137
  Top 0.254: A10.V2 249.41,219.93 250.43,220.94 250.43,260.57 247.38,263.61 247.38,268.19 246.87,268.69 243.32,268.69 243.32,264.63 A11.D1
N$138
  Route2 0.254: A10.U2 252.97,222.97 255,222.97 272.78,240.75 272.78,241.77 277.35,246.34 278.88,246.34 283.45,241.77 271.26,229.58 A09.S1
N$139
  Bottom 0.254: A10.T2 249.41,226.53 251.45,228.56 251.95,228.56 A10.S2
N$140  (via drill 0.61)
  Top 0.254: A21.E2 102.6,260.57 102.09,260.06 102.09,248.88 102.6,248.37 A21.K2 103.62,247.87 104.63,246.85 v104.63,193.51
  Route15 0.254: v104.63,193.51 115.3,182.84 116.83,182.84 131.56,168.11 131.56,166.08 AB19.BP2
N$142
  Bottom 0.254: C09.R1 268.72,99.02 275.83,99.02 278.37,101.56 280.4,101.56 C08.P2
N$146
  Bottom 0.254: C09.D1 268.72,130.01 276.34,130.01 276.85,129.5 285.48,129.5 287,127.98 C08.E1
N$147  (via drill 0.61)
  Route15 0.254: v271.26,112.74 262.11,121.88 262.11,123.91 C09.F2
  Bottom 0.254: v271.26,112.74 283.45,112.74 283.96,112.23 C08.L1
N$148
  Route15 0.254: C08.S1 287,95.97 287,99.53 271.76,114.77 C09.K1
N$150
  Top 0.254: D16.S2 173.21,25.36 178.8,25.36 D16.S1
N$151
  Route2 0.254: D16.V2 169.66,16.73 163.56,22.82 169.66,28.92 D16.R2
N$153
  Top 0.254: A10.J2 249.41,251.93 249.41,257.01 A10.F2
N$155  (via drill 0.61)
  Route15 0.254: v212.84,123.41 219.44,116.8 220.97,116.8 v225.54,112.23
  Bottom 0.254: v212.84,123.41 210.81,125.44 200.14,125.44 198.61,126.96 C14.E2 | v225.54,112.23 227.57,110.2 253.99,110.2 255,111.21 C10.L1
N$161
  Top 0.254: A11.F1 242.3,258.03 241.79,258.53 241.79,268.19 242.81,269.2 247.89,269.2 247.89,267.68 253.99,261.58 253.99,257.52 254.49,257.01 254.49,248.37 264.65,238.21 264.65,235.67 A09.P2
N$162
  Top 0.254: A12.D1 229.6,264.63 229.6,269.71 A12.B1
  Route15 0.254: A11.H1 245.86,254.98 245.86,257.01 237.73,265.14 231.63,265.14 230.62,264.12 A12.D1
N$185
  Bottom 0.254: C14.C1 205.22,133.57 206.23,132.55 214.36,132.55 214.87,133.06 215.89,133.06 216.9,132.04 256.53,132.04 258.56,130.01 258.56,127.98 C10.E1
N$193  (via drill 0.61)
  Route15 0.254: v223.51,96.99 219.95,100.55 216.9,100.55 201.66,115.79 201.66,117.31 C14.J1
  Bottom 0.254: v223.51,96.99 257.54,96.99 258.56,95.97 C10.S1
NC  (59 unrouted)
PAR  (via drill 0.61)
  Route15 0.254: v154.93,216.37 154.42,216.37 v140.7,230.09
  Bottom 0.254: v154.93,216.37 170.17,216.37 171.69,214.85 201.66,214.85 202.68,215.86 223.51,215.86 224.01,215.35 299.71,215.35 299.71,220.94 299.2,221.45 288.53,221.45 287.51,222.47 A08.U1 | v140.7,230.09 140.19,230.59 59.42,230.59 55.36,226.53 52.82,226.53 A25.T1
PAR\  (via drill 0.61)
  Route15 0.254: B04.M1 340.85,172.17 340.85,174.21 332.22,182.84 331.2,182.84 289.04,225.01 289.04,227.04 287.51,228.56 A08.S1 | v259.57,230.59 233.67,256.5 233.67,260.57 A12.E1
  Bottom 0.254: v259.57,230.59 285.99,230.59 287,229.58 A08.S1
PC+ES
  Top 0.254: A11.H2 239.25,254.98 235.19,254.98 235.19,265.14 233.67,266.66 A12.C1
PC+ES\
  Top 0.254: B11.R2 236.71,162.52 237.73,163.54 237.73,216.37 237.22,216.88 237.22,217.89 237.73,218.4 237.73,249.9 236.71,250.91 A11.J2
PWR_CLR\  (via drill 0.61)
  Top 0.254: A10.H2 252.97,253.96 253.48,253.45 253.48,242.79 252.97,242.28 A10.M2 252.97,241.26 253.99,240.25 253.99,203.67 257.03,200.62 257.03,186.4 v256.53,185.89 | v180.83,272.76 180.83,272.25 105.14,272.25 82.79,249.9 82.79,243.29 83.8,242.28 A23.M1 | v236.71,78.19 239.25,80.73 239.25,88.86 C11.U2 | v305.8,124.42 305.29,123.91 305.29,103.09 305.8,102.58 C06.P2
  Route2 0.254: 306.31,104.1 306.31,102.58 C06.P2 | 306.31,104.1 311.9,109.69 318.5,109.69 321.55,112.74 323.58,112.74 325.11,114.26 C05.K1 | v280.91,80.73 285.99,85.81 288.02,85.81 306.31,104.1
  Route15 0.254: A10.H2 251.95,254.47 250.43,254.47 235.19,269.71 235.19,271.74 233.67,273.27 A12.A1 | v236.71,78.19 244.33,70.57 245.86,70.57 D11.A1 | v216.9,81.24 201.66,96.48 201.66,98.51 C14.R1 | v305.8,124.42 280.91,149.31 280.91,152.36 B08.U2 280.4,152.87 278.88,154.39 278.88,156.43 278.37,156.93 277.86,156.93 269.73,165.06 269.73,169.13 263.64,175.22 263.64,176.24 256.53,183.35 v256.53,185.89
  Bottom 0.254: v180.83,272.76 181.34,272.25 232.14,272.25 233.16,273.27 A12.A1 | v216.9,81.24 217.41,80.73 234.17,80.73 v236.71,78.19 239.25,80.73 v280.91,80.73
RD+WD  (via drill 0.61)
  Top 0.254: v277.86,164.05 277.86,168.11 B08.N2 | v270.24,216.88 270.24,234.15 271.26,235.17 A09.P1
  Route2 0.254: v283.96,157.95 266.69,140.68 266.69,139.15 230.11,102.58 230.11,99.53 C12.R1 | v270.24,216.88 269.73,216.88 249.92,197.07 v249.41,197.07
  Route15 0.254: v283.96,157.95 v277.86,164.05 | v249.41,197.07 249.41,196.56 277.35,168.62 B08.N2
  Bottom 0.254: v249.41,197.07 248.4,197.07 246.87,195.54 242.3,195.54 239.25,192.49 225.03,192.49 224.01,193.51 B12.D2
RD_EN  (via drill 0.61)
  Route2 0.254: v242.81,113.75 236.71,107.66 236.71,105.63 C11.N2
  Route15 0.254: v242.81,113.75 242.81,117.31 C11.J1
RD_EN_LPB_00-02  (via drill 0.61)
  Top 0.254: D09.R1 268.72,29.43 270.24,30.95 270.24,43.65 271.26,44.67 D09.K1 271.76,45.17 272.78,46.19 272.78,60.41 268.72,60.41 D09.D1
  Route2 0.254: 221.47,105.12 245.35,128.99 247.38,128.99 248.91,130.52 C10.D2 | 221.47,105.12 218.93,102.58 218.93,101.56 210.3,92.93 208.27,92.93 C13.T2 | v221.98,104.61 221.47,105.12
  Route15 0.254: v221.98,104.61 265.67,60.92 267.7,60.92 D09.D1
RD_EN_LPB_03-05
  Top 0.254: D09.U2 264.65,19.77 263.64,20.79 263.64,33.49 262.11,35.01 D09.N2 262.11,36.03 262.11,37.55 266.18,41.62 266.18,50.25 265.67,50.76 D09.H2
  Route15 0.254: D09.H2 264.65,51.27 260.59,51.27 259.06,52.79 255,52.79 227.57,80.23 226.55,80.23 225.54,81.24 223.51,81.24 209.79,94.96 209.79,96.99 208.27,98.51 C13.R2
  Bottom 0.254: C13.R2 208.27,99.53 208.77,100.04 248.4,100.04 248.91,99.53 C10.R2
RDD_00  (via drill 0.61)
  Top 0.254: v260.59,102.07 260.59,55.84 261.61,54.83 D09.F2
  Route2 0.254: D09.F2 262.11,54.83 264.65,54.83 269.73,59.91 269.73,61.94 271.26,63.46 D09.C1 | v260.59,102.07 261.1,102.07 266.18,107.15 266.18,112.74 271.76,118.33 271.76,119.34 272.78,120.36 272.78,121.88 v277.35,126.45 | v254.49,160.49 254.49,163.03 261.1,169.63 263.13,169.63 264.65,171.16 B09.M2
  Route15 0.254: v109.2,214.85 103.62,220.43 103.62,222.47 A21.U2 | v223,214.85 224.01,214.85 244.33,194.53 244.33,190.46 258.05,176.75 262.11,176.75 263.13,175.73 263.13,174.21 265.16,172.17 B09.M2 | v277.35,126.45 277.35,128.99 276.34,130.01 276.34,137.63 274.31,139.66 274.31,140.68 v254.49,160.49
  Bottom 0.254: v109.2,214.85 109.71,214.34 212.33,214.34 212.84,214.85 v223,214.85
RDD_01  (via drill 0.61)
  Top 0.254: D09.M2 265.67,39.08 267.19,40.6 267.19,47.21 267.7,47.71 D09.J1 | v271.26,162.01 271.26,165.06 B09.P1
  Route2 0.254: v251.95,144.23 252.97,145.25 255,145.25 265.16,155.41 265.16,155.92 v271.26,162.01 | v300.72,85.81 272.78,57.87 272.78,56.86 268.21,52.29 268.21,48.73 D09.J1
  Route15 0.254: v300.72,85.81 300.72,86.32 292.59,94.45 292.59,98.51 288.53,102.58 288.53,103.09 276.34,115.28 276.34,116.29 275.83,116.8 275.83,120.87 266.69,130.01 266.69,130.52 264.65,132.55 264.15,132.55 253.48,143.22 252.97,143.22 v251.95,144.23
  Bottom 0.254: v251.95,144.23 119.36,144.23 119.36,152.36 B20.U2
RDD_02  (via drill 0.61)
  Top 0.254: v152.39,21.81 120.89,53.3 120.89,220.94 119.36,222.47 A20.U2
  Route2 0.254: D09.P1 271.26,31.97 269.73,30.44 267.7,30.44 262.11,24.85 262.11,23.33 D09.T2 261.61,22.31 257.54,22.31 253.48,18.25 205.73,18.25 202.68,15.2 158.99,15.2 v152.39,21.81
  Route15 0.254: v218.93,217.89 218.93,215.86 v242.81,191.99
  Bottom 0.254: v218.93,217.89 159.5,217.89 156.45,220.94 120.89,220.94 119.36,222.47 A20.U2 | v242.81,191.99 263.64,191.99 264.65,190.97 B09.E2
RDMK
  Top 0.254: CD18.AS2 144.26,95.97 143.24,96.99 143.24,151.35 144.26,152.36 B18.U2
READ_ALL\
  Route15 0.254: D07.N1 296.66,36.03 294.12,36.03 276.34,53.81 276.34,55.84 251.95,80.23 251.95,87.85 250.94,88.86 250.94,93.94 247.38,97.5 247.38,105.63 246.87,106.13 246.87,107.66 246.37,108.17 C11.M1
READ_DATA  (via drill 0.61)
  Top 0.254: v249.41,108.67 247.38,110.71 247.38,119.85 246.37,120.87 C11.H1 | v202.68,166.08 v202.68,197.57
  Route2 0.254: v253.99,90.39 253.99,100.04 v255.51,101.56 | v202.68,197.57 220.97,215.86 223.51,215.86 252.46,244.82 255,244.82 A10.L1
  Route15 0.254: v253.99,90.39 272.78,71.59 272.78,70.57 275.32,68.03 275.32,65.49 290.56,50.25 290.56,48.73 D07.J2 | v255.51,101.56 255.51,102.07 249.41,108.17 v249.41,108.67 | v202.68,166.08 202.68,164.05 205.73,161 205.73,159.98 215.38,150.33 215.38,147.79 217.41,145.76 218.93,145.76 241.79,122.9 244.33,122.9 245.86,121.37 C11.H1
READ_DATA\  (via drill 0.61)
  Top 0.254: v295.64,114.77 295.64,49.75 296.66,48.73 D07.J1 | v279.89,132.04 279.38,132.55 279.38,174.21 v279.89,174.71
  Route2 0.254: v279.89,174.71 278.37,174.71 B08.L2
  Route15 0.254: v295.64,114.77 295.64,116.29 v279.89,132.04
  Bottom 0.254: B11.J2 236.71,180.81 236.71,176.75 243.83,176.75 244.33,176.24 276.34,176.24 277.35,175.22 B08.L2
RSTA\  (via drill 0.61)
  Top 0.254: v355.08,156.93 355.08,164.55 354.57,165.06 B03.P1
  Route2 0.254: 347.97,173.19 347.97,176.75 348.98,177.76 348.98,178.78 351.01,180.81 B03.J1 | 347.97,173.19 347.97,172.17 B03.M2 | B03.C1 353.55,197.07 351.52,197.07 346.44,191.99 346.44,190.46 344.41,188.43 B03.F2 | v355.08,156.93 341.87,143.73 341.87,142.2 341.36,141.69 341.36,140.68 C04.A1 | 347.97,173.19 351.01,173.19 352.54,171.67 352.54,167.6 354.06,166.08 B03.P1
  Route15 0.254: B03.F2 344.92,187.41 344.92,185.38 346.95,183.35 348.98,183.35 350.5,181.83 B03.J1
RSTB\  (via drill 0.61)
  Top 0.254: v342.38,150.84 342.88,151.35 342.88,164.05 341.87,165.06 B04.P1
  Route2 0.254: B04.C1 340.85,197.07 338.82,197.07 333.74,191.99 333.74,190.46 331.71,188.43 B04.F2 | v342.38,150.84 325.61,134.07 C05.C1 | B04.J1 338.31,180.81 338.31,177.25 336.79,175.73 336.79,173.7 335.26,172.17 B04.M2
  Route15 0.254: B04.F2 332.22,187.41 334.25,187.41 336.28,185.38 336.28,183.35 337.81,181.83 B04.J1 | B04.M2 335.26,171.67 337.3,171.67 339.33,169.63 339.33,168.11 341.36,166.08 B04.P1
SE\  (via drill 0.61)
  Top 0.254: v272.27,148.81 272.78,149.31 272.78,252.95 271.76,253.96 A09.H1
  Route2 0.254: v322.06,69.05 321.55,69.05 308.34,55.84 308.34,51.27 300.72,43.65 298.69,43.65 297.17,42.13 D07.L1
  Route15 0.254: v272.27,148.81 272.27,146.27 292.09,126.45 292.09,125.95 303.77,114.26 303.77,113.25 316.98,100.04 316.98,94.45 317.49,93.94 317.49,89.88 317.99,89.37 317.99,83.27 319.52,81.75 319.52,71.59 v322.06,69.05
SEARCH  (via drill 0.61)
  Route2 0.254: v299.71,65.49 294.12,59.91 294.12,57.87 D07.E2
  Route15 0.254: v299.71,65.49 299.71,68.03 305.29,73.62 278.88,100.04 277.86,100.04 267.19,110.71 267.19,114.26 263.13,118.33 263.13,118.83 262.62,119.34 256.53,119.34 253.48,122.39 248.4,122.39 240.27,130.52 236.71,130.52 C11.D2
SEARCH\  (via drill 0.61)
  Top 0.254: v296.15,132.55 295.64,132.04 295.64,116.8 298.18,114.26 298.18,107.66 299.2,106.64 299.2,103.59 298.69,103.09 298.69,101.05 301.74,98.01 301.74,85.31 301.23,84.8 301.23,58.89 300.21,57.87 D07.E1 | v306.82,147.28 305.29,148.81 305.29,162.01 v306.31,163.03
  Route2 0.254: v296.15,132.55 296.15,133.06 297.17,134.07 297.17,135.09 306.82,144.74 v306.82,147.28 | v306.31,163.03 313.93,170.65 313.93,171.67 315.96,173.7 316.47,173.7 316.98,174.21 316.98,175.73 319.01,177.76 B05.K2
  Bottom 0.254: B11.K2 240.27,177.76 240.78,177.25 244.33,177.25 244.84,176.75 314.94,176.75 315.96,177.76 318.5,177.76 B05.K2
SEL  (via drill 0.61)
  Route2 0.254: v119.87,281.9 68.56,230.59 65.01,230.59 63.99,229.58 55.87,229.58 A25.S1
  Route15 0.254: v250.94,283.43 272.78,261.58 272.78,260.57 276.85,256.5 278.37,256.5 280.4,254.47 A08.H2
  Bottom 0.254: v119.87,281.9 121.4,283.43 v250.94,283.43
SEL\
  Route2 0.254: A09.N2 262.11,239.23 265.67,239.23 277.35,250.91 A08.J2
  Route15 0.254: B04.H1 340.85,184.87 340.85,186.91 332.22,195.54 330.19,195.54 280.91,244.82 280.91,245.83 279.89,246.85 279.89,248.88 277.86,250.91 A08.J2
SH_DTB  (via drill 0.61)
  Top 0.254: C09.S2 265.67,95.97 267.19,97.5 267.19,104.1 267.7,104.61 C09.N1 267.7,105.63 267.19,106.13 267.19,138.14 | 266.18,159.98 267.19,161 267.19,167.6 267.7,168.11 B09.N1 | 266.18,159.98 265.67,159.47 B09.S2 | 267.19,138.14 267.7,137.63 C09.B1 | 267.19,138.14 267.19,151.85 266.18,152.87 266.18,159.98 | B10.E1 259.06,190.97 261.61,193.51 B09.D2 | v247.89,218.4 247.89,230.59 248.91,231.61 A10.R2
  Route2 0.254: C09.H1 271.26,120.87 271.26,118.83 265.67,113.25 263.13,113.25 262.11,112.23 C09.L2 | B09.L2 262.11,175.22 262.11,176.75 267.7,182.33 269.73,182.33 271.26,183.86 B09.H1 | B09.B1 268.21,199.61 268.21,198.08 265.67,195.54 263.64,195.54 262.11,194.02 B09.D2
  Route15 0.254: C09.D2 262.11,130.01 262.11,128.49 267.7,122.9 269.73,122.9 271.26,121.37 C09.H1 | C09.L2 262.11,111.21 262.11,109.18 264.15,107.15 265.67,107.15 267.7,105.12 C09.N1 | v247.89,218.4 252.46,218.4 266.69,204.18 266.69,202.15 268.21,200.62 B09.B1 | B09.H1 271.26,184.87 271.26,186.4 265.67,191.99 263.64,191.99 262.11,193.51 B09.D2 | B09.N1 267.7,168.62 266.18,168.62 263.64,171.16 263.64,172.68 262.11,174.21 B09.L2
SH_EN  (via drill 0.61)
  Top 0.254: A11.N2 236.21,239.23 234.68,240.75 234.68,255.49 229.6,260.57 227.57,260.57 A12.E2 | 257.54,126.45 256.02,124.93 C10.F1 | 257.54,126.45 257.54,138.65 258.56,139.66 C10.A1 259.06,140.68 v259.06,150.84 | 257.54,126.45 257.54,109.69 258.56,108.67 C10.M1
  Route2 0.254: v283.96,178.78 283.96,177.76 280.91,174.71 280.91,174.21 276.34,169.63 276.34,168.11 271.26,163.03 270.75,163.03 269.23,161.51 269.23,161 v259.06,150.84
  Route15 0.254: v283.96,178.78 272.78,189.95 272.78,197.57 267.19,203.16 267.19,204.69 261.1,210.78 261.1,213.83 257.54,217.39 257.54,220.94 252.97,225.51 252.97,226.02 240.78,238.21 236.71,238.21 A11.N2
SH_EN\  (via drill 0.61)
  Top 0.254: 260.08,132.55 259.06,133.57 C10.C1 | 260.08,132.55 260.08,103.59 259.06,102.58 C10.P1 | 260.08,132.55 263.13,135.6 263.13,144.74 262.62,145.25 262.62,147.79 263.13,148.3 263.13,163.54 v260.59,166.08
  Route2 0.254: A12.V2 224.01,219.93 224.01,223.99 237.73,237.71 237.73,239.23 239.76,241.26 A11.M2
  Route15 0.254: C10.P1 258.56,102.58 258.56,106.64 257.54,107.66 257.54,115.28 255.51,117.31 C10.J1 | v260.59,166.08 260.59,166.59 260.08,167.09 260.08,168.11 256.53,171.67 256.53,172.17 251.95,176.75 251.45,176.75 225.54,202.65 225.54,206.21 221.98,209.77 221.98,211.8 218.43,215.35 218.43,216.88 217.92,217.39 217.92,218.4 221.47,221.96 223.51,219.93 A12.V2
SH_ST  (via drill 0.61)
  Top 0.254: v164.07,125.95 164.58,126.45 164.58,139.15 164.07,139.66 C17.A1
  Route2 0.254: v164.07,125.95 151.37,113.25 151.37,108.67 CD18.AM1
SH_ST-B
  Route2 0.254: CD18.BC1 150.86,64.48 150.86,68.03 151.88,69.05 151.88,72.61 174.23,94.96 174.23,100.55 173.21,101.56 C16.P2
SHIFT_CK
  Route2 0.254: CD18.BR2 141.21,29.43 141.21,33.49 135.11,39.59 142.73,47.21 142.73,56.35 122.92,76.16 159.5,112.74 161.02,112.74 163.05,114.77 C17.K1
SKP_RQ\  (via drill 0.61)
  Route15 0.254: v279.89,227.55 317.99,189.45 320.53,189.45 322.06,187.92 B05.F1
  Bottom 0.254: v279.89,227.55 258.05,227.55 255,230.59 239.25,230.59 238.75,230.09 234.17,230.09 233.67,229.58 A12.S1
SP_DY\
  Top 0.254: D14.F2 196.07,54.83 197.09,55.84 197.09,107.15 198.11,108.17 C14.M2
ST_BLK_MK  (via drill 0.61)
  Top 0.254: v41.64,205.7 41.64,246.85 42.66,247.87 A26.K1
  Route2 0.254: v199.63,118.33 208.27,126.96 210.81,126.96 C13.E2 | v165.09,116.8 162.55,116.8 150.86,105.12 149.34,105.12 144.77,100.55 143.24,100.55 141.72,99.02 CD18.AR2
  Route15 0.254: v41.64,205.7 41.64,202.65 54.85,189.45 55.87,189.45 110.73,134.58 110.73,131.53 139.18,103.09 139.18,101.56 141.21,99.53 CD18.AR2
  Bottom 0.254: v199.63,118.33 198.11,116.8 v165.09,116.8
ST_BLK_MK\  (via drill 0.61)
  Top 0.254: v262.11,172.68 263.64,174.21 263.64,230.59 271.26,238.21 271.26,241.26 A09.M1
  Route2 0.254: v262.11,172.68 218.43,128.99 216.9,128.99 210.81,122.9 209.28,122.9 208.27,123.91 C13.F2
  Route15 0.254: A09.D2 262.11,263.61 262.11,259.55 272.78,248.88 272.78,245.83 276.85,241.77 276.85,240.75 274.81,238.72 271.76,241.77 A09.M1
ST_CK  (via drill 0.61)
  Top 0.254: D17.P2 156.96,32.47 154.42,35.01 D17.N2 154.42,35.52 156.96,38.06 D17.M2 | v219.95,121.37 219.95,229.07 v215.89,233.13
  Route2 0.254: CD18.BR1 147.81,29.43 147.81,31.46 149.85,33.49 151.37,33.49 153.4,35.52 D17.N2 | D17.M2 157.47,39.08 158.99,40.6 158.99,42.63 168.64,52.29 168.64,55.33 171.69,58.38 171.69,71.59 213.35,113.25 213.35,115.79 214.36,116.8 214.36,117.31 C13.J1 214.87,117.82 216.39,117.82 v219.95,121.37
  Bottom 0.254: 212.33,236.69 243.32,236.69 243.83,237.2 256.02,237.2 257.54,235.67 258.56,235.67 A10.P1 | 212.33,236.69 44.18,236.69 43.16,235.67 A26.P1 | 212.33,236.69 v215.89,233.13
ST_CK\  (via drill 0.61)
  Route15 0.254: v188.45,114.77 176.26,126.96 173.21,126.96 C16.E2
  Bottom 0.254: v188.45,114.77 189.98,113.25 215.89,113.25 216.9,114.26 C13.K1
ST_CK_0P  (via drill 0.61)
  Top 0.254: v209.79,162.01 209.79,149.82 213.85,145.76 213.85,137.63 C13.B1
  Route2 0.254: v209.79,162.01 218.93,171.16 218.93,171.67 226.55,179.29 226.55,183.86 B12.H2
  Route15 0.254: C12.S1 232.65,95.97 232.65,100.55 231.63,101.56 231.63,110.2 233.67,112.23 231.63,114.26 231.63,117.82 231.12,118.33 231.12,118.83 224.52,125.44 223.51,125.44 216.39,132.55 216.39,134.58 214.36,136.61 C13.B1
ST_CK_0P\  (via drill 0.61)
  Top 0.254: v209.28,102.07 209.79,102.58 209.79,109.69 211.31,111.21 211.31,112.23 209.79,113.75 209.79,117.31 212.33,119.85 212.33,122.39 211.82,122.9 211.82,125.95 212.33,126.45 212.33,136.61 v211.82,137.12
  Route2 0.254: v209.28,102.07 206.23,99.02 206.23,94.96 174.23,62.95 174.23,56.86 165.09,47.71 165.09,44.16 164.58,43.65 164.07,43.65 156.96,36.54 153.91,39.59 153.91,41.11 D17.L2 | v211.82,137.12 212.33,137.12 213.35,138.14 214.87,138.14 216.9,140.17 C13.A1
ST_DATA  (via drill 0.61)
  Top 0.254: v204.71,205.7 206.23,204.18 206.23,148.3 209.79,144.74 209.79,125.44 210.81,124.42 210.81,121.37 C13.H2
  Bottom 0.254: C16.J2 170.17,118.33 171.18,119.34 218.43,119.34 218.93,119.85 218.93,122.39 216.39,122.39 215.38,121.37 211.31,121.37 C13.H2 | v204.71,205.7 205.22,205.19 217.92,205.19 220.97,202.15 232.14,202.15 233.16,203.16 B12.A1
ST_FINAL  (via drill 0.61)
  Top 0.254: v249.92,211.29 250.43,210.78 250.43,172.68 250.94,172.17 250.94,169.13 253.48,166.59 253.48,155.92 250.43,152.87 250.43,144.23 247.38,141.19 v247.38,137.12
  Route2 0.254: v221.47,112.74 239.25,130.52 240.78,130.52 | 240.78,130.52 242.3,130.52 C11.D1 | v249.92,211.29 265.16,226.53 265.16,228.56 A09.S2 | 240.78,130.52 v247.38,137.12 | v31.99,164.55 34.53,167.09 34.53,223.99 38.59,228.05 38.59,233.13 39.61,234.15 39.61,238.21 A26.N1 | v210.3,111.72 183.37,84.8 182.36,84.8 143.24,45.68 143.24,44.67 142.23,43.65 142.23,42.63 141.72,42.13 CD18.BL2
  Route15 0.254: v31.99,164.55 31.99,153.38 56.88,128.49 56.88,126.96 99.05,84.8 100.57,84.8 139.18,46.19 139.18,44.16 141.21,42.13 CD18.BL2 | v210.3,111.72 213.85,111.72 C13.L1
  Bottom 0.254: v221.47,112.74 220.97,112.23 214.87,112.23 C13.L1
ST_FINAL\  (via drill 0.61)
  Route15 0.254: v189.47,107.66 173.21,123.91 170.17,123.91 C16.F2
  Bottom 0.254: C11.M2 239.25,108.67 238.24,109.69 225.54,109.69 225.03,109.18 218.43,109.18 217.92,108.67 C13.M1 216.9,108.17 215.89,107.15 189.98,107.15 v189.47,107.66
ST_IDLE  (via drill 0.61)
  Route2 0.254: v35.04,166.08 35.04,223.48 39.61,228.05 39.61,231.61 A26.R1 | v204.71,118.33 204.71,117.82 199.63,112.74 199.63,111.72 190.99,103.09 190.99,99.02 176.77,84.8 174.23,84.8 155.43,66 154.42,66 150.86,62.45 143.24,62.45 141.72,60.92 CD18.BD2
  Route15 0.254: v35.04,166.08 35.04,165.06 51.8,148.3 52.82,148.3 110.73,90.39 110.73,89.37 137.65,62.45 139.18,62.45 140.7,60.92 CD18.BD2 | v204.71,118.33 207.76,115.28 210.81,115.28 C13.K2
ST_IDLE\  (via drill 0.61)
  Top 0.254: v208.27,116.29 208.27,112.23 C13.L2 | v262.11,171.16 260.08,171.16 260.08,172.68 259.57,173.19 259.57,175.22 263.13,178.78 263.13,231.1 267.7,235.67 267.7,238.21 A09.N1 268.72,239.23 269.73,240.25 269.73,260.57 265.67,260.57 A09.E2
  Route2 0.254: v208.27,116.29 218.93,126.96 218.93,128.49 261.61,171.16 v262.11,171.16
ST_REV_CK  (via drill 0.61)
  Top 0.254: C11.A1 245.86,140.68 245.35,141.19 245.35,150.84 244.84,151.35 244.84,157.44 245.86,158.46 B11.S1 | D12.F2 223.51,54.83 221.47,56.86 221.47,58.89 220.97,59.4 219.95,59.4 219.95,85.81 220.46,86.32 220.46,90.39 216.39,94.45 216.39,111.72 218.93,114.26 218.93,117.31 215.89,120.36 215.89,128.99 214.87,130.01 C13.D1
  Route2 0.254: v193.53,24.35 223.51,54.32 D12.F2 | B11.S1 245.86,158.46 241.29,158.46 231.12,148.3 229.6,148.3 214.36,133.06 214.36,131.03 C13.D1
  Route15 0.254: v193.53,24.35 156.45,24.35 154.93,25.87 151.37,25.87 CD18.BS1 | v95.49,246.85 96,246.85 108.7,234.15 111.75,234.15 162.55,183.35 164.07,183.35 212.33,135.09 212.33,132.55 213.85,131.03 C13.D1
  Bottom 0.254: D12.H2 226.55,51.78 224.52,53.81 224.01,53.81 D12.F2 | v95.49,246.85 41.64,246.85 40.12,245.33 A26.L1
SWTM  (via drill 0.61)
  Route2 0.254: B06.P2 305.8,165.06 304.79,164.05 304.79,159.98 v293.1,148.3 276.34,131.53 276.34,130.01 253.48,107.15 250.94,107.15 249.41,105.63 C10.N2
  Route15 0.254: v293.1,148.3 291.58,149.82 291.58,150.84 284.97,157.44 284.97,158.46 272.78,170.65 272.78,172.17 244.84,200.11 243.32,200.11 B11.B1 | v212.84,110.2 v220.46,102.58 | v138.16,110.71 110.73,138.14 110.73,141.19 55.87,196.05 54.85,196.05 33.51,217.39 33.51,218.91 A26.V2
  Bottom 0.254: v293.1,148.3 284.97,148.3 284.47,148.81 B08.V1 | C10.N2 248.91,104.61 246.37,104.61 242.3,100.55 228.08,100.55 227.06,101.56 C12.P2 226.05,102.58 v220.46,102.58 | 190.49,110.2 189.47,111.21 C15.L1 | 190.49,110.2 v212.84,110.2 | v138.16,110.71 138.67,110.2 190.49,110.2
SWTM\
  Route2 0.254: C10.L2 249.41,112.23 253.99,112.23 271.76,130.01 273.29,130.01 293.1,149.82 293.61,149.82 301.23,157.44 301.23,159.47 303.26,161.51 B06.R2
SYNC  (via drill 0.61)
  Top 0.254: v166.1,124.42 166.1,123.91 163.56,123.91 155.94,116.29 155.94,78.7 152.89,75.65 152.89,50.76 146.29,44.16 146.29,36.03 141.72,36.03 CD18.BN2
  Route2 0.254: v166.1,124.42 210.3,168.62 210.3,169.13 210.81,169.63 211.82,169.63 v217.41,175.22 | v221.47,170.65 222.49,170.65 241.79,189.95 243.32,189.95 245.35,191.99 247.38,191.99 248.91,193.51 B10.D2
  Route15 0.254: v217.41,175.22 217.41,174.71 v221.47,170.65 | B10.E2 251.95,190.97 249.41,193.51 B10.D2
SYNC-P\  (via drill 0.61)
  Top 0.254: v215.38,183.35 215.38,201.64 216.9,203.16 B13.A1
  Bottom 0.254: 215.38,182.33 239.25,182.33 241.79,179.79 247.89,179.79 248.91,180.81 B10.J2 | 215.38,182.33 211.31,182.33 211.31,178.27 B13.K2 | 215.38,182.33 v215.38,183.35
SYNC_EN  (via drill 0.61)
  Top 0.254: v149.34,147.79 149.34,52.79 150.35,51.78 CD18.BH1
  Route2 0.254: v149.34,147.79 v167.62,166.08
  Bottom 0.254: v167.62,166.08 168.64,167.09 198.11,167.09 203.69,172.68 224.01,172.68 226.55,170.14 238.24,170.14 239.25,171.16 B11.M2
T3
  Route15 0.254: C17.S1 164.07,95.47 164.07,94.96 183.88,75.15 184.9,75.15 216.39,43.65 219.95,43.65 226.55,37.05 228.08,37.05 229.6,35.52 D12.N1 230.62,35.01 233.16,32.47 D12.P1
T_00\
  Top 0.254: A24.V2 62.47,218.91 63.48,217.89 63.48,163.03 74.15,152.36 74.15,149.82 B23.V2
  Route2 0.254: B23.V2 75.17,149.31 80.76,143.73 86.85,149.82 B22.V2
T_01\
  Route2 0.254: B23.M2 77.71,172.17 77.71,176.24 58.91,195.03 66.53,202.65 66.53,208.75 82.28,224.5 82.28,227.04 83.8,228.56 A23.S1
  Route15 0.254: A24.M2 65.52,241.77 69.07,241.77 79.74,231.1 82.28,231.1 83.8,229.58 A23.S1
T_02\
  Top 0.254: B23.N2 75.17,168.11 75.68,167.6 75.68,161 73.14,161 73.14,166.59 66.53,173.19 66.53,231.61 62.47,235.67 62.47,238.21 A24.N2
  Route2 0.254: A24.N2 61.96,239.23 61.96,240.75 73.64,252.44 75.17,252.44 77.2,254.47 A23.H2
T_03\  (via drill 0.61)
  Top 0.254: v68.56,179.29 67.04,179.29 67.04,233.64 65.52,235.17 A24.P2
  Route2 0.254: A24.P2 65.52,235.67 65.52,240.25 72.63,247.36 72.63,249.39 74.15,250.91 A23.J2 | v68.56,179.29 68.06,178.78 77.2,169.63 77.2,165.57 B23.P2
T_04\
  Top 0.254: B23.R2 74.15,162.52 73.64,163.03 73.64,167.09 73.14,167.6 73.14,237.2 74.15,238.21 A23.N2
  Route2 0.254: A24.R2 62.47,232.12 66.03,232.12 70.6,236.69 72.63,236.69 74.15,238.21 A23.N2
T_05\
  Top 0.254: B23.S2 77.2,159.47 76.19,160.49 76.19,234.15 77.2,235.17 A23.P2
  Route2 0.254: A24.S2 65.52,229.07 69.58,229.07 74.15,233.64 75.68,233.64 77.2,235.17 A23.P2
T_06\
  Route2 0.254: B23.T2 74.15,155.92 74.15,160.49 57.39,177.25 57.39,200.62 75.68,218.91 75.68,220.94 77.2,222.47 A23.U2
  Bottom 0.254: A24.T2 62.47,225.51 63.99,223.99 76.19,223.99 77.2,222.97 A23.U2
T_07\
  Top 0.254: B23.U2 77.2,152.87 75.68,154.39 75.68,157.44 63.99,169.13 63.99,221.96 64.5,222.47 A24.U2
  Route15 0.254: A24.U2 65.52,222.47 69.58,222.47 70.6,221.45 72.63,221.45 74.15,219.93 A23.V2
T_FWD\
  Top 0.254: B23.H2 77.2,183.86 76.69,183.35 76.69,176.75 85.33,176.75 85.33,246.85 84.31,247.87 A23.K1
  Route15 0.254: A24.E2 65.52,260.57 68.06,260.57 77.71,250.91 79.23,250.91 80.25,249.9 82.28,249.9 83.8,248.37 A23.K1
T_GO\  (via drill 0.61)
  Top 0.254: v59.42,210.78 59.93,211.29 59.93,264.12 62.47,266.66 64.5,266.66 A24.C2
  Route15 0.254: v59.42,210.78 74.15,196.05 74.15,194.02 B23.D2 | A23.D1 80.76,264.63 75.68,264.63 75.17,265.14 67.55,265.14 65.52,267.17 A24.C2
T_PWR_CLR\  (via drill 0.61)
  Top 0.254: B23.K2 78.22,178.27 79.74,179.79 79.74,196.56 82.28,199.1 82.28,230.59 81.27,231.61 A23.R1 80.76,232.63 80.76,235.17 74.66,241.26 74.66,242.28 v74.15,242.79
  Route15 0.254: v74.15,242.79 65.01,251.93 65.01,253.96 A24.H2
T_REV\  (via drill 0.61)
  Top 0.254: v82.79,193.51 82.79,242.28 82.28,242.79 | 82.28,242.79 81.27,243.8 81.27,244.31 A23.L1 | 82.28,242.79 82.28,252.95 70.6,252.95 67.04,256.5 67.04,257.01 62.47,257.01 A24.F2
  Route2 0.254: v82.79,193.51 75.17,185.89 75.17,181.32 B23.J2
T_SINGLE_UNIT\
  Route2 0.254: B21.T2 99.55,155.41 95.49,155.41 94.47,154.39 74.15,154.39 56.88,171.67 56.88,219.42 47.23,229.07 61.96,243.8 62.47,243.8 62.98,244.31 62.98,246.34 64.5,247.87 A24.K2
T_STOP\  (via drill 0.61)
  Top 0.254: v62.47,204.18 60.44,206.21 60.44,262.6 61.45,263.61 A24.D2
  Route15 0.254: v62.47,204.18 75.68,190.97 77.2,190.97 B23.E2 | A23.E1 83.8,261.07 79.74,261.07 78.72,262.09 64.5,262.09 62.47,264.12 A24.D2
T_TRK  (via drill 0.61)
  Top 0.254: D14.U1 204.71,19.77 204.71,25.36 D14.S1 204.71,26.38 204.71,28.92 200.65,32.98 200.65,40.09 187.44,53.3 187.44,98.51 182.87,98.51 C15.R2 | v179.82,192.49 180.83,191.48 180.83,100.55 v179.82,99.53
  Route2 0.254: v179.82,99.53 182.36,99.53 C15.R2
  Route15 0.254: v179.82,192.49 156.96,215.35 154.42,215.35 147.31,222.47 144.77,222.47 A18.U2
  Bottom 0.254: v179.82,192.49 181.34,190.97 185.41,190.97 B15.E2
T_TRK\  (via drill 0.61)
  Route15 0.254: v169.66,215.35 189.98,195.03 189.98,192.49 191.5,190.97 B15.E1
  Bottom 0.254: v169.66,215.35 145.27,215.35 141.72,218.91 A18.V2
T_WRITE_OK\  (via drill 0.61)
  Top 0.254: v72.12,176.24 70.09,176.24 70.09,234.15 62.47,241.77 62.47,244.31 A24.L2
  Route2 0.254: v76.19,243.8 77.71,243.8 86.34,252.44 87.87,252.44 89.9,254.47 A22.H2 | v72.12,176.24 72.63,176.75 74.15,175.22 B23.L2
  Bottom 0.254: v76.19,243.8 62.98,243.8 62.47,244.31 A24.L2
TIM  (via drill 0.61)
  Route2 0.254: v84.31,227.55 125.97,227.55 v136.64,238.21
  Bottom 0.254: v84.31,227.55 60.44,227.55 55.87,222.97 A25.U1 | v136.64,238.21 141.72,243.29 252.97,243.29 253.48,242.79 253.48,240.75 255.51,240.75 261.1,246.34 282.94,246.34 283.96,245.33 A08.L1
TIM\  (via drill 0.61)
  Top 0.254: v326.63,170.14 326.63,186.91 324.09,189.45 324.09,207.23 v322.56,208.75
  Route15 0.254: v322.56,208.75 291.58,239.74 289.04,239.74 287.51,241.26 A08.M1
  Bottom 0.254: A08.M1 287,242.28 285.48,243.8 262.62,243.8 262.11,244.31 A09.L2 | v326.63,170.14 336.79,170.14 337.81,169.13 B04.N1
TM_EN
  Top 0.254: B18.R2 140.7,163.03 139.69,164.05 139.69,230.59 140.7,231.61 A18.R2
  Route2 0.254: C16.R2 169.66,99.53 169.66,100.55 175.75,106.64 177.28,106.64 178.8,108.17 C16.M1
  Route15 0.254: C15.S1 191.5,95.97 189.98,95.97 181.34,104.61 181.34,106.64 179.82,108.17 C16.M1 178.8,108.67 177.28,108.67 168.64,117.31 168.64,118.83 163.05,124.42 163.05,125.95 158.99,130.01 158.99,136.11 155.94,139.15 155.94,143.22 148.32,150.84 148.32,153.38 143.24,158.46 143.24,160.49 141.72,162.01 B18.R2
  Bottom 0.254: C13.N1 213.85,105.63 212.84,106.64 181.34,106.64 179.82,108.17 C16.M1
TM_EN\  (via drill 0.61)
  Top 0.254: D15.K2 185.41,45.17 182.87,47.71 D15.J2 182.87,48.73 184.39,50.25 v184.39,71.59 181.34,74.64 181.34,192.49 182.36,193.51 B15.D2 | v223.51,126.96 225.54,124.93 225.54,115.79 226.05,115.28 C12.K2
  Route2 0.254: C12.K2 226.55,114.26 226.55,111.72 217.41,102.58 C13.P1 216.9,102.07 214.87,100.04 213.35,100.04 184.9,71.59 v184.39,71.59 | v223.51,126.96 229.6,133.06 231.12,133.06 231.63,133.57 232.65,133.57 C12.C1
  Bottom 0.254: B15.D2 182.87,193.51 188.45,193.51 B15.D1
TP00  (via drill 0.61)
  Top 0.254: B10.N1 255,168.62 253.48,170.14 253.48,183.35 252.97,183.86 B10.H2 | v189.98,127.47 190.49,127.98 190.49,179.79 189.47,180.81 B15.J1 | v190.99,185.89 190.99,226.02 187.44,229.58 187.44,243.29 188.45,244.31 A15.L1
  Route2 0.254: A08.B1 283.96,269.71 283.96,266.15 308.34,241.77 300.21,233.64 300.21,233.13 285.48,218.4 282.43,218.4 253.48,189.45 250.94,189.45 249.41,187.92 B10.F2 | A15.L1 188.45,244.82 185.91,244.82 178.29,237.2 174.74,237.2 173.21,235.67 A16.P2 | v190.99,185.89 189.47,184.37 189.47,181.32 B15.J1 | v189.98,127.47 191.5,127.47 C15.E1 | B13.B1 214.36,199.61 214.36,198.08 211.82,195.54 209.79,195.54 208.27,194.02 B13.D2
  Route15 0.254: B10.F2 249.41,186.91 251.95,184.37 B10.H2 | A16.P2 172.71,235.67 170.17,238.21 A16.N2 | B13.H1 216.9,184.37 215.38,184.37 212.84,186.91 212.84,190.97 211.82,191.99 210.81,191.99 209.79,193 208.77,193 208.27,193.51 B13.D2
  Bottom 0.254: A16.N2 170.17,239.23 172.2,241.26 172.71,241.26 A16.M2 | v190.99,185.89 197.6,192.49 206.74,192.49 207.76,193.51 B13.D2 | B10.H2 251.95,184.87 251.45,185.38 218.43,185.38 217.92,184.87 B13.H1
TP00\  (via drill 0.61)
  Top 0.254: A15.E1 191.5,260.57 189.47,258.53 189.47,258.03 A15.F1 189.47,257.01 191.5,254.98 A15.H1 191.5,253.96 189.47,251.93 A15.J1 189.47,250.91 189.47,250.41 191.5,248.37 A15.K1 192.52,248.37 197.09,248.37 197.09,249.39 209.28,249.39 209.28,227.04 215.38,220.94 215.38,203.16 212.84,200.62 212.84,169.63 213.85,168.62 B13.N1
  Route2 0.254: v211.31,168.62 195.06,152.36 195.06,151.85 165.09,121.88 165.09,120.36 150.35,105.63 147.81,105.63 CD18.AN1
  Route15 0.254: v211.31,168.62 213.85,168.62 B13.N1
TP00_A  (via drill 0.61)
  Top 0.254: v233.16,167.6 229.09,163.54 229.09,161 231.63,158.46 231.63,148.81 227.57,144.74 227.57,142.71 228.08,142.2 228.08,128.99 227.06,127.98 C12.E2
  Route2 0.254: v233.16,167.6 235.7,165.06 242.81,172.17 | 242.81,172.17 252.46,181.83 253.48,181.83 254.49,182.84 257.54,182.84 258.56,183.86 B10.H1 | 242.81,172.17 v242.3,172.68
  Route15 0.254: v242.3,172.68 241.79,172.68 225.03,189.45 225.03,194.53 224.52,195.03 224.01,195.03 192.01,227.04 192.01,228.56 A15.S1
TP00_A\
  Top 0.254: A15.M1 191.5,241.26 189.47,239.23 A15.N1 189.47,238.21 191.5,236.18 191.5,235.67 A15.P1 191.5,235.17 191.5,234.66 189.47,232.63 A15.R1
  Route15 0.254: A16.L2 170.17,244.82 174.23,244.82 184.9,234.15 186.93,234.15 188.45,232.63 A15.R1
TP0_XTLK_DY\  (via drill 0.61)
  Route2 0.254: A15.F2 182.36,257.01 182.36,255.49 176.77,249.9 175.25,249.9 173.21,247.87 A16.K2
  Route15 0.254: A16.J2 170.17,250.91 172.71,248.37 A16.K2 | v210.81,231.1 210.81,231.61 186.42,255.99 184.39,255.99 182.87,257.52 A15.F2
  Bottom 0.254: v210.81,231.1 235.7,231.1 236.21,231.61 A11.R2
TP01  (via drill 0.61)
  Top 0.254: v146.29,113.75 146.29,55.84 147.31,54.83 CD18.BF1 | A15.P2 185.41,235.17 184.39,234.15 184.39,169.13 186.93,166.59 186.93,149.31 189.47,146.77 189.47,137.63 C15.B1
  Route2 0.254: v202.68,234.15 206.74,234.15 223.51,250.91 A12.J2
  Route15 0.254: B16.N2 170.17,168.11 172.71,165.57 B16.P2 173.21,165.06 173.21,161 180.83,153.38 180.83,148.3 182.36,146.77 182.36,145.76 193.03,135.09 | 193.03,135.09 v211.31,116.8 | 193.03,135.09 191.5,135.09 189.47,137.12 C15.B1
  Bottom 0.254: v202.68,234.15 186.93,234.15 185.91,235.17 A15.P2 | B16.N2 170.17,168.62 172.71,171.16 B16.M2 | v146.29,113.75 165.09,132.55 181.34,132.55 185.41,136.61 188.45,136.61 C15.B1 | v211.31,116.8 231.12,116.8 231.63,117.31 236.21,117.31 C11.J2
TP01\  (via drill 0.61)
  Top 0.254: v181.85,198.08 181.34,198.59 181.34,237.2 182.36,238.21 A15.N2
  Route2 0.254: A15.N2 182.87,238.72 185.41,241.26 A15.M2
  Route15 0.254: v181.85,198.08 204.71,175.22 207.76,175.22 B13.L2 | A15.M2 185.41,242.28 182.87,244.82 A15.L2 182.87,245.33 185.41,247.87 A15.K2
  Bottom 0.254: A15.J2 182.87,250.91 185.41,248.37 A15.K2
TP01_A  (via drill 0.61)
  Top 0.254: v187.44,126.96 187.44,110.2 185.91,108.67 C15.M2 | v222.49,183.35 222.49,180.81 220.46,178.78 220.46,167.09 222.49,165.06 222.49,156.93 223.51,155.92 B12.T2
  Route2 0.254: v187.44,126.96 210.81,150.33 212.33,150.33 213.35,151.35 219.44,151.35 223.51,155.41 B12.T2
  Route15 0.254: v222.49,183.35 186.42,219.42 182.87,219.42 A15.V2
TP01_A\  (via drill 0.61)
  Top 0.254: v168.64,209.77 168.64,176.24 169.66,175.22 B16.L2
  Route2 0.254: v168.64,209.77 180.83,221.96 180.83,223.99 182.36,225.51 A15.T2 182.87,226.02 185.41,228.56 A15.S2
  Route15 0.254: A15.U2 185.41,222.97 182.87,225.51 A15.T2
  Bottom 0.254: A15.S2 185.41,229.58 183.37,231.61 182.87,231.61 A15.R2
TP1_XTLK_DY\  (via drill 0.61)
  Route2 0.254: B16.J2 170.17,181.32 172.71,183.86 B16.H2 173.21,184.87 173.21,187.92 v201.15,215.86
  Route15 0.254: A11.V2 236.21,219.93 236.21,220.94 235.7,221.45 235.7,224.5 229.09,231.1 229.09,234.66 228.59,235.17 228.59,241.77 227.06,243.29 226.05,243.29 225.54,243.8 217.92,243.8 193.03,268.69 190.99,268.69 189.47,270.22 A15.B1
  Bottom 0.254: v201.15,215.86 201.66,216.37 229.6,216.37 232.14,218.91 236.21,218.91 A11.V2
TS03\  (via drill 0.61)
  Top 0.254: D17.K2 156.96,45.17 154.42,47.71 D17.J2
  Route2 0.254: v284.97,52.29 299.2,66.51 299.71,66.51 330.69,97.5 330.69,100.04 336.79,106.13 336.79,112.23 339.33,114.77 340.85,114.77 C04.K1
  Bottom 0.254: D17.J2 154.42,48.73 156.45,50.76 156.96,50.76 D17.H2 | v284.97,52.29 276.34,43.65 249.92,43.65 247.38,46.19 158.48,46.19 157.47,45.17 D17.K2
U+M_DY\  (via drill 0.61)
  Top 0.254: D14.E2 199.12,57.37 203.19,57.37 203.19,37.05 202.17,36.03 D14.N1 | v235.7,114.26 235.19,114.77 235.19,122.9 234.68,123.41 234.68,138.65 233.67,139.66 C12.A1
  Route2 0.254: D14.E2 199.12,57.87 200.65,59.4 202.68,59.4 221.98,78.7 221.98,93.43 225.54,96.99 224.01,98.51 C12.R2 223.51,99.53 225.54,101.56 225.54,103.09 235.7,113.25 v235.7,114.26
USR_00  (via drill 0.61)
  Top 0.254: v290.56,203.16 290.56,218.91 A07.V2 | v173.72,284.44 69.58,284.44 58.91,273.77 55.87,273.77 A25.A1
  Route15 0.254: v290.56,203.16 290.56,202.15 298.18,194.53 298.18,192.49 299.71,190.97 B07.E1 | v173.72,284.44 231.12,284.44 241.29,274.28 241.29,268.69 270.24,239.74 271.76,239.74 273.8,237.71 274.81,237.71 288.53,223.99 288.53,221.45 290.05,219.93 A07.V2
USR_00\  (via drill 0.61)
  Route2 0.254: v318.5,198.59 311.9,191.99 305.8,191.99 301.74,187.92 297.17,187.92 B07.F1
  Bottom 0.254: v318.5,198.59 322.06,202.15 352.54,202.15 353.55,203.16 B03.A1
USR_01  (via drill 0.61)
  Top 0.254: B07.H2 293.1,184.87 292.09,185.89 292.09,221.45 293.1,222.47 A07.U2 294.12,222.97 294.12,227.55 300.72,227.55 301.23,228.05 301.23,280.38 280.91,280.38 270.24,291.05 270.24,292.06 63.99,292.06 63.48,291.55 v61.45,291.55
  Route2 0.254: v61.45,291.55 52.82,282.92 52.82,270.73 A25.B1
USR_01\
  Route2 0.254: B07.J2 291.07,181.32 291.07,185.89 299.71,194.53 300.72,194.53 301.74,195.54 306.82,195.54 323.58,212.31 323.58,213.83 340.35,230.59 354.57,230.59 359.14,226.02 355.08,221.96 355.08,206.72 352.54,204.18 352.54,202.65 351.01,201.13 B03.B1
USR_02  (via drill 0.61)
  Top 0.254: B07.L1 296.66,175.22 295.64,176.24 295.64,217.89 296.66,218.91 A07.V1 | v144.26,279.36 67.55,279.36 55.87,267.68 A25.C1
  Route15 0.254: v144.26,279.36 164.07,279.36 174.23,269.2 175.25,269.2 216.9,227.55 219.95,227.55 v231.12,216.37
  Bottom 0.254: v231.12,216.37 268.21,216.37 270.24,218.4 296.15,218.4 296.66,218.91 A07.V1
USR_02\  (via drill 0.61)
  Route2 0.254: v322.06,185.38 v305.8,169.13
  Route15 0.254: v305.8,169.13 303.77,171.16 300.21,171.16 B07.M1
  Bottom 0.254: v322.06,185.38 323.07,186.4 349.49,186.4 350.5,187.41 B03.F1
UTS  (via drill 0.61)
  Top 0.254: v197.09,125.44 197.09,109.69 196.58,109.18 196.58,100.55 195.57,99.53 C14.R2 | v193.03,130.52 193.53,131.03 193.53,164.05 192.52,165.06 B15.P1 | v179.82,179.79 178.29,181.32 178.29,237.2 178.8,237.71 178.8,240.25 174.74,244.31 v174.74,270.22
  Route15 0.254: v197.09,125.44 197.09,125.95 193.03,130.01 v193.03,130.52 | v244.84,274.79 246.87,274.79 257.03,264.63 257.03,262.6 258.56,261.07 A10.E1 | v179.82,179.79 191.5,168.11 191.5,165.57 B15.P1
  Bottom 0.254: v244.84,274.79 174.74,274.79 | 174.74,274.79 76.19,274.79 66.53,265.14 38.59,265.14 38.59,256.5 39.1,256.5 39.1,251.93 A26.J1 | 174.74,274.79 v174.74,270.22
UTS\  (via drill 0.61)
  Top 0.254: C16.F1 175.75,124.93 175.75,130.01 C16.D1
  Route2 0.254: C16.H1 178.8,120.87 176.26,118.33 C16.J1 | C16.D1 176.26,131.03 178.8,133.57 C16.C1 | C16.A1 179.31,139.66 176.77,137.12 C16.B1 | v217.92,106.64 222.49,111.21 223,111.21 C12.L2
  Route15 0.254: C16.J1 176.26,117.31 178.8,114.77 C16.K1 179.31,114.26 179.31,110.71 183.88,106.13 183.88,104.1 185.41,102.58 C15.P2 | C16.F1 176.26,123.91 178.8,121.37 C16.H1 | C16.B1 176.26,136.61 178.8,134.07 C16.C1
  Bottom 0.254: 197.09,103.59 186.93,103.59 185.91,102.58 C15.P2 | 197.09,103.59 198.11,102.58 C14.P2 | v217.92,106.64 214.87,103.59 197.09,103.59
VCC  (via drill 0.61)
  Top 0.635: v139.69,118.33 139.69,75.15 144.26,70.57 CD18.BA2 | A12.A2 226.55,273.27 218.93,273.27 218.93,272.25 218.43,271.74 198.61,271.74 198.61,273.27 A14.A2 | AB01.AA2 373.37,273.27 375.91,270.73 AB01.AB1 | AB01.AF1 376.41,258.03 378.95,260.57 AB01.AE1 378.95,261.07 376.41,263.61 AB01.AD1 | AB01.AJ1 376.41,250.91 378.95,248.37 AB01.AK1 378.95,247.87 376.41,245.33 AB01.AL1 376.41,244.31 377.94,242.79 377.94,214.85 373.37,210.27 373.37,204.18 AB01.BA2 373.37,203.16 375.91,200.62 AB01.BB1 376.41,200.11 378.95,197.57 AB01.BC1
  Route2 0.635: v248.4,72.61 242.3,72.61 240.27,70.57 D11.A2 | v258.56,76.16 252.97,70.57 D10.A2 | v204.71,147.28 204.71,146.77 198.61,140.68 C14.A2 | v217.92,146.77 211.82,140.68 211.31,140.68 C13.A2 | A10.A2 251.95,273.77 246.37,279.36 240.27,273.27 A11.A2 | A08.A2 280.4,273.77 273.8,273.77 269.73,277.84 265.67,273.77 A09.A2 | A16.A2 173.21,273.77 177.28,273.77 178.8,275.3 183.88,275.3 185.41,273.77 A15.A2 | v247.38,208.24 242.81,203.67 240.27,203.67 B11.A2