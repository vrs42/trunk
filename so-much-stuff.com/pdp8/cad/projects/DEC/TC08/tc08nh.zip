# EAGLE board tc08nh (EAGLE 4.11), part 5 of 5
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
VCC  (via drill 0.61) (continued)
  Route15 0.635: CD18.BA2 144.77,70.57 150.86,76.67 156.96,70.57 D17.A2 | v248.4,72.61 250.43,70.57 251.95,70.57 D10.A2 | v258.56,76.16 264.15,70.57 264.65,70.57 D09.A2 | v204.71,147.28 210.81,141.19 210.81,140.68 C13.A2 | v217.92,146.77 219.44,146.77 226.05,140.17 C12.A2 | A12.A2 227.57,273.77 233.16,279.36 239.25,273.27 A11.A2 | A14.A2 198.11,273.77 194.55,273.77 193.03,275.3 187.44,275.3 185.91,273.77 A15.A2 | v247.38,208.24 251.95,203.67 B10.A2 | CD18.AA2 144.26,140.68 144.26,142.71 118.35,168.62 118.35,170.14 114.28,174.21 114.28,177.25 91.93,199.61 91.93,202.15 90.92,203.16 B22.A2
  Bottom 0.635: 278.88,68.54 267.19,68.54 265.67,70.07 D09.A2 | 278.88,68.54 280.4,70.07 D08.A2 | 278.88,68.54 291.58,68.54 293.1,70.07 D07.A2 | 174.74,68.54 173.21,70.07 D16.A2 | 183.88,68.54 174.74,68.54 | 183.88,68.54 185.41,70.07 D15.A2 | 196.58,68.54 198.11,70.07 D14.A2 | 183.88,68.54 196.58,68.54 | 209.28,68.54 210.81,70.07 D13.A2 | 196.58,68.54 209.28,68.54 | 209.28,68.54 225.03,68.54 226.55,70.07 D12.A2 227.57,70.57 229.09,72.1 237.73,72.1 239.25,70.57 D11.A2 | 174.74,68.54 158.99,68.54 157.47,70.07 D17.A2 | 155.94,138.65 145.78,138.65 144.77,139.66 CD18.AA2 144.26,139.66 139.69,139.66 v139.69,118.33 | 155.94,138.65 156.96,139.66 C17.A2 | 171.69,138.65 172.71,139.66 C16.A2 | 155.94,138.65 171.69,138.65 | 184.39,138.65 185.41,139.66 C15.A2 | 171.69,138.65 184.39,138.65 | 184.39,138.65 193.03,138.65 193.53,139.15 197.6,139.15 198.11,139.66 C14.A2 | C12.A2 227.06,139.66 227.57,139.15 231.12,139.15 231.63,138.65 238.24,138.65 239.25,139.66 C11.A2 240.27,140.68 241.29,141.69 250.94,141.69 251.95,140.68 C10.A2 252.46,140.68 253.99,142.2 263.13,142.2 263.64,141.69 | 263.64,141.69 264.65,140.68 C09.A2 | 279.38,141.69 280.4,140.68 C08.A2 | 263.64,141.69 279.38,141.69 | 292.09,141.69 293.1,140.68 C07.A2 | 279.38,141.69 292.09,141.69 | 304.79,141.69 305.8,140.68 C06.A2 | 292.09,141.69 304.79,141.69 | 317.49,141.69 318.5,140.68 C05.A2 | 304.79,141.69 317.49,141.69 | 333.74,141.69 334.76,140.68 C04.A2 | 317.49,141.69 333.74,141.69 | 346.44,141.69 347.46,140.68 C03.A2 | 333.74,141.69 346.44,141.69 | 359.14,141.69 360.16,140.68 C02.A2 | 346.44,141.69 359.14,141.69 | 359.14,141.69 371.84,141.69 372.86,140.68 C01.A2
  Bottom 0.635: A08.A2 281.42,273.77 282.94,275.3 291.58,275.3 293.1,273.77 A07.A2 294.12,273.77 295.64,275.3 371.33,275.3 372.86,273.77 AB01.AA2 | A09.A2 264.65,273.27 263.13,271.74 254.49,271.74 252.97,273.27 A10.A2 | 88.38,271.74 79.74,271.74 78.22,273.27 A23.A2 | 88.38,271.74 89.9,273.27 A22.A2 | 88.38,271.74 98.03,271.74 99.55,273.27 102.6,273.27 A21.A2 103.62,273.27 105.14,271.74 117.33,271.74 | 117.33,271.74 118.86,273.27 A20.A2 | 142.73,271.74 144.26,273.27 A18.A2 | 142.73,271.74 117.33,271.74 | 142.73,271.74 171.18,271.74 172.71,273.27 A16.A2 | B22.A2 90.92,203.16 92.44,201.64 101.08,201.64 102.6,203.16 B21.A2 103.62,203.67 105.14,205.19 117.84,205.19 | 117.84,205.19 118.86,204.18 B20.A2 | 117.84,205.19 143.24,205.19 144.26,204.18 B18.A2 144.77,203.16 145.78,202.15 174.23,202.15 | B11.A2 239.25,203.67 237.73,205.19 229.09,205.19 227.57,203.67 B12.A2 226.55,203.67 223.51,206.72 205.73,206.72 205.22,207.23 204.2,207.23 200.14,203.16 | 174.23,202.15 174.74,201.64 183.88,201.64 | 174.23,202.15 173.21,203.16 B16.A2 | 183.88,201.64 185.41,203.16 B15.A2 | 183.88,201.64 196.58,201.64 198.11,203.16 B14.A2 198.61,203.16 200.14,203.16 | 200.14,203.16 201.66,201.64 209.28,201.64 210.81,203.16 B13.A2 | 263.13,201.64 254.49,201.64 252.97,203.16 B10.A2 | 263.13,201.64 264.65,203.16 B09.A2 | 278.88,201.64 280.4,203.16 B08.A2 | 263.13,201.64 278.88,201.64 | 291.58,201.64 293.1,203.16 B07.A2 | 278.88,201.64 291.58,201.64 | 304.28,201.64 305.8,203.16 B06.A2 | 291.58,201.64 304.28,201.64 | 304.28,201.64 316.98,201.64 318.5,203.16 B05.A2 319.52,203.67 321.04,205.19 336.28,205.19 | AB01.AD1 376.41,264.63 378.44,266.66 378.95,266.66 AB01.AC1 378.95,267.68 378.44,267.68 376.41,269.71 AB01.AB1
  Bottom 0.635: AB01.AJ1 376.41,251.93 378.44,253.96 378.95,253.96 AB01.AH1 378.95,254.98 378.44,254.98 376.41,257.01 AB01.AF1 | AB01.BE1 378.95,191.48 376.92,193.51 376.41,193.51 AB01.BD1 376.41,194.53 378.95,197.07 AB01.BC1 | 336.28,205.19 335.26,204.18 B04.A2 | 336.28,205.19 346.44,205.19 | 346.44,205.19 347.46,204.18 B03.A2 | 359.14,205.19 360.16,204.18 B02.A2 | 346.44,205.19 359.14,205.19 | 359.14,205.19 371.84,205.19 372.86,204.18 AB01.BA2
W01  (via drill 0.61)
  Route2 0.254: v114.28,132.04 114.28,77.69 142.23,49.75 141.21,48.73 CD18.BJ2
  Route15 0.254: v114.28,132.04 56.88,189.45 56.88,191.99 17.26,231.61 33.01,247.36 33.01,250.91 A26.J2
W02
  Top 0.254: A26.K2 36.05,247.87 31.48,247.87 31.48,245.33 28.43,242.28 28.43,131.53 60.44,99.53 60.44,98.01 115.3,43.14 117.33,43.14 117.33,42.63 140.7,19.27 140.7,16.73 CD18.BV2
W03  (via drill 0.61)
  Top 0.254: v36.05,176.75 35.04,177.76 35.04,242.79 33.51,244.31 A26.L2
  Route15 0.254: v36.05,176.75 36.05,174.71 56.88,153.89 56.88,150.33 110.73,96.48 110.73,93.43 142.73,61.43 142.73,59.4 144.26,57.87 CD18.BE2
W04
  Bottom 0.254: A26.M2 36.05,241.26 36.05,236.69 35.04,236.69 35.04,170.65 63.48,142.2 73.14,142.2 115.3,100.04 131.05,100.04 136.64,94.45 139.18,94.45 140.7,92.93 CD18.AT2
W05
  Top 0.254: A26.N2 33.01,238.21 28.94,238.21 28.94,137.63 60.44,106.13 60.44,103.09 114.79,48.73 114.79,46.7 141.72,19.77 144.26,19.77 CD18.BU2
W06
  Route15 0.254: A26.P2 36.05,235.17 33.01,235.17 26.4,228.56 56.88,198.08 56.88,197.07 105.65,148.3 106.67,148.3 142.73,112.23 142.73,110.2 144.26,108.67 CD18.AM2
W07
  Route15 0.254: CD18.AK2 144.26,115.28 144.26,117.31 119.87,141.69 118.35,141.69 60.44,199.61 60.44,201.64 42.66,219.42 42.66,220.94 38.59,225.01 38.59,228.56 36.56,230.59 34.53,230.59 33.51,231.61 A26.R2
W08
  Route15 0.254: CD18.AL1 147.31,111.72 144.77,111.72 117.84,138.65 117.84,139.66 54.85,202.65 54.34,202.65 35.04,221.96 35.04,227.04 36.56,228.56 A26.S2
W09  (via drill 0.61)
  Route2 0.254: v31.99,166.08 31.99,220.43 33.01,221.45 33.01,225.51 A26.T2
  Route15 0.254: v31.99,166.08 56.88,141.19 56.88,139.66 108.7,87.85 110.22,87.85 139.18,58.89 139.18,56.86 141.21,54.83 CD18.BF2
W+UTS  (via drill 0.61)
  Top 0.254: v192.52,147.28 190.99,148.81 190.99,183.35 186.93,187.41 186.93,252.95 | 186.93,252.95 185.91,253.96 A15.H2 | 186.93,252.95 186.93,264.12 189.98,267.17 189.98,271.74 191.5,273.27 A15.A1
  Route15 0.254: v192.52,147.28 198.11,141.69 199.12,141.69 209.79,131.03 209.79,126.96 211.82,124.93 211.82,122.9 220.46,114.26 220.46,112.23 224.01,108.67 226.05,108.67 C12.M2
W-INH\  (via drill 0.61)
  Top 0.254: v241.79,183.86 241.79,175.73 242.3,175.22 B11.L1
  Route2 0.254: v241.79,183.86 277.35,219.42 A08.V2
  Route15 0.254: B12.H1 233.67,183.86 233.67,181.83 238.75,176.75 240.27,176.75 242.3,174.71 B11.L1
WB00  (via drill 0.61)
  Top 0.254: v101.58,209.26 101.08,209.77 101.08,237.71 100.57,238.21 A21.N2 | v199.63,82.77 200.14,83.27 200.14,114.26 202.68,116.8 202.68,123.41 202.17,123.91 C14.F1
  Route2 0.254: v202.17,127.47 201.66,126.96 201.66,124.93 C14.F1
  Route15 0.254: 141.21,171.16 141.21,169.13 B18.N2 | 141.21,171.16 116.83,195.54 115.3,195.54 v101.58,209.26 | v182.87,132.55 173.72,141.69 170.67,141.69 141.21,171.16 | v255,82.77 267.19,70.57 271.26,70.57 D09.A1
  Bottom 0.254: A25.P2 48.75,235.17 47.74,234.15 41.64,234.15 41.64,237.2 98.54,237.2 99.55,238.21 A21.N2 | v202.17,127.47 200.65,128.99 186.42,128.99 v182.87,132.55 | v199.63,82.77 v255,82.77
WB00\  (via drill 0.61)
  Route2 0.254: v145.78,186.91 145.78,171.16 144.77,170.14 144.77,166.08 B18.P2
  Route15 0.254: A21.P2 103.62,235.17 105.14,233.64 105.14,231.61 114.79,221.96 114.79,218.4 145.78,187.41 v145.78,186.91 163.05,169.63 170.67,169.63 187.44,152.87 187.44,148.81 204.71,131.53 204.71,127.98 C14.E1
  Bottom 0.254: C14.E1 205.22,126.96 206.23,125.95 235.7,125.95 236.21,125.44 248.4,125.44 252.97,130.01 255,130.01 C10.D1
WB01  (via drill 0.61)
  Route2 0.254: v186.42,104.61 186.42,107.15 193.53,114.26 193.53,115.79 195.06,117.31 C14.J2
  Route15 0.254: v119.87,169.13 125.46,163.54 142.23,163.54 158.48,147.28 162.55,147.28 179.82,130.01 180.83,130.01 191.5,119.34 194.04,119.34 195.06,118.33 C14.J2 | A25.R2 46.21,231.61 50.78,231.61 54.85,227.55 55.87,227.55 106.16,177.25 106.67,177.25 115.3,168.62 B20.N2 | v234.17,53.3 234.17,53.81 221.98,66 221.98,69.05 v186.42,104.61
  Bottom 0.254: v119.87,169.13 116.32,169.13 B20.N2 | v234.17,53.3 267.19,53.3 267.7,53.81 D09.F1
WB01\  (via drill 0.61)
  Route15 0.254: v169.66,146.27 170.67,145.25 171.69,145.25 183.88,133.06 183.88,132.04 189.47,126.45 190.99,126.45 194.55,122.9 196.58,122.9 198.11,121.37 C14.H2 198.61,120.87 200.14,119.34 202.17,119.34 208.77,112.74 210.81,112.74 211.31,112.23 v214.36,115.28
  Bottom 0.254: v169.66,146.27 167.62,146.27 150.35,163.54 120.89,163.54 119.36,165.06 B20.P2 | v214.36,115.28 215.38,116.29 231.63,116.29 232.14,116.8 257.03,116.8 258.56,115.28 C10.K1
WB02  (via drill 0.61)
  Top 0.254: v205.73,90.89 203.69,92.93 203.69,107.66 204.2,108.17 C14.M1 | v153.4,203.67 158.48,198.59 158.48,151.85 156.96,150.33 v156.96,147.28
  Route2 0.254: A25.S2 49.77,229.07 53.33,229.07 60.95,221.45 63.48,223.99 76.69,223.99 83.3,230.59 107.17,230.59 115.3,238.72 A20.N2
  Route15 0.254: v205.73,90.89 215.89,80.73 215.89,77.69 253.48,40.09 265.16,40.09 266.18,39.08 271.26,39.08 D09.M1 | v153.4,203.67 118.86,238.21 116.32,238.21 A20.N2 | v156.96,147.28 156.96,144.74 163.05,138.65 165.59,138.65 174.74,129.5 180.33,129.5 192.52,117.31 194.04,117.31 201.15,110.2 202.68,110.2 204.2,108.67 C14.M1
WB02\  (via drill 0.61)
  Top 0.254: v123.43,135.6 123.43,235.17 119.36,235.17 A20.P2
  Route15 0.254: v238.24,113.25 241.79,113.25 242.3,112.74 243.83,112.74 253.48,103.09 253.48,101.56 255.51,99.53 C10.R1
  Bottom 0.254: 202.68,112.74 202.17,112.23 C14.L1 | 202.68,112.74 219.95,112.74 220.97,113.75 225.54,113.75 226.05,113.25 v238.24,113.25 | v123.43,135.6 123.43,133.06 143.75,112.74 202.68,112.74
WC  (via drill 0.61)
  Top 0.254: D11.S1 245.86,26.38 244.84,27.39 244.84,73.62 244.33,74.13 v244.33,145.76 244.33,168.62 244.84,169.13 244.84,176.75 245.86,177.76 B11.K1
  Route15 0.254: v157.97,149.82 142.73,165.06 141.21,165.06 111.24,195.03 108.19,195.03 101.08,202.15 96,202.15 56.88,241.26 56.88,242.79 45.7,253.96 43.16,253.96 A26.H1 | v252.46,173.7 249.92,176.24 247.89,176.24 246.37,177.76 B11.K1
  Bottom 0.254: v157.97,149.82 161.02,146.77 166.1,146.77 167.62,145.25 243.83,145.25 v244.33,145.76 | v252.46,173.7 257.03,173.7 258.56,172.17 B10.M1
WC0  (via drill 0.61)
  Route2 0.254: v328.66,107.15 329.68,107.15 338.31,115.79 339.33,115.79 v360.16,136.61
  Route15 0.254: v360.16,136.61 374.89,121.88 v374.89,121.37
  Bottom 0.254: v328.66,107.15 324.09,107.15 321.55,109.69 307.83,109.69 306.82,108.67 C06.M2 | v374.89,121.37 378.95,121.37 C01.H1
WC0\  (via drill 0.61)
  Route2 0.254: v315.45,88.35 313.42,86.32 312.91,86.32 272.78,46.19 270.75,46.19 265.16,40.6 264.15,40.6 263.64,40.09 258.05,40.09 247.38,29.43 243.32,29.43 D11.R1
  Route15 0.254: v315.45,88.35 315.45,90.89 305.29,101.05 305.29,102.58 303.26,104.61 C06.N2
WC\  (via drill 0.61)
  Top 0.254: D11.U1 245.86,19.77 244.33,21.3 244.33,31.46 240.27,35.52 240.27,38.06 D11.M2 | v220.97,62.95 220.97,89.88 223,91.91 C12.T2
  Route2 0.254: v245.35,168.11 245.35,167.09 231.12,152.87 230.11,152.87 227.57,150.33 227.57,147.79 202.68,122.9 197.6,122.9 v195.57,120.87
  Route15 0.254: v220.97,62.95 220.97,59.4 237.73,42.63 237.73,41.11 239.76,39.08 D11.M2 | v245.35,168.11 226.55,186.91 224.01,186.91 B12.F2 | v195.57,120.87 223.51,92.93 C12.T2
WR_EN  (via drill 0.61)
  Top 0.254: B20.R2 115.3,163.03 114.28,164.05 114.28,230.59 115.3,231.61 A20.R2 | D09.S2 265.67,26.38 267.19,27.9 267.19,34.51 267.7,35.01 D09.N1 268.72,36.03 269.73,37.05 269.73,49.24 271.26,50.76 D09.H1 | D09.B1 267.7,66.51 266.69,65.49 266.69,58.89 265.67,57.87 D09.E2 | C15.A1 191.5,139.66 190.99,139.15 190.99,109.18 191.5,108.67 C15.M1
  Route15 0.254: v57.9,231.1 41.13,247.87 41.13,251.93 39.61,253.45 39.61,257.01 A26.F1 | C10.U2 252.46,88.86 252.46,80.73 264.15,69.05 265.67,69.05 267.7,67.02 D09.B1 | 271.76,49.24 272.27,49.75 271.26,50.76 D09.H1 | 271.76,49.24 264.65,42.13 262.11,42.13 D09.L2 | 271.76,49.24 265.67,55.33 265.67,57.37 D09.E2 | C14.U1 204.71,89.88 204.71,92.42 201.15,95.97 201.15,97.5 194.04,104.61 194.04,106.64 192.52,108.17 C15.M1 | v239.76,129.5 247.89,121.37 251.95,121.37 C10.H2
  Bottom 0.254: 101.08,231.1 100.57,231.61 A21.R2 | 101.08,231.1 114.79,231.1 115.3,231.61 A20.R2 | 101.08,231.1 v57.9,231.1 | 193.53,141.69 199.63,141.69 199.63,138.65 199.12,138.14 197.09,138.14 197.09,132.55 200.14,129.5 215.38,129.5 215.89,130.01 223,130.01 C12.D2 224.01,130.01 224.52,129.5 v239.76,129.5 | 193.53,141.69 192.52,140.68 C15.A1 | C10.U2 251.95,89.88 250.94,90.89 207.25,90.89 206.23,89.88 205.22,89.88 C14.U1 | 193.53,141.69 117.84,141.69 117.84,156.43 116.83,157.44 116.32,157.44 116.32,162.01 B20.R2
WR_EN\  (via drill 0.61)
  Top 0.254: C15.H2 185.41,121.37 183.88,122.9 183.88,128.99 182.87,130.01 C15.D2 | v220.97,165.06 220.46,164.55 220.46,123.91 223.51,120.87 223.51,118.33 C12.J2
  Route2 0.254: C14.S1 205.22,95.97 205.22,99.53 223.51,117.82 C12.J2 | v220.97,165.06 222.49,166.59 222.49,169.13 240.78,187.41 242.3,187.41 B11.F1
  Bottom 0.254: 225.03,119.34 224.01,118.33 C12.J2 | 225.03,119.34 225.54,119.85 238.24,119.85 239.25,120.87 C11.H2 | 225.03,119.34 221.47,122.9 215.89,122.9 215.38,122.39 186.93,122.39 185.91,121.37 C15.H2
WRITE_ALL  (via drill 0.61)
  Top 0.254: v249.41,100.55 250.43,101.56 250.43,139.66 v249.92,140.17
  Route2 0.254: v236.71,189.45 249.41,202.15 253.48,202.15 276.34,225.01 276.34,226.53 278.88,229.07 280.4,229.07 A08.S2 | v249.92,140.17 249.92,143.73 251.95,145.76 253.99,145.76 257.03,148.81 257.03,150.84 v257.54,151.35
  Route15 0.254: B12.F1 230.62,187.41 232.14,187.41 244.33,175.22 244.33,173.7 245.86,172.17 B11.M1 246.37,171.16 247.89,169.63 247.89,161 v257.54,151.35 | v249.41,100.55 251.45,98.51 251.95,98.51 279.38,71.08 279.38,69.56 296.66,52.29 292.59,48.22 292.59,43.65 293.61,42.63 293.61,39.08 D07.M2
  Bottom 0.254: v236.71,189.45 236.21,188.94 231.63,188.94 230.62,187.92 B12.F1
WRITE_DATA  (via drill 0.61)
  Top 0.254: v269.73,78.19 270.24,78.7 270.24,91.91 272.78,94.45 272.78,128.49 v272.27,128.99 | v228.08,173.19 228.08,189.45 228.59,189.95 228.59,198.59 229.6,199.61 B12.B1
  Route2 0.254: B12.B1 230.62,200.62 230.62,203.16 259.06,231.61 261.1,231.61 261.61,232.12 A09.R2
  Route15 0.254: v269.73,78.19 279.38,68.54 279.38,63.46 287,55.84 289.55,55.84 290.05,55.33 290.05,54.83 D07.F2 | v272.27,128.99 237.73,163.54 235.19,163.54 233.67,165.06 B12.P1 233.16,165.57 231.63,167.09 231.63,169.13 228.08,172.68 v228.08,173.19
  Bottom 0.254: B11.R1 242.3,162.52 241.29,163.54 235.19,163.54 233.67,165.06 B12.P1
WRITE_DATA\  (via drill 0.61)
  Route2 0.254: v315.45,76.16 297.17,57.87 297.17,54.83 D07.F1 | v277.86,120.36 277.86,122.39 278.88,123.41 278.88,127.47 v301.23,149.82
  Route15 0.254: v315.45,76.16 315.45,76.67 289.04,103.09 289.04,103.59 282.43,110.2 282.43,111.72 279.89,114.26 279.89,118.33 v277.86,120.36 | v301.23,149.82 300.21,149.82 282.94,167.09 282.94,169.63 281.42,171.16 B08.M2
WRITE_OK  (via drill 0.61)
  Top 0.254: v188.45,157.44 188.45,161.51 B15.R1
  Route2 0.254: v188.45,157.44 187.95,157.44 167.12,136.61 167.12,133.57 157.47,123.91 157.47,121.37 C17.H2 | v239.76,201.13 237.73,203.16 218.93,184.37 218.93,183.86 211.82,176.75 201.66,176.75 190.99,166.08 190.99,164.55 188.96,162.52 B15.R1
  Route15 0.254: v188.45,157.44 188.45,157.95 163.56,182.84 162.04,182.84 111.24,233.64 108.19,233.64 96,245.83 94.98,245.83 88.38,252.44 88.38,258.53 87.36,259.55 87.36,263.61 A22.D2 | v239.76,201.13 243.32,197.57 245.86,197.57 B11.C1
WRITE_OK+UTS
  Top 0.254: B12.D1 230.62,193.51 232.14,191.99 232.14,179.29 233.16,178.27 B12.K1
  Route2 0.254: C17.M1 164.07,108.67 164.07,110.2 170.17,116.29 171.18,116.29 217.41,162.52 219.95,162.52 231.63,174.21 231.63,175.73 233.67,177.76 B12.K1
WRITE_OK\  (via drill 0.61)
  Top 0.254: v157.47,130.01 158.99,131.53 v158.99,220.94
  Route2 0.254: v157.47,130.01 151.88,124.42 153.91,122.39 153.91,118.33 C17.J2 | v224.01,227.55 224.01,228.05 242.3,246.34 248.4,246.34 251.45,249.39 252.97,249.39 255,251.42 A10.J1
  Bottom 0.254: v158.99,220.94 159.5,221.45 213.85,221.45 219.95,227.55 v224.01,227.55
WRTM  (via drill 0.61)
  Top 0.254: v255.51,125.95 257.03,127.47 257.03,143.22 253.99,146.27 253.99,156.93 257.03,159.98 257.03,175.22 253.99,178.27 253.99,184.87 250.94,187.92 250.94,212.31 249.41,212.31 248.91,211.8 248.91,206.21 246.37,203.67 B11.A1
  Route2 0.254: v255.51,125.95 255,125.95 250.94,121.88 250.94,116.8 252.46,115.28 C10.K2
  Route15 0.254: v247.89,106.64 247.89,98.01 273.29,72.61 273.29,71.08 275.83,68.54 275.83,66 290.56,51.27 293.1,51.27 D07.H2
  Bottom 0.254: C12.N2 224.01,105.63 225.03,106.64 v247.89,106.64 252.97,106.64 257.03,110.71 257.03,114.26 252.97,114.26 C10.K2
WRTM+FR03  (via drill 0.61)
  Route2 0.254: C12.V2 223.51,86.83 223.51,90.39 228.08,94.96 228.08,101.56 231.12,104.61 231.12,106.64 232.65,108.17 C12.M1 | v289.04,168.62 288.53,168.62 276.34,156.43 276.34,154.39 269.73,147.79 269.73,147.28 269.23,146.77 257.54,146.77 252.46,141.69 251.95,141.69 250.94,140.68 250.94,136.61 234.17,119.85 233.16,119.85 v232.14,118.83
  Route15 0.254: v289.04,168.62 288.53,168.62 281.42,175.73 281.42,177.76 B08.K2 | v232.14,118.83 232.14,117.82 234.17,115.79 234.17,109.18 233.67,108.67 C12.M1
WRTM\  (via drill 0.61)
  Top 0.254: v260.59,164.55 260.59,145.76 v261.61,144.74
  Route2 0.254: v260.59,164.55 276.34,180.3 276.34,181.83 278.88,184.37 280.4,184.37 B08.H2 | v261.61,144.74 261.61,140.17 v243.32,121.88
  Route15 0.254: D07.H1 299.71,51.78 299.71,55.33 279.38,75.65 279.38,77.69 266.69,90.39 266.69,91.91 254.49,104.1 254.49,106.64 252.97,108.17 C10.M2 251.95,108.67 250.43,110.2 250.43,112.23 243.32,119.34 v243.32,121.88
XOR_TO_LPB
  Top 0.254: C10.E2 252.97,126.96 253.48,126.45 253.48,96.48 252.97,95.97 C10.S2
  Route2 0.254: D12.P2 226.55,32.47 226.55,36.54 220.46,42.63 225.03,47.21 225.03,59.91 234.68,69.56 234.68,72.1 240.27,77.69 240.27,85.81 245.35,90.89 247.38,90.89 248.91,92.42 C10.T2 249.41,92.93 251.95,95.47 C10.S2
  Bottom 0.254: C10.F2 249.41,124.93 251.45,126.96 251.95,126.96 C10.E2
XSA_DY  (via drill 0.61)
  Top 0.254: v152.89,170.14 152.89,93.43 153.4,92.93 C17.T2 | B14.B1 201.15,199.61 199.63,198.08 199.63,182.84 196.07,179.29 195.06,179.29 195.06,175.22 B14.L2
  Route2 0.254: A08.D2 277.35,263.61 277.35,262.6 247.89,233.13 247.89,228.56 217.41,198.08 216.9,198.08 216.39,197.57 216.39,194.02 199.12,176.75 197.09,176.75 195.57,175.22 B14.L2
  Bottom 0.254: v152.89,170.14 153.4,170.65 169.66,170.65 172.71,173.7 194.55,173.7 195.06,174.21 B14.L2
XSAD  (via drill 0.61)
  Route15 0.254: v255.51,242.79 264.15,234.15 265.67,234.15 267.7,232.12 A09.R1
  Bottom 0.254: v255.51,242.79 254.49,243.8 237.22,243.8 236.71,244.31 A11.L2
XSAD\  (via drill 0.61)
  Top 0.254: v209.28,120.87 209.28,104.1 208.27,103.09 208.27,101.56 212.33,97.5 212.33,42.13 208.27,42.13 D13.L2 | v238.24,217.39 238.24,246.85 239.25,247.87 A11.K2
  Route2 0.254: v177.79,157.95 179.31,156.43 199.12,176.24 199.63,176.24 216.9,193.51 216.9,194.53 218.93,196.56 218.93,198.08 v238.24,217.39
  Route15 0.254: v209.28,120.87 203.69,126.45 203.69,131.03 193.03,141.69 191.5,141.69 186.42,146.77 186.42,149.31 v177.79,157.95
XSTA  (via drill 0.61)
  Top 0.254: D13.P2 210.81,32.47 208.27,35.01 D13.N2 | B07.L2 291.07,175.22 291.58,175.73 291.58,193 291.07,193.51 B07.D2 | C07.L2 291.07,112.23 291.58,112.74 291.58,129.5 291.07,130.01 C07.D2 | C07.B1 296.66,137.63 296.66,145.76 295.64,146.77 295.64,158.46 294.12,158.46 B07.S2 294.12,159.47 295.64,161 295.64,167.09 296.66,168.11 B07.N1 297.17,168.62 298.18,169.63 298.18,198.59 297.17,199.61 B07.B1 | v241.29,60.92 241.29,37.05 242.3,36.03 D11.N1
  Route2 0.254: B07.B1 296.66,199.61 296.66,198.08 294.12,195.54 292.59,195.54 291.07,194.02 B07.D2 | C07.B1 296.66,136.61 296.66,134.58 294.62,132.55 293.1,132.55 291.07,130.52 C07.D2 | v241.29,60.92 241.29,61.43 270.75,90.89 271.76,90.89 288.53,107.66 288.53,109.69 290.05,111.21 C07.L2
  Route15 0.254: B07.H1 300.21,184.87 300.21,186.4 294.62,191.99 292.59,191.99 291.07,193.51 B07.D2 | C07.H1 299.71,121.37 297.67,121.37 292.59,126.45 292.59,127.98 290.56,130.01 C07.D2
  Bottom 0.254: 209.28,37.05 210.3,38.06 210.81,38.06 D13.M2 | 209.28,37.05 208.27,36.03 D13.N2 | 209.28,37.05 237.22,37.05 238.24,36.03 242.3,36.03 D11.N1 | C04.F1 337.81,123.91 333.74,123.91 332.73,122.9 301.74,122.9 300.21,121.37 C07.H1
XSTA\  (via drill 0.61)
  Top 0.254: D13.K2 210.81,45.17 208.27,47.71 D13.J2 208.27,48.22 210.81,50.76 D13.H2
  Route2 0.254: D14.L2 196.07,42.13 196.07,42.63 198.11,44.67 D14.K2 199.12,45.17 200.65,46.7 202.68,46.7 203.69,47.71 207.76,47.71 D13.J2 | v274.31,55.84 275.83,55.84 310.88,90.89 310.88,96.48 320.03,105.63 320.03,107.15 326.63,113.75 326.63,114.77 329.68,117.82 329.68,118.83 334.76,123.91 335.77,123.91 337.3,125.44 338.82,125.44 340.85,127.47 C04.E1
  Route15 0.254: v306.82,167.09 307.32,167.09 314.44,159.98 314.44,158.97 316.98,156.43 316.98,154.39 317.49,153.89 317.49,151.85 328.15,141.19 328.66,141.19 329.17,140.68 329.17,136.11 331.2,134.07 332.22,134.07 335.26,131.03 335.77,131.03 337.3,129.5 338.82,129.5 340.85,127.47 C04.E1
  Bottom 0.254: D16.N2 170.17,36.03 172.2,38.06 172.71,38.06 D16.M2 173.21,39.08 174.74,40.6 194.55,40.6 195.06,41.11 D14.L2 | v306.82,167.09 299.2,167.09 296.15,164.05 279.89,164.05 278.37,162.52 B08.R2 | v274.31,55.84 211.31,55.84 211.31,51.78 D13.H2

## Text on the board
Top: 1 | A
Bottom: A
tPlace: 28 | 27 | 26 | 25 | 24 | 23 | 22 | 21 | 20 | 19 | 18 | 17 | 16 | 15 | 14 | 13 | 12 | 11 | 10 | 9 | 8 | 7 | 6 | 5 | 4 | 3 | 2 | 1 | Rip Up NC | Add Holes? | Fix G821 connections | Fold in ECOs. | A | B | C | D
bPlace: A | B | C | D | 28 | 27 | 26 | 25 | 24 | 23 | 22 | 21 | 20 | 19 | 18 | 17 | 16 | 15 | 14 | 13 | 12 | 11 | 10 | 9 | 8 | 7 | 6 | 5 | 4 | 3 | 2 | 1