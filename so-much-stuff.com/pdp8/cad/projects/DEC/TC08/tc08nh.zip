# EAGLE board tc08nh (EAGLE 4.11), part 3 of 5
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
I/O_BAC_11  (via drill 0.61) (continued)
  Route2 0.254: v340.35,99.02 345.93,104.61 345.93,106.64 347.46,108.17 C03.M2 | v317.99,230.59 330.19,242.79 330.19,245.33 338.82,253.96 338.82,254.98 341.87,258.03 346.95,252.95 348.47,252.95 354.06,258.53 357.62,254.98 360.16,254.98 A02.H2 | v331.71,165.57 331.2,165.57 v326.12,160.49 | v347.46,131.53 341.87,125.95 v341.36,125.95
  Route15 0.254: v340.35,73.62 360.16,53.81 360.16,51.78 D02.H2 | v320.03,181.32 320.03,179.79 328.15,171.67 328.15,169.13 v331.71,165.57 | v326.12,160.49 327.65,160.49 329.68,158.46 329.68,156.43 328.15,154.9 329.17,153.89 329.68,153.89 342.38,141.19 342.38,136.61 v347.46,131.53
I/O_BMB_00  (via drill 0.61)
  Top 0.254: v350.5,84.29 350.5,67.53 D03.B1 | v370.32,164.05 368.79,165.57 368.79,171.16 371.33,173.7 371.33,201.13 369.81,202.65 369.81,213.83 371.33,215.35 371.33,258.53 368.79,261.07 368.79,265.14 353.55,265.14 352.54,266.15 352.54,268.19 351.01,269.71 A03.B1
  Route2 0.254: v350.5,84.29 351.01,84.29 352.03,85.31 352.03,89.37 v383.02,120.36 | v375.91,153.38 375.91,151.35 374.89,150.33 374.89,148.81 366.76,140.68 C02.A1
  Route15 0.254: v366.76,136.61 v383.02,120.36 | v370.32,164.05 371.33,163.03 371.33,157.95 v375.91,153.38
  Bottom 0.254: v366.76,136.61 366.76,139.66 C02.A1
I/O_BMB_01  (via drill 0.61)
  Top 0.254: 349.49,127.47 349.49,62.45 350.5,61.43 D03.D1 | 349.49,127.47 v350,127.98 | 349.49,127.47 349.49,262.6 350.5,263.61 A03.D1
  Route2 0.254: v350,127.98 v353.05,131.03
  Bottom 0.254: v353.05,131.03 354.06,132.04 362.19,132.04 363.21,131.03 C02.D1
I/O_BMB_02  (via drill 0.61)
  Top 0.254: v380.48,59.4 380.99,59.91 v380.99,103.09 | v372.35,233.64 371.84,233.13 371.84,169.13 371.33,168.62 371.33,126.45 377.94,119.85 v377.94,108.67
  Route2 0.254: v377.94,108.67 v376.41,107.15
  Route15 0.254: 376.41,107.66 365.75,118.33 365.75,119.85 365.24,120.36 365.24,122.39 363.71,123.91 C02.F1 | 376.41,107.66 v380.99,103.09 | v372.35,233.64 355.08,250.91 355.08,254.98 354.57,255.49 354.57,260.57 A03.E1 | v376.41,107.15 376.41,107.66
  Bottom 0.254: v380.48,59.4 356.09,59.4 354.57,57.87 D03.E1
I/O_BMB_03  (via drill 0.61)
  Top 0.254: D03.J1 351.01,48.73 352.03,49.75 v352.03,119.85 352.03,132.55 | 352.03,132.55 352.03,138.14 351.52,138.65 351.52,140.17 352.03,140.68 352.03,249.9 351.01,250.91 A03.J1 | 352.03,132.55 v351.52,132.55
  Bottom 0.254: C05.D2 316.47,130.01 316.98,129.5 326.63,129.5 327.14,130.01 331.2,130.01 C04.D2 332.22,131.03 333.74,132.55 v351.52,132.55 | v352.03,119.85 361.68,119.85 363.21,118.33 C02.J1
I/O_BMB_03\  (via drill 0.61)
  Top 0.254: v383.02,176.75 383.53,177.25 383.53,209.77 385.05,211.29 v385.05,226.02
  Route2 0.254: v378.95,80.23 374.38,75.65 374.38,69.56 356.09,51.27 354.57,51.27 D03.H1 | v341.36,128.99 341.36,130.52 366.76,155.92 367.78,155.92 370.32,158.46 370.32,160.49 380.48,170.65 380.48,174.21 v383.02,176.75 | v385.05,226.02 355.59,255.49 354.57,254.47 A03.H1
  Route15 0.254: v378.95,80.23 378.95,87.34 368.79,97.5 368.79,101.56 364.73,105.63 364.73,106.13 358.12,112.74 354.06,112.74 343.39,123.41 343.39,126.96 v341.36,128.99
I/O_BMB_04  (via drill 0.61)
  Top 0.254: v384.54,207.73 386.57,205.7 386.57,119.85 v385.56,118.83
  Route2 0.254: v383.53,76.16 380.48,73.11 380.48,69.05 354.06,42.63 354.06,39.08 D03.M1 | v385.56,118.83 v369.81,103.09
  Route15 0.254: v383.53,76.16 383.53,89.37 v369.81,103.09 365.24,107.66 365.24,109.69 363.71,111.21 C02.L1 | v384.54,207.73 354.06,238.21 354.06,241.26 A03.M1 | v354.06,110.71 337.81,126.96 335.26,126.96 C04.E2
  Bottom 0.254: C05.E2 319.52,127.98 320.53,128.99 326.12,128.99 327.14,127.98 334.76,127.98 C04.E2 | v354.06,110.71 354.57,110.2 362.19,110.2 363.21,111.21 C02.L1
I/O_BMB_04\  (via drill 0.61)
  Top 0.254: v274.31,134.07 v274.31,96.99
  Route2 0.254: v274.31,134.07 274.31,136.61 289.04,151.35 289.04,152.87 v290.05,153.89 | v268.72,178.78 268.72,179.79 272.78,183.86 272.78,186.91 290.05,204.18 292.09,204.18 303.77,215.86 315.45,215.86 317.49,217.89 318.5,217.89 324.6,223.99 326.63,223.99 346.95,244.31 350,244.31 350.5,244.82 A03.L1
  Route15 0.254: v329.68,40.09 329.68,50.25 318.5,61.43 317.49,61.43 313.42,65.49 303.77,65.49 300.21,61.94 298.69,63.46 298.69,68.54 298.18,69.05 298.18,70.57 283.96,84.8 283.45,84.8 276.34,91.91 276.34,94.96 v274.31,96.99 | v290.05,153.89 290.05,154.39 279.89,164.55 279.89,168.11 271.26,176.75 270.75,176.75 v268.72,178.78
  Bottom 0.254: v329.68,40.09 349.49,40.09 350.5,41.11 D03.L1
I/O_BMB_05  (via drill 0.61)
  Top 0.254: v385.56,200.11 386.06,199.61 386.06,124.93 v385.56,124.42
  Route2 0.254: v384.54,71.08 367.78,54.32 367.78,50.25 355.08,37.55 355.08,30.95 354.06,29.93 354.06,26.38 D03.S1 | v385.56,124.42 368.29,107.15 365.24,107.15 363.71,105.63 C02.N1
  Route15 0.254: v384.54,71.08 384.54,73.11 377.94,79.72 377.94,87.34 368.29,96.99 368.29,98.51 365.24,101.56 | 365.24,101.56 365.24,103.09 363.71,104.61 C02.N1 | v385.56,200.11 356.6,229.07 354.57,229.07 A03.S1 | 365.24,101.56 354.57,112.23 353.55,112.23 335.26,130.52 333.74,128.99 333.74,126.45 336.28,123.91 336.28,120.36 335.77,119.85 334.25,119.85 332.22,121.88 332.22,123.91 C04.F2
  Bottom 0.254: C05.F2 316.47,124.93 316.98,125.44 330.69,125.44 331.2,124.93 C04.F2
I/O_BMB_05\
  Top 0.254: D03.P1 353.55,32.47 352.54,33.49 352.54,85.31 355.08,87.85 355.08,149.31 352.54,151.85 352.54,234.15 353.55,235.17 A03.P1
I/O_BMB_06  (via drill 0.61)
  Top 0.254: v343.39,203.16 343.9,203.67 343.9,211.29 343.39,211.8 343.39,227.04 345.93,229.58 345.93,259.04 347.46,260.57 A03.E2 | v329.68,171.16 329.68,156.43 328.15,154.9 328.15,144.74 329.68,143.22 v329.68,126.96
  Route2 0.254: v373.37,87.34 338.31,52.29 340.85,49.75 341.87,49.75 347.46,55.33 347.46,57.37 D03.E2 | v343.39,203.16 343.39,188.94 339.33,184.87 339.33,184.37 337.81,182.84 337.3,182.84 330.69,176.24 330.69,172.17 v329.68,171.16
  Route15 0.254: v373.37,87.34 372.86,87.34 365.24,94.96 365.24,96.99 363.71,98.51 C02.R1 | v329.68,126.96 v329.68,121.88 | v360.16,99.02 346.95,112.23 346.44,112.23 v337.81,120.87
  Bottom 0.254: 329.68,122.39 333.74,122.39 334.76,121.37 C04.H2 335.26,120.87 v337.81,120.87 | 329.68,122.39 320.53,122.39 319.52,121.37 C05.H2 | v329.68,121.88 329.68,122.39 | v360.16,99.02 363.21,99.02 C02.R1
I/O_BMB_06\  (via drill 0.61)
  Top 0.254: v277.35,78.19 277.35,83.27 278.88,84.8 278.88,120.87 275.83,123.91 275.83,139.66 v275.32,140.17 | v280.4,145.25 279.89,145.76 279.89,173.19 280.91,174.21 280.91,175.73 279.89,176.75 v279.89,181.32
  Route2 0.254: v280.4,82.77 279.38,82.77 277.35,80.73 v277.35,78.19 | v280.4,145.25 v275.32,140.17 | v271.76,188.94 272.78,189.95 272.78,191.48 324.6,243.29 326.12,243.29 342.38,259.55 342.38,261.58 344.41,263.61 A03.D2
  Route15 0.254: v316.98,59.4 301.74,59.4 292.09,69.05 292.09,71.08 v280.4,82.77 | v279.89,181.32 279.38,181.32 v271.76,188.94
  Bottom 0.254: v316.98,59.4 323.07,59.4 325.61,61.94 343.39,61.94 343.9,61.43 D03.D2
I/O_BMB_07  (via drill 0.61)
  Top 0.254: 348.98,72.61 348.98,46.19 347.97,45.17 D03.K2 | 348.98,72.61 v348.47,73.11 | 348.98,144.23 348.98,72.61 | 348.98,144.23 348.98,246.85 347.97,247.87 A03.K2 | 348.98,144.23 v347.46,144.23
  Route2 0.254: v348.47,73.11 350.5,73.11 363.21,85.81 C02.V1 | v347.46,144.23 347.46,143.73 331.71,127.98 329.17,127.98 319.01,117.82 316.47,117.82 C05.J2
  Bottom 0.254: C05.J2 316.47,117.31 320.53,117.31 321.04,116.8 330.69,116.8 331.2,117.31 C04.J2
I/O_BMB_07\  (via drill 0.61)
  Top 0.254: v238.75,37.05 235.19,40.6 235.19,72.61 241.29,78.7 241.29,120.36 240.78,120.87 v240.78,138.65 | v246.37,145.76 247.89,147.28 v247.89,195.03
  Route2 0.254: v240.78,138.65 240.78,139.15 241.29,139.66 241.29,140.68 v246.37,145.76 | v273.8,198.59 273.8,199.61 323.58,249.39 327.65,249.39 343.39,265.14 345.93,265.14 351.01,260.06 349.49,258.53 349.49,256.5 347.97,254.98 A03.H2
  Bottom 0.254: v238.75,37.05 240.27,37.05 243.32,40.09 326.12,40.09 335.77,49.75 346.44,49.75 347.46,50.76 D03.H2 | v247.89,195.03 248.4,195.54 267.7,195.54 270.75,198.59 v273.8,198.59
I/O_BMB_08  (via drill 0.61)
  Top 0.254: 346.44,112.74 v346.95,113.25 | 346.44,112.74 346.44,33.49 347.46,32.47 D03.P2 | 346.44,128.99 346.44,112.74 | 346.44,128.99 346.44,234.15 347.46,235.17 A03.P2 | 346.44,128.99 v347.46,128.99
  Bottom 0.254: v346.95,113.25 320.53,113.25 319.52,114.26 C05.K2 | v347.46,128.99 359.14,128.99 360.16,127.98 C02.E2
I/O_BMB_08\  (via drill 0.61)
  Top 0.254: v327.14,65.49 327.65,66 327.65,94.96 326.63,95.97 326.63,110.71 v326.12,111.21 | v377.43,212.31 381.49,208.24 381.49,144.74 v378.44,141.69 | v357.11,120.87 358.63,119.34 358.63,98.01 v357.62,96.99
  Route2 0.254: v326.12,111.21 326.12,111.72 v328.66,114.26 | v377.43,212.31 378.44,213.32 350.5,241.26 347.97,241.26 A03.M2 | v378.44,141.69 377.94,141.69 v357.11,120.87 | v357.62,96.99 331.2,70.57 331.2,69.56 v327.14,65.49
  Route15 0.254: v327.14,65.49 330.69,61.94 330.69,59.4 347.46,42.63 347.46,39.08 D03.M2
  Bottom 0.254: v328.66,114.26 334.76,114.26 C04.K2
I/O_BMB_09  (via drill 0.61)
  Top 0.254: v377.94,201.13 380.99,201.13 380.99,145.76 v379.46,144.23
  Route2 0.254: v379.46,144.23 357.11,121.88 356.6,121.88 356.09,121.37 356.09,120.36 356.6,119.85 358.63,119.85 360.16,121.37 C02.H2
  Route15 0.254: v385.56,81.24 385.56,81.75 384.03,83.27 384.03,93.43 383.02,94.45 383.02,95.47 365.75,112.74 365.75,113.75 362.19,117.31 362.19,119.34 360.67,120.87 C02.H2 | v377.94,201.13 350.5,228.56 347.97,228.56 A03.S2
  Bottom 0.254: v385.56,81.24 385.56,54.83 361.68,30.95 347.97,30.95 347.97,26.38 D03.S2
I/O_BMB_10  (via drill 0.61)
  Top 0.254: 345.93,108.17 345.93,24.35 344.92,23.33 D03.T2 | 345.93,108.17 v345.43,108.67 | 345.93,108.17 345.93,224.5 344.92,225.51 A03.T2
  Route2 0.254: v345.43,108.67 345.93,108.67 350,112.74 353.55,112.74 355.08,114.26 355.08,117.82 356.6,119.34 359.14,119.34 359.65,119.85 360.67,119.85 362.19,118.33 362.19,116.8 360.67,115.28 C02.K2
I/O_BMB_11  (via drill 0.61)
  Top 0.254: D03.V2 343.9,16.73 342.88,17.74 342.88,106.13 v343.39,106.64 343.39,201.64 344.41,202.65 344.41,218.91 A03.V2
  Bottom 0.254: v343.39,106.64 343.9,107.15 356.09,107.15 357.11,108.17 360.16,108.17 C02.M2
I/O_BRK_RQ\  (via drill 0.61)
  Top 0.254: v329.17,58.38 330.19,59.4 330.19,74.64 330.69,75.15 330.69,83.78 330.19,84.29 330.19,119.85 328.66,121.37 328.66,135.09 325.11,138.65 324.09,138.65 324.09,188.43 322.56,189.95 322.56,193.51 B05.D1 322.06,194.02 322.06,196.05 323.58,197.57 323.58,201.13 321.55,203.16 321.55,209.26 323.58,211.29 323.58,233.64 317.99,239.23 317.99,247.36 318.5,247.87 A05.K2
  Route2 0.254: v329.17,58.38 319.01,48.22 319.01,45.17 D05.K2
I/O_BWC0\  (via drill 0.61)
  Top 0.254: 304.79,61.43 304.79,234.15 305.8,235.17 A06.P2 | 304.79,61.43 304.79,33.49 305.8,32.47 D06.P2 | 304.79,61.43 v306.31,61.43
  Route2 0.254: v306.31,61.43 314.94,70.07 314.94,71.59 324.09,80.73 325.11,80.73 329.17,84.8 332.73,84.8 342.38,94.45 342.38,94.96 350.5,103.09 351.01,103.09 366.25,118.33 367.27,118.33 375.4,126.45 375.4,128.99 375.91,129.5 376.92,129.5 377.43,128.99 377.43,127.98 376.92,127.47 376.92,125.95 376.41,125.44 376.41,124.93 C01.F1
I/O_DATA_IN  (via drill 0.61)
  Top 0.254: v327.14,51.27 327.65,51.78 327.65,64.48 328.15,64.99 328.15,95.47 327.14,96.48 327.14,127.98 326.63,128.49 326.63,131.03 327.14,131.53 v327.14,134.07 | v316.47,176.75 316.47,180.81 B05.J2 | v326.12,193.51 328.66,196.05 328.66,229.58 321.04,237.2 321.04,239.74 319.52,241.26 A05.M2
  Route2 0.254: v327.14,51.27 319.01,43.14 319.01,39.08 D05.M2 | v327.14,134.07 327.14,134.58 341.87,149.31 v342.38,149.31 | v326.12,193.51 317.99,185.38 317.99,182.84 316.47,181.32 B05.J2
  Route15 0.254: v342.38,149.31 330.69,161 330.69,162.52 v316.47,176.75
I/O_INT_RQ\  (via drill 0.61)
  Top 0.254: v327.65,229.07 327.65,196.56 325.11,194.02 325.11,190.97 B05.E1 | v336.79,45.17 336.79,40.6 335.26,39.08 D04.M2 | v319.01,87.34 317.99,88.35 317.99,118.33 v318.5,118.83
  Route2 0.254: v327.65,229.07 327.65,232.12 333.23,237.71 333.23,239.74 334.76,241.26 A04.M2 | v306.82,131.03 306.82,131.53 325.11,149.82 326.12,149.82 v329.17,152.87 | v315.45,163.54 315.45,164.55 316.98,166.08 316.98,167.6 323.58,174.21 323.58,179.29 324.09,179.79 324.09,180.81 326.63,183.35 326.63,189.45 325.61,190.46 B05.E1
  Route15 0.254: v336.79,45.17 336.79,52.29 330.19,58.89 330.19,60.92 326.12,64.99 326.12,67.02 323.58,69.56 323.58,82.77 v319.01,87.34 | v318.5,118.83 318.5,119.34 v306.82,131.03
  Bottom 0.254: v329.17,152.87 330.69,154.39 330.69,163.54 v315.45,163.54
I/O_PWR_CLR  (via drill 0.61)
  Top 0.254: 356.09,126.45 v356.6,125.95 | 356.09,126.45 356.09,218.4 356.6,218.91 A02.V2 | 356.09,126.45 356.09,73.62 355.59,73.11 355.59,17.74 356.6,16.73 D02.V2
  Route2 0.254: v356.6,125.95 v350.5,119.85
  Bottom 0.254: v350.5,119.85 326.63,119.85 325.61,120.87 C05.H1
I/O_SKP_RQ\  (via drill 0.61)
  Top 0.254: v334.76,176.75 336.28,176.75 | 336.28,176.75 336.28,246.85 335.26,247.87 A04.K2 | 336.28,176.75 336.28,46.19 335.26,45.17 D04.K2
  Bottom 0.254: v334.76,176.75 334.25,176.75 333.74,177.25 326.12,177.25 325.61,177.76 B05.K1
I/O_TS03  (via drill 0.61)
  Route2 0.254: v384.03,169.13 386.57,166.59 386.57,126.96 v382.51,122.9 | v385.56,113.25 385.56,110.71 v365.75,90.89
  Route15 0.254: 364.22,89.37 359.14,94.45 359.14,99.02 348.47,109.69 344.41,109.69 336.79,117.31 336.79,121.37 338.31,122.9 339.33,122.9 340.85,121.37 C04.H1 | 364.22,89.37 386.57,67.02 386.57,43.65 367.27,24.35 366.25,24.35 365.24,25.36 360.67,25.36 D02.S2 | v356.09,221.45 356.09,218.91 365.75,209.26 365.75,208.24 374.89,199.1 374.89,198.08 380.99,191.99 380.99,175.22 384.03,172.17 v384.03,169.13 | v382.51,122.9 382.51,122.39 384.03,120.87 384.03,116.29 384.54,115.79 384.54,114.26 v385.56,113.25 | v365.75,90.89 364.22,89.37
  Bottom 0.254: v356.09,221.45 358.63,223.99 360.16,223.99 360.16,228.56 A02.S2
I/O_TS04  (via drill 0.61)
  Top 0.254: v299.2,112.74 298.69,113.25 298.69,117.31 301.23,119.85 301.23,145.76 300.21,146.77 300.21,150.33 301.23,151.35 301.23,175.22 v300.72,175.73
  Route2 0.254: v300.72,175.73 301.23,175.73 306.82,181.32 307.83,181.32 311.9,185.38 315.96,185.38 326.63,196.05 326.63,197.57 353.05,223.99 354.57,223.99 356.6,226.02 A02.T2
  Route15 0.254: v299.2,112.74 299.2,112.23 314.44,96.99 314.44,95.97 316.98,93.43 316.98,89.37 317.49,88.86 317.49,69.56 328.15,58.89 328.15,57.87 330.19,55.84 330.19,53.81 333.74,50.25 333.74,43.65 354.57,22.82 356.6,22.82 D02.T2
IM_00\
  Top 0.254: 336.79,192.49 336.79,68.54 337.81,67.53 D04.B1 | 336.79,192.49 337.81,193.51 B04.D1 | 336.79,192.49 336.79,268.69 337.81,269.71 A04.B1
  Bottom 0.254: B03.D1 350.5,193.51 350,193 338.82,193 338.31,193.51 B04.D1
IM_01\  (via drill 0.61)
  Top 0.254: v384.54,105.12 384.54,125.44 385.56,126.45 385.56,181.83 v384.54,182.84
  Route2 0.254: v384.54,105.12 340.85,61.43 338.31,61.43 D04.D1 | v356.6,230.59 361.17,226.02 359.14,223.99 359.14,198.59 356.09,195.54 356.09,193.51 354.06,191.48 B03.E1
  Route15 0.254: v356.6,230.59 339.33,247.87 339.33,258.53 338.31,259.55 338.31,263.61 A04.D1
  Bottom 0.254: v384.54,182.84 377.94,189.45 355.59,189.45 | 355.59,189.45 354.57,190.46 B03.E1 | 355.59,189.45 342.88,189.45 341.87,190.46 B04.E1
IM_02\  (via drill 0.61)
  Top 0.254: v355.08,74.13 355.59,74.64 355.59,154.39 353.55,156.43 v353.55,156.93 | A04.E1 341.87,260.57 342.88,259.55 342.88,212.31 341.87,211.29 341.87,205.19 342.38,204.69 342.38,179.29 341.87,178.78 B04.K1
  Route2 0.254: v355.08,74.13 341.87,60.92 341.87,57.87 D04.E1 | v353.55,156.93 351.52,158.97 355.59,163.03 355.59,165.06 358.63,168.11 358.63,171.16 353.05,176.75 354.06,177.76 B03.K1
  Bottom 0.254: B04.K1 341.87,177.76 342.88,176.75 352.54,176.75 353.55,177.76 B03.K1
IM_03\  (via drill 0.61)
  Top 0.254: v371.84,83.78 371.84,124.93 368.79,127.98 368.79,158.46 v369.3,158.97
  Route2 0.254: v371.84,83.78 341.36,53.3 341.36,51.78 D04.H1 | A04.H1 341.87,254.47 343.39,254.47 379.97,217.89 379.46,217.39 379.46,206.21 352.54,179.29 352.54,177.25 351.01,175.73 B03.L1
  Route15 0.254: v369.3,158.97 355.08,173.19 352.54,173.19 351.01,174.71 B03.L1
  Bottom 0.254: B04.L1 338.31,175.73 338.82,176.24 350,176.24 350.5,175.73 B03.L1
IM_04\
  Top 0.254: 339.33,161 339.33,148.3 338.82,147.79 338.82,139.15 339.33,138.65 339.33,49.75 338.31,48.73 D04.J1 | 339.33,161 338.31,162.01 B04.R1 | 339.33,161 339.33,249.9 338.31,250.91 A04.J1
  Bottom 0.254: B03.R1 350.5,163.03 350,163.54 338.82,163.54 338.31,163.03 B04.R1
IM_05\  (via drill 0.61)
  Top 0.254: v380.99,53.81 382.51,55.33 382.51,91.91 381.49,92.93 381.49,102.07 382,102.58 382,118.83 381.49,119.34 v381.49,128.99
  Route2 0.254: A04.L1 338.31,245.33 338.31,249.39 339.33,250.41 339.33,254.47 340.85,255.99 342.88,255.99 384.03,214.85 382,212.81 382,183.35 372.35,173.7 370.82,173.7 361.17,164.05 357.11,164.05 356.09,163.03 356.09,161 354.57,159.47 B03.S1
  Route15 0.254: v381.49,128.99 381.49,134.07 373.87,141.69 370.82,141.69 365.24,147.28 363.71,147.28 356.09,154.9 356.09,157.44 354.57,158.97 B03.S1
  Bottom 0.254: v380.99,53.81 379.46,53.81 369.3,43.65 339.84,43.65 338.31,42.13 D04.L1 | B04.S1 341.87,159.47 342.88,160.49 352.54,160.49 353.55,159.47 B03.S1
IM_06\  (via drill 0.61)
  Top 0.254: v332.73,166.59 333.23,166.08 333.23,151.35 334.25,150.33 334.25,148.3 333.23,147.28 333.23,85.31 332.22,84.29 332.22,78.19 333.23,77.18 333.23,30.95 342.38,30.95 342.38,37.55 341.87,38.06 D04.M1
  Route2 0.254: v332.73,166.59 351.52,185.38 351.52,185.89 | 351.52,185.89 351.52,186.4 352.03,186.91 352.03,188.94 351.01,189.95 349.49,188.43 349.49,186.4 347.97,184.87 B03.H2 | v363.21,217.39 363.21,202.15 362.19,201.13 362.19,196.56 351.52,185.89
  Route15 0.254: v363.21,217.39 341.36,239.23 341.36,241.26 A04.M1
  Bottom 0.254: B04.H2 335.26,184.87 336.28,185.89 346.44,185.89 347.46,184.87 B03.H2
IM_07\  (via drill 0.61)
  Top 0.254: 339.84,180.3 339.84,150.33 342.88,147.28 342.88,113.25 342.38,112.74 342.38,74.13 339.84,71.59 339.84,33.49 340.85,32.47 D04.P1 | v340.35,180.81 339.84,180.3 | 339.84,180.3 339.84,234.15 340.85,235.17 A04.P1
  Bottom 0.254: 340.35,180.3 343.39,180.3 343.9,180.81 B03.J2 | 340.35,180.3 332.73,180.3 332.22,180.81 B04.J2 | 340.35,180.3 v340.35,180.81
IM_08\  (via drill 0.61)
  Top 0.254: v327.65,128.99 327.65,121.37 329.68,119.34 329.68,83.78 330.19,83.27 330.19,75.65 329.17,74.64 329.17,64.99 328.15,63.97 328.15,30.44 339.33,30.44 339.33,27.9 340.85,26.38 D04.S1
  Route2 0.254: v327.65,128.99 327.65,129.5 332.73,134.58 332.73,135.6 336.28,139.15 336.28,141.69 343.39,148.81 343.39,156.93 346.95,160.49 346.95,162.01 349.49,164.55 349.49,165.57 352.03,168.11 352.03,171.16 350.5,172.68 348.47,170.65 346.44,170.65 344.92,169.13 B03.N2 | v323.07,195.54 324.09,196.56 324.09,198.08 339.84,213.83 339.84,223.48 341.36,225.01 341.36,228.56 A04.S1
  Route15 0.254: v323.07,195.54 323.07,195.03 326.63,191.48 326.63,189.45 342.38,173.7 342.38,171.16 344.41,169.13 B03.N2
  Bottom 0.254: B04.N2 332.22,168.11 332.73,167.6 343.39,167.6 343.9,168.11 B03.N2
IM_09\  (via drill 0.61)
  Top 0.254: D04.D2 331.2,61.43 330.69,61.94 330.69,74.13 331.2,74.64 331.2,84.29 330.69,84.8 330.69,138.14 332.73,140.17 332.73,148.3 v333.23,148.81 333.23,150.33 330.69,152.87 330.69,194.02 330.19,194.53 330.19,262.6 331.2,263.61 A04.D2
  Route2 0.254: v333.23,148.81 345.93,161.51 345.93,163.54 347.46,165.06 B03.P2
IM_10\  (via drill 0.61)
  Top 0.254: v292.59,15.2 171.69,15.2 171.69,81.75 167.12,86.32 167.12,131.03 165.09,133.06 165.09,154.9 162.04,157.95 v162.04,193.51
  Route2 0.254: v292.59,15.2 314.44,37.05 319.52,37.05 330.19,47.71 330.19,48.73 334.76,53.3 334.76,57.37 D04.E2 | v162.04,193.51 164.58,196.05 164.58,199.61 218.93,253.96 218.93,254.98 238.75,274.79 240.27,274.79 245.86,280.38 309.87,280.38 331.2,259.04 333.23,259.04 334.76,260.57 A04.E2
IM_11\  (via drill 0.61)
  Top 0.254: v365.75,52.79 365.24,53.3 365.24,84.29 v365.75,84.8 | v328.15,180.3 328.15,193.51 329.68,195.03 329.68,265.14 332.73,265.14 333.23,264.63 333.23,256.5 334.76,254.98 A04.H2
  Route2 0.254: v365.75,84.8 365.75,85.31 382.51,102.07 383.53,102.07 v385.56,104.1
  Route15 0.254: v385.56,104.1 385.56,111.72 382.51,114.77 382.51,115.79 336.79,161.51 336.79,163.54 335.26,165.06 B04.P2 334.76,166.08 333.23,167.6 331.2,167.6 328.66,170.14 328.66,178.78 328.15,179.29 v328.15,180.3
  Bottom 0.254: v365.75,52.79 336.28,52.79 335.26,51.78 D04.H2
INT_RQ\  (via drill 0.61)
  Route15 0.254: v298.69,219.42 317.49,200.62 322.06,200.62 B05.B1 | v264.65,220.94 243.32,242.28 241.29,242.28 237.22,246.34 235.19,246.34 233.67,247.87 A12.K1
  Bottom 0.254: v298.69,219.42 298.69,220.94 v264.65,220.94
IOP_1
  Top 0.254: A02.K2 360.67,247.87 361.68,246.85 361.68,46.19 360.67,45.17 D02.K2
  Route15 0.254: D02.K2 360.67,45.17 360.67,49.24 365.75,54.32 332.73,87.34 331.71,87.34 321.04,98.01 321.04,99.53 319.01,101.56 C05.P2
  Bottom 0.254: C05.P2 319.52,102.58 320.53,103.59 326.63,103.59 328.15,102.07 334.76,102.07 C04.P2
IOP_2  (via drill 0.61)
  Top 0.254: v274.81,254.98 274.81,233.13 275.83,232.12 275.83,193 274.31,191.48 274.31,139.66 275.32,138.65 v275.32,41.11
  Route2 0.254: v275.32,41.11 275.32,42.63 279.38,46.7 279.38,47.71 283.96,52.29 283.96,52.79 284.47,53.3 284.97,53.3 316.98,85.31 316.98,93.43 313.93,96.48 315.96,98.51 C05.R2
  Route15 0.254: D02.M2 360.67,39.08 360.67,42.63 372.35,54.32 336.28,90.39 336.28,92.42 333.74,94.96 333.74,96.99 332.22,98.51 C04.R2
  Bottom 0.254: C05.R2 316.47,99.53 316.98,100.04 330.69,100.04 331.2,99.53 C04.R2 | v274.81,254.98 277.35,254.98 281.42,259.04 323.58,259.04 326.63,255.99 342.38,255.99 355.08,243.29 359.14,243.29 360.16,242.28 A02.M2
IOP_4  (via drill 0.61)
  Top 0.254: v359.14,69.05 359.14,234.15 360.16,235.17 A02.P2
  Route15 0.254: 358.63,69.05 336.79,90.89 336.79,93.94 335.26,95.47 C04.S2 | 358.63,69.05 375.91,51.78 360.67,36.54 360.67,32.47 D02.P2 | v359.14,69.05 358.63,69.05
  Bottom 0.254: C05.S2 319.52,95.97 320.53,96.99 333.74,96.99 334.76,95.97 C04.S2
LDMF  (via drill 0.61)
  Top 0.254: v328.66,118.33 327.65,117.31 327.65,96.99 329.17,95.47 v329.17,82.77
  Route2 0.254: D11.B1 242.3,67.02 240.78,67.02 238.24,64.48 238.24,62.95 236.71,61.43 D11.D2 | v329.17,82.77 328.15,82.77 316.47,71.08 v315.96,71.08
  Route15 0.254: D11.H1 245.86,51.78 245.86,53.81 240.78,58.89 238.24,58.89 236.71,60.41 D11.D2 | v328.66,118.33 326.63,120.36 326.63,121.88 324.6,123.91 322.56,123.91 C05.F1
  Bottom 0.254: v315.96,71.08 315.96,68.54 313.42,68.54 310.88,66 300.72,66 295.13,71.59 262.62,71.59 259.57,68.54 244.33,68.54 243.32,67.53 D11.B1
LDMF\
  Route15 0.254: B08.P2 281.42,165.06 283.96,165.06 300.21,148.81 301.74,148.81 302.25,148.3 304.28,148.3 306.31,146.27 308.85,146.27 323.58,131.53 323.58,129.5 325.11,127.98 C05.E1
LPB_00  (via drill 0.61)
  Top 0.254: v282.94,64.48 282.94,120.87 285.48,123.41 285.48,126.45 283.96,127.98 283.96,130.01 C08.D1
  Route15 0.254: v102.6,176.24 57.39,221.45 54.85,221.45 50.78,225.51 46.21,225.51 A25.T2 | v236.21,159.98 v246.87,149.31 | v268.72,147.79 269.23,147.79 282.43,134.58 282.43,132.55 283.96,131.03 C08.D1 | v282.94,64.48 287,60.41 287,57.87 D08.E1
  Bottom 0.254: v102.6,176.24 111.75,167.09 152.39,167.09 154.93,164.55 155.94,164.55 156.96,163.54 225.54,163.54 229.09,159.98 v236.21,159.98 | v246.87,149.31 248.4,147.79 v268.72,147.79
LPB_00\
  Route2 0.254: D10.M1 259.06,39.08 263.64,39.08 264.65,40.09 268.72,40.09 272.78,44.16 272.78,45.17 280.4,52.79 282.94,52.79 283.96,53.81 D08.F1
LPB_01  (via drill 0.61)
  Route2 0.254: v314.94,78.7 307.83,71.59 307.83,69.56 284.47,46.19 284.47,42.13 D08.L1
  Route15 0.254: v134.61,217.89 163.05,189.45 164.58,189.45 188.96,165.06 189.98,165.06 206.74,148.3 207.76,148.3 217.41,138.65 219.44,138.65 v222.49,135.6 | v314.94,78.7 313.93,79.72 313.93,83.78 311.39,86.32 311.39,87.34 304.79,93.94 304.79,94.96 289.04,110.71 289.04,112.74 287.51,114.26 C08.K1
  Bottom 0.254: v134.61,217.89 49.77,217.89 49.77,222.47 A25.U2 | v222.49,135.6 223,135.09 242.3,135.09 244.84,132.55 259.06,132.55 260.59,131.03 260.59,128.49 260.08,127.98 260.08,122.39 266.18,122.39 266.69,121.88 266.69,119.85 275.83,119.85 277.35,121.37 278.37,121.37 279.89,119.85 284.47,119.85 287,117.31 287,115.28 C08.K1
LPB_01\
  Bottom 0.254: D10.N1 256.02,36.03 257.03,37.05 285.99,37.05 287,38.06 D08.M1
LPB_02  (via drill 0.61)
  Top 0.254: C08.R1 284.47,98.51 285.99,96.99 285.99,54.83 288.53,52.29 288.53,27.39 287.51,26.38 D08.S1
  Route2 0.254: v63.99,123.91 63.99,140.68 64.5,141.19 44.69,161 44.69,201.13 46.21,202.65 46.21,218.91 A25.V2
  Bottom 0.254: v63.99,123.91 63.99,103.59 66.03,103.59 101.08,68.54 124.44,68.54 162.55,30.44 284.97,30.44 287,28.41 287,26.38 D08.S1
LPB_02\
  Route15 0.254: D10.P1 259.06,31.97 263.13,31.97 264.15,30.95 273.8,30.95 283.45,21.3 285.48,21.3 287,19.77 D08.U1
LPB_03  (via drill 0.61)
  Top 0.254: D08.H2 280.4,51.78 279.38,52.79 279.38,119.85 280.4,120.87 C08.H2
  Route2 0.254: v213.85,20.79 251.45,20.79 270.75,40.09 271.76,40.09 278.88,47.21 278.88,48.73 280.91,50.76 D08.H2
  Route15 0.254: v213.85,20.79 164.58,70.07 164.58,71.59 110.22,125.95 108.7,125.95 56.88,177.76 56.88,178.78 50.28,185.38 50.28,186.4 4.05,232.63 37.58,266.15 37.58,267.68 37.07,268.19 37.07,273.27 A26.A2
LPB_03\
  Route2 0.254: D10.R1 256.02,29.43 259.06,29.43 277.35,47.71 D08.J2
LPB_04  (via drill 0.61)
  Top 0.254: D08.P2 281.42,31.97 282.43,30.95 282.43,25.36 281.42,24.35 276.34,24.35 276.34,104.1 277.35,105.12 C08.N2
  Route2 0.254: v253.48,84.8 256.53,84.8 v271.76,100.04
  Bottom 0.254: v253.48,84.8 248.91,84.8 247.89,83.78 147.81,83.78 137.65,93.94 115.3,93.94 67.55,141.69 62.98,141.69 31.48,173.19 28.94,173.19 28.94,262.09 32.5,265.65 33.01,265.65 33.01,269.71 A26.B2 | v271.76,100.04 276.34,104.61 277.35,104.61 C08.N2
LPB_04\
  Bottom 0.254: D10.R2 249.41,28.41 249.92,27.9 276.85,27.9 277.35,28.41 D08.R2
LPB_05  (via drill 0.61)
  Top 0.254: v273.29,79.72 273.29,31.46 270.24,28.41 270.24,16.73 277.35,16.73 D08.V2
  Route2 0.254: v273.29,79.72 278.88,85.31 278.88,86.83 280.91,88.86 C08.U2
  Route15 0.254: v152.89,77.18 110.73,119.34 110.73,121.88 55.87,176.75 54.85,176.75 1.51,230.09 1.51,235.67 33.01,267.17 36.05,267.17 A26.C2
  Bottom 0.254: v152.89,77.18 270.75,77.18 v273.29,79.72
LPB_05\
  Top 0.254: D10.T2 249.41,22.31 251.95,19.77 D10.U2
  Bottom 0.254: D10.T2 249.41,23.33 251.45,25.36 251.95,25.36 D10.S2 | D08.V1 283.96,16.73 282.43,18.25 253.99,18.25 252.97,19.27 D10.U2
LPB_NOT_EQ_1  (via drill 0.61)
  Top 0.254: v247.89,38.57 247.89,17.74 248.91,16.73 D10.V2
  Route2 0.254: v149.34,151.35 149.34,154.39 165.09,170.14 165.09,172.17 197.6,204.69 208.77,204.69 220.46,216.37 223,216.37 250.43,243.8 250.43,244.82 v251.95,246.34
  Route15 0.254: v247.89,38.57 247.89,41.11 222.49,66.51 222.49,69.56 203.69,88.35 203.69,92.42 200.65,95.47 200.65,96.99 190.99,106.64 190.99,107.66 178.8,119.85 178.29,119.85 165.09,133.06 165.09,135.6 v149.34,151.35 | v251.95,246.34 252.46,246.34 255,243.8 257.03,243.8 258.56,242.28 A10.M1
LPB_TO_DTB  (via drill 0.61)
  Top 0.254: v275.32,183.35 275.32,141.69 276.34,140.68 276.34,125.95 277.35,124.93 C08.F2 | 285.48,119.34 284.47,118.33 C08.J1 | 285.48,119.34 285.99,119.85 285.99,128.49 287.51,130.01 287.51,133.57 C08.C1 | 285.48,119.34 285.48,104.1 287,102.58 C08.P1
  Route2 0.254: C08.T2 277.86,92.93 277.86,94.96 282.94,100.04 285.48,100.04 287,101.56 C08.P1 | v236.71,221.96 236.71,225.51 A11.T2
  Route15 0.254: C08.M2 281.42,108.17 281.42,106.13 283.45,104.1 285.48,104.1 287,102.58 C08.P1 | C08.F2 277.86,123.91 277.86,121.88 279.89,119.85 282.43,119.85 283.96,118.33 C08.J1 | v275.32,183.35 v236.71,221.96
M-STOP\  (via drill 0.61)
  Route2 0.254: A11.S1 245.86,228.56 244.84,227.55 242.81,227.55 242.3,227.04 235.7,227.04 224.01,215.35 224.01,213.83 212.84,202.65 212.84,201.64 205.22,194.02 202.17,194.02 B14.D1 201.15,193.51 201.15,188.94 168.64,156.43 168.64,154.39 146.29,132.04 146.29,118.83 143.24,115.79 143.24,102.07 v141.72,100.55 | v251.95,99.53 218.93,66.51 218.93,63.46 212.33,56.86 212.33,50.25 204.2,42.13 202.17,42.13 D14.L1
  Route15 0.254: v141.72,100.55 155.43,86.83 155.43,85.31 187.44,53.3 188.45,53.3 198.11,43.65 200.14,43.65 201.66,42.13 D14.L1
  Bottom 0.254: v251.95,99.53 256.02,103.59 272.78,103.59 279.38,110.2 287,110.2 291.07,114.26 293.1,114.26 C07.K2
MB_TO_DTB\
  Top 0.254: D12.S1 233.16,26.38 232.14,27.39 232.14,43.65 233.16,44.67 D12.K1
  Route2 0.254: D12.H1 233.16,50.76 230.62,48.22 D12.J1
  Route15 0.254: D12.J1 230.62,47.71 233.16,45.17 D12.K1
  Bottom 0.254: D12.H1 233.16,51.78 231.12,53.81 230.62,53.81 D12.F1
MC00  (via drill 0.61)
  Top 0.254: v154.93,79.21 151.88,82.26 v151.88,225.51
  Route15 0.254: v172.71,227.55 172.71,226.53 197.6,201.64 198.11,201.64 198.61,201.13 198.61,200.11 202.17,196.56 203.19,196.56 207.25,192.49 209.28,192.49 210.81,190.97 B13.E2 | v232.65,78.19 239.25,71.59 240.78,71.59 249.41,62.95 249.41,61.43 D10.D2
  Bottom 0.254: B13.E2 211.31,190.46 216.9,190.46 B13.E1 | 151.88,227.55 v172.71,227.55 | 151.88,227.55 121.4,227.55 115.3,221.45 54.34,221.45 51.8,223.99 43.16,223.99 43.16,228.56 A26.S1 | v232.65,78.19 232.14,77.69 218.93,77.69 217.41,79.21 v154.93,79.21 | 151.88,227.55 v151.88,225.51
MC00\  (via drill 0.61)
  Top 0.254: v235.19,171.16 235.19,156.93 236.21,155.92 B11.T2
  Route2 0.254: A10.R1 255.51,231.61 255.51,229.58 225.03,199.1 224.01,199.1 216.39,191.48 216.39,189.95 214.36,187.92 B13.F1
  Route15 0.254: v235.19,171.16 235.19,171.67 224.52,182.33 221.47,182.33 218.43,185.38 216.9,185.38 214.87,187.41 B13.F1
MC01  (via drill 0.61)
  Top 0.254: v215.89,158.97 215.89,179.79 214.87,180.81 B13.J1
  Route2 0.254: 210.3,179.79 212.84,179.79 213.85,180.81 B13.J1 | v204.71,179.79 210.3,179.79 | 210.3,179.79 219.95,189.45 222.49,189.45 277.35,244.31 277.86,244.31 A08.L2
  Route15 0.254: v91.42,185.89 91.42,186.4 56.88,220.94 54.34,220.94 50.78,224.5 45.2,224.5 44.18,225.51 40.12,225.51 A26.T1 | v215.89,158.97 215.89,158.46 223.51,150.84 225.03,150.84 245.86,130.01 245.86,127.98 C11.E1 | B13.H2 211.31,183.86 213.85,181.32 B13.J1
  Bottom 0.254: v91.42,185.89 133.08,185.89 139.18,179.79 178.29,179.79 179.31,180.81 180.33,180.81 181.34,179.79 v204.71,179.79
MC01\  (via drill 0.61)
  Top 0.254: v245.35,138.14 244.84,137.63 244.84,101.05 250.43,95.47 250.43,59.4 251.95,57.87 D10.E2 | v241.29,164.55 241.29,142.2 242.3,141.19 242.3,137.63 C11.B1 | v209.28,171.67 209.28,179.79 208.27,180.81 B13.J2
  Bottom 0.254: v245.35,138.14 244.84,137.63 243.32,137.63 C11.B1 | v241.29,164.55 242.81,164.55 | 242.81,164.55 245.35,164.55 245.86,165.06 B11.P1 | v209.28,171.67 209.28,166.59 240.78,166.59 242.81,164.55
MC02  (via drill 0.61)
  Top 0.254: v209.28,76.16 206.74,78.7 206.74,120.87 v209.79,123.91
  Route2 0.254: v209.79,123.91 210.81,123.91 216.39,129.5 217.92,129.5 228.08,139.66 228.08,141.19 229.6,142.71 229.6,144.23 236.21,150.84 237.73,150.84 239.25,152.36 B11.U2
  Route15 0.254: D12.E2 226.55,57.87 224.01,60.41 D12.D2 224.01,61.43 v209.28,76.16 | v182.36,212.31 182.36,210.27 200.14,192.49 200.14,190.97 212.33,178.78 | 212.33,178.78 212.33,176.75 213.85,175.22 B13.L1 | 212.33,178.78 220.46,170.65 220.46,169.63 237.22,152.87 239.25,152.87 B11.U2
  Bottom 0.254: v182.36,212.31 181.34,213.32 43.16,213.32 43.16,222.47 A26.U1
MC02\  (via drill 0.61)
  Top 0.254: B13.M1 216.9,172.17 216.39,172.68 216.39,196.05 216.9,196.56 B13.C1 | v245.35,99.02 244.84,98.51 244.84,74.64 247.38,72.1 247.38,56.35 248.91,54.83 D10.F2
  Route2 0.254: v232.14,124.93 232.65,124.93 240.27,132.55 240.78,132.55 244.33,136.11 244.33,140.68 246.87,143.22 v247.38,143.22
  Route15 0.254: v245.35,99.02 245.35,100.55 241.79,104.1 241.79,108.67 238.24,112.23 237.73,112.23 237.22,112.74 237.22,114.77 238.24,115.79 237.22,116.8 235.7,116.8 235.19,117.31 235.19,121.88 v232.14,124.93 | v247.38,143.22 245.35,143.22 240.78,147.79 240.78,148.3 217.92,171.16 B13.M1
MF00  (via drill 0.61)
  Route15 0.254: v220.46,58.38 180.83,98.01 180.83,102.58 163.56,119.85 162.55,119.85 121.4,161 115.3,161 112.25,164.05 108.7,164.05 53.33,219.42 52.82,219.42 A25.V1
  Bottom 0.254: v220.46,58.38 220.97,58.89 244.84,58.89 245.86,57.87 D11.E1
MF00\  (via drill 0.61)
  Top 0.254: v327.14,139.15 327.14,168.11 325.61,169.63 325.61,171.16 B05.M1 325.61,172.17 v325.61,176.24
  Route2 0.254: v327.14,139.15 259.57,71.59 258.05,71.59 243.32,56.86 243.32,54.83 D11.F1 | v325.61,176.24 326.63,177.25 326.63,178.78 327.14,179.29 327.14,180.81 330.69,184.37 330.69,188.43 331.71,189.45 331.71,193.51 B04.D2
MF01  (via drill 0.61)
  Top 0.254: v30.97,167.09 38.09,167.09 38.09,266.66 42.66,271.23 42.66,273.27 A26.A1
  Bottom 0.254: v30.97,167.09 32.5,167.09 51.29,148.3 53.33,148.3 107.17,94.45 110.22,94.45 145.27,59.4 151.37,59.4 161.02,49.75 234.17,49.75 234.68,50.25 238.75,50.25 239.25,50.76 D11.H2
MF01\  (via drill 0.61)
  Top 0.254: v314.94,108.67 314.44,109.18 v314.44,145.25 | v321.55,152.36 321.04,152.87 321.04,165.57 322.06,166.59 322.06,168.11 B05.N1
  Route2 0.254: v257.03,49.24 257.03,51.78 270.75,65.49 272.27,65.49 314.94,108.17 v314.94,108.67 | v321.55,152.36 v314.44,145.25 | B04.E2 334.76,190.46 334.76,186.4 330.69,182.33 330.69,179.79 323.58,172.68 323.58,169.63 322.56,168.62 B05.N1
  Bottom 0.254: v257.03,49.24 237.22,49.24 236.71,48.73 D11.J2
MF02
  Bottom 0.254: D11.L1 242.3,42.13 240.78,43.65 154.42,43.65 110.22,87.85 107.17,87.85 56.37,138.65 54.34,138.65 28.43,164.55 28.43,271.74 38.09,271.74 39.1,270.73 A26.B1
MF02\  (via drill 0.61)
  Top 0.254: v247.38,54.83 247.38,40.09 246.37,39.08 D11.M1 | v328.15,140.17 327.65,140.68 v327.65,178.27
  Route2 0.254: v247.38,54.83 247.38,56.86 260.08,69.56 260.08,70.57 328.15,138.65 v328.15,140.17 | v314.94,190.97 315.45,191.48 315.45,193.51 B05.D2
  Route15 0.254: v314.94,190.97 v327.65,178.27
  Bottom 0.254: v327.65,178.27 334.76,178.27 B04.K2
MK_BLK_END  (via drill 0.61)
  Top 0.254: v221.47,101.56 221.47,103.59 220.46,104.61 220.46,116.8 222.49,118.83 v222.49,120.36 | v257.03,154.39 257.54,154.9 257.54,193.51 260.59,196.56 260.59,224.5 261.61,225.51 A09.T2
  Route2 0.254: v221.47,101.56 220.46,100.55 220.46,98.51 218.93,96.99 218.93,94.96 164.58,40.6 164.58,37.55 151.37,24.35 151.37,19.77 CD18.BU1 | v222.49,120.36 230.62,128.49 230.62,128.99 231.12,129.5 233.16,129.5 241.79,138.14 241.79,139.15 v257.03,154.39
MK_BLK_END\  (via drill 0.61)
  Route2 0.254: v208.77,261.58 152.39,205.19 149.85,205.19 110.73,166.08 110.73,57.37 147.81,20.28 147.81,16.73 CD18.BV1
  Bottom 0.254: v208.77,261.58 209.79,262.6 226.55,262.6 229.6,265.65 270.24,265.65 271.26,266.66 A09.C1
MK_BLK_MK  (via drill 0.61)
  Route2 0.254: D10.B1 256.02,67.53 258.56,70.07 D10.A1
  Route15 0.254: v196.07,75.15 164.58,106.64 164.58,109.69 151.37,122.9 146.8,122.9 144.77,124.93 144.77,126.96 CD18.AE2
  Bottom 0.254: v196.07,75.15 198.11,73.11 246.37,73.11 247.89,71.59 257.54,71.59 258.56,70.57 D10.A1
MK_BLK_START\  (via drill 0.61)
  Top 0.254: v218.93,264.63 222.49,268.19 222.49,271.74 223,272.25 238.24,272.25 238.24,274.79 239.76,276.31 271.26,276.31 271.26,273.77 A09.A1
  Route2 0.254: v130.54,145.25 130.54,174.21 170.67,214.34 170.67,216.37 v218.93,264.63
  Route15 0.254: v130.54,145.25 146.8,128.99 146.8,126.45 147.81,125.44 147.81,124.93 CD18.AF1
MK_DATA\  (via drill 0.61)
  Top 0.254: v142.23,189.45 142.73,188.94 142.73,91.4 144.26,89.88 CD18.AU2
  Route2 0.254: v164.07,192.49 166.1,192.49 194.55,220.94 206.74,220.94 216.9,231.1 216.9,232.63 218.93,234.66 218.93,235.67 248.4,265.14 254.49,265.14 258.05,268.69 266.18,268.69 267.7,270.22 A09.B1
  Bottom 0.254: v142.23,189.45 142.23,192.49 v164.07,192.49
MK_END  (via drill 0.61)
  Route2 0.254: v240.27,251.93 218.93,230.59 218.93,228.05 164.58,173.7 164.58,170.65 139.18,145.25 139.18,132.55 138.16,131.53 141.21,128.49 141.21,124.93 CD18.AF2
  Bottom 0.254: v240.27,251.93 240.78,252.44 245.86,252.44 248.4,249.9 258.05,249.9 273.8,265.65 285.99,265.65 287,266.66 A08.C1
MK_END\  (via drill 0.61)
  Route2 0.254: v133.08,130.52 133.08,151.85 151.88,170.65 151.88,181.83 165.09,195.03 165.09,198.08 216.39,249.39 217.92,249.39 v231.63,263.11
  Route15 0.254: v133.08,130.52 142.23,121.37 144.26,121.37 CD18.AH2
  Bottom 0.254: v231.63,263.11 233.67,265.14 267.19,265.14 267.7,264.63 A09.D1
MKT  (via drill 0.61)
  Top 0.254: v225.54,153.38 226.55,154.39 226.55,158.46 B12.S2
  Route2 0.254: v225.54,153.38 225.03,153.38 219.44,147.79 217.41,147.79 211.31,141.69 210.3,141.69 202.68,134.07 202.68,129.5 192.52,119.34 188.45,119.34 182.36,113.25 182.36,112.23 C15.L2
  Route15 0.254: v207.25,153.89 207.76,153.38 207.76,149.82 B13.V2 | v105.65,179.29 56.88,228.05 56.88,230.09 36.56,250.41 36.56,253.96 A26.H2 | B12.S2 226.55,158.97 225.03,158.97 223,161 221.47,161 219.44,163.03 216.39,163.03 215.38,164.05 214.36,164.05 211.82,166.59 207.76,166.59 206.74,167.6 204.71,167.6 202.68,169.63 196.07,169.63 193.03,172.68 191.5,172.68 189.47,174.71 B15.L1
  Bottom 0.254: v207.25,153.89 209.79,151.35 223.51,151.35 v225.54,153.38 | v105.65,179.29 108.19,176.75 186.93,176.75 188.45,175.22 B15.L1
MKT\  (via drill 0.61)
  Top 0.254: v221.47,128.99 v221.47,146.77
  Route2 0.254: v242.81,147.28 255.51,159.98 255.51,161.51 B10.R1 | v221.47,128.99 221.47,128.49 210.3,117.31 210.3,116.29 203.69,109.69 203.69,107.66 201.66,105.63 C14.N1
  Route15 0.254: B13.V1 213.85,149.82 212.84,149.82 212.33,150.33 211.31,150.33 209.79,151.85 209.79,153.89 208.27,155.41 B13.T2 | D10.H2 252.46,51.78 252.46,53.3 226.05,79.72 223.51,79.72 207.25,95.97 207.25,97.5 203.69,101.05 203.69,102.58 201.66,104.61 C14.N1
  Bottom 0.254: v242.81,147.28 241.79,146.27 221.47,146.27 | 221.47,146.27 219.95,146.27 217.41,148.81 214.87,148.81 B13.V1 | v221.47,146.77 221.47,146.27
MKTK  (via drill 0.61)
  Route2 0.254: v221.47,265.65 218.43,265.65 v185.91,233.13
  Route15 0.254: v221.47,265.65 238.24,265.65 271.26,232.63 277.35,232.63 A08.R2
  Bottom 0.254: v185.91,233.13 184.9,234.15 56.88,234.15 55.87,235.17 A25.P1
MKTK\  (via drill 0.61)
  Route15 0.254: A09.K2 265.67,247.87 265.67,245.33 270.75,240.25 272.27,240.25 274.31,238.21 276.34,238.21 277.35,237.2 278.88,237.2 280.4,235.67 A08.P2 | v314.94,229.07 338.31,205.7 338.31,201.13 B04.B1
  Bottom 0.254: v314.94,229.07 313.42,230.59 288.02,230.59 283.45,235.17 281.42,235.17 A08.P2
MOVE\  (via drill 0.61)
  Top 0.254: v289.55,243.29 289.04,242.79 289.04,193 289.55,192.49 290.56,192.49 290.56,189.45 289.04,187.92 289.04,173.19 291.58,170.65 291.58,134.07 v290.05,132.55 | v293.61,110.71 295.13,110.71 295.13,47.21 295.64,46.7 298.18,46.7 298.18,59.4 297.17,60.41 D07.D1
  Route2 0.254: v290.05,132.55 287,129.5 284.47,129.5 282.43,127.47 282.43,126.96 v280.4,124.93
  Route15 0.254: v289.55,243.29 287.51,245.33 287,245.33 272.78,259.55 270.75,259.55 263.13,267.17 260.59,264.63 260.59,263.11 261.61,262.09 261.61,258.03 A09.F2 | v280.4,124.93 280.4,123.91 v293.61,110.71
MR00
  Route15 0.254: A25.D1 51.8,264.12 50.28,264.12 47.74,266.66 47.74,274.28 64.5,291.05 83.3,272.25 89.39,272.25 108.7,252.95 110.73,252.95 140.7,222.97 142.23,222.97 163.05,202.15 165.59,202.15 194.04,173.7 196.58,173.7 198.11,172.17 B14.M2
  Bottom 0.254: B07.P2 293.1,165.57 293.1,169.63 259.57,169.63 259.06,170.14 243.32,170.14 237.22,176.24 236.21,176.24 235.7,176.75 201.66,176.75 198.61,173.7 198.61,172.17 B14.M2
MR00\  (via drill 0.61)
  Route2 0.254: v312.41,181.32 293.1,162.01 291.07,162.01 B07.R2
  Bottom 0.254: v312.41,181.32 313.42,182.33 330.19,182.33 331.2,183.35 352.54,183.35 353.55,184.37 B03.H1
MR01  (via drill 0.61)
  Route15 0.254: v93.97,259.55 110.73,242.79 110.73,239.74 164.58,185.89 164.58,184.37 v210.81,138.14 | v277.35,103.59 276.34,104.61 276.34,106.13 263.64,118.83 263.64,119.34 255,127.98 255,128.49 v247.89,135.6
  Bottom 0.254: v93.97,259.55 56.88,259.55 55.87,260.57 A25.E1 | v210.81,138.14 229.09,138.14 229.6,137.63 C12.B1 230.11,136.61 231.12,135.6 v247.89,135.6 | v277.35,103.59 292.09,103.59 293.1,102.58 C07.P2
MR01\  (via drill 0.61)
  Top 0.254: v209.28,212.31 203.69,206.72 203.69,198.08 204.2,197.57 B14.C1
  Route2 0.254: v315.45,96.48 326.63,107.66 326.63,108.67 334.25,116.29 338.82,116.29 348.98,126.45 348.98,131.53 353.05,135.6 353.05,137.12 v366.25,150.33
  Route15 0.254: v366.25,150.33 366.25,151.35 365.24,152.36 365.24,158.46 356.09,167.6 356.09,170.14 354.57,171.67 B03.M1 353.55,172.17 353.05,172.68 352.03,172.68 351.01,173.7 350,173.7 342.38,181.32 342.38,186.4 326.63,202.15 324.6,202.15 315.45,211.29 v315.45,213.32
  Bottom 0.254: v315.45,96.48 314.94,96.99 292.59,96.99 291.07,98.51 C07.R2 | v209.28,212.31 209.79,212.81 306.31,212.81 306.82,213.32 v315.45,213.32
N$1
  Bottom 0.254: B08.S2 281.42,159.47 281.93,159.98 302.75,159.98 303.26,159.47 305.8,159.47 B06.S2
N$2
  Top 0.254: C16.M2 172.71,108.67 170.17,111.21 C16.L2 170.17,112.23 172.71,114.77 C16.K2
  Route15 0.254: C17.B1 160.51,136.61 160.51,132.55 164.58,128.49 164.58,127.47 167.12,124.93 167.12,122.9 171.18,118.83 171.18,116.8 172.71,115.28 C16.K2
  Bottom 0.254: C16.N2 170.17,105.63 172.71,108.17 C16.M2
N$3  (via drill 0.61)
  Top 0.254: v241.79,190.97 241.29,191.48 241.29,230.59 242.3,231.61 A11.R1
  Route2 0.254: v260.59,173.7 259.57,172.68 258.05,172.68 256.02,170.65 255.51,170.65 243.83,158.97 240.27,158.97 B11.S2
  Route15 0.254: v260.59,173.7 260.08,173.7 244.84,188.94 243.83,188.94 v241.79,190.97
N$4
  Top 0.254: D13.R2 208.27,28.41 210.81,25.87 D13.S2
N$5  (via drill 0.61)
  Top 0.254: v148.32,113.75 146.29,115.79 146.29,183.86 149.34,186.91 149.34,231.61 164.58,246.85 v164.58,250.91
  Route15 0.254: v148.32,113.75 162.04,100.04 162.04,94.96 169.66,87.34 169.66,86.83 C16.V2
  Bottom 0.254: v164.58,250.91 167.62,253.96 172.71,253.96 A16.H2
N$6
  Route15 0.254: D12.B1 230.62,67.02 233.16,64.48 D12.C1
  Bottom 0.254: D12.B1 230.62,67.53 233.16,70.07 D12.A1 | D13.F2 208.27,54.83 208.27,59.4 228.59,59.4 229.6,60.41 D12.D1 230.62,61.43 231.12,61.43 233.16,63.46 D12.C1
N$7
  Top 0.254: A12.P1 233.16,235.67 230.62,238.21 A12.N1 229.6,239.23 229.09,239.74 229.09,250.41 229.6,250.91 A12.J1
N$8
  Top 0.254: D17.F2 154.42,54.83 158.99,54.83 158.99,97.5 160.01,98.51 C17.R1
N$10  (via drill 0.61)
  Top 0.254: v228.59,149.82 228.59,164.55 233.16,169.13 233.16,171.16 B12.M1
  Route15 0.254: v228.59,149.82 228.59,149.31 243.83,134.07 245.86,134.07 C11.C1
N$11
  Top 0.254: C11.F1 242.3,124.93 241.79,125.44 241.79,140.68 240.78,141.69 240.78,148.81 234.68,154.9 234.68,162.01 232.65,164.05 230.62,164.05 230.62,162.52 B12.R1
N$12
  Bottom 0.254: D17.E2 156.96,57.87 154.42,60.41 D17.D2
N$13  (via drill 0.61)
  Top 0.254: v199.63,201.64 199.63,246.85 198.61,247.87 A14.K2 | A14.H2 198.11,253.96 195.57,251.42 A14.J2
  Route2 0.254: v199.63,201.64 199.63,196.05 190.99,187.41 189.47,187.41 B15.F1
  Bottom 0.254: A14.J2 195.57,250.91 198.11,248.37 A14.K2
N$14
  Top 0.254: A16.D2 170.17,263.61 172.71,261.07 A16.E2
N$15  (via drill 0.61)
  Top 0.254: v171.18,146.27 171.18,255.99 170.17,257.01 A16.F2
  Route2 0.254: v171.18,146.27 167.62,142.71 167.62,140.17 164.07,136.61 164.07,134.07 C17.C1
N$16  (via drill 0.61)
  Top 0.254: v166.61,140.68 v166.61,238.72 | A15.C1 191.5,266.66 189.47,264.63 A15.D1
  Route2 0.254: v166.61,140.68 156.96,131.03 154.42,131.03 C17.D2 | v166.61,238.72 182.87,254.98 182.87,255.99 186.93,260.06 186.93,262.09 188.45,263.61 A15.D1
N$17  (via drill 0.61)
  Top 0.254: v179.82,143.22 178.29,141.69 178.29,99.53 180.83,96.99 180.83,62.95 182.36,61.43 D15.D2
  Route2 0.254: v179.82,143.22 180.83,143.22 194.55,156.93 | 194.55,156.93 196.58,156.93 198.11,158.46 B14.S2 | 194.55,156.93 201.15,163.54 201.15,168.11 B14.N1
N$18  (via drill 0.61)
  Top 0.254: v197.09,200.11 197.09,234.15 198.11,235.17 A14.P2 198.11,235.67 195.57,238.21 A14.N2 195.57,238.72 198.11,241.26 A14.M2
  Route2 0.254: v197.09,200.11 184.9,187.92 182.87,187.92 B15.F2
N$19
  Route2 0.254: A14.L2 195.57,245.33 195.57,247.36 200.65,252.44 202.17,252.44 204.2,254.47 A14.H1
N$20
  Bottom 0.254: A16.R2 170.17,231.61 172.2,229.58 172.71,229.58 A16.S2
N$21
  Top 0.254: A14.D2 195.57,263.61 198.11,261.07 A14.E2
N$22  (via drill 0.61)
  Route2 0.254: v192.52,220.43 195.06,222.97 195.06,225.51 A14.T2
  Bottom 0.254: v192.52,220.43 193.03,220.94 228.08,220.94 228.59,221.45 234.68,221.45 236.21,222.97 239.25,222.97 A11.U2
N$23  (via drill 0.61)
  Route15 0.254: v215.89,234.66 195.06,255.49 195.06,257.01 A14.F2
  Bottom 0.254: v215.89,234.66 216.39,234.15 238.24,234.15 239.25,235.17 A11.P2
N$24  (via drill 0.61)
  Top 0.254: v177.79,177.76 177.79,161.51 176.77,160.49 176.77,156.93 177.79,156.93 177.79,96.99 178.8,95.97 C16.S1
  Bottom 0.254: v177.79,177.76 173.21,177.76 B16.K2
N$25
  Top 0.254: A14.V2 195.57,219.93 196.58,220.94 196.58,230.59 195.57,231.61 A14.R2
N$26
  Bottom 0.254: A14.S2 198.61,228.56 204.2,228.56 A14.S1
N$27
  Top 0.254: D15.S2 185.41,26.38 183.88,27.9 183.88,34 182.87,35.01 D15.N2
N$28  (via drill 0.61)
  Top 0.254: v215.89,114.77 215.38,115.28 215.38,127.47 212.84,130.01 212.84,145.76 209.28,149.31 209.28,158.97 v208.77,159.47
  Route2 0.254: v208.77,159.47 223.51,174.21 B12.L2
  Route15 0.254: v215.89,114.77 220.97,109.69 220.97,104.1 232.65,92.42 232.65,89.88 C12.U1
N$29
  Bottom 0.254: B16.D2 170.17,193.51 172.71,190.97 B16.E2
N$30  (via drill 0.61)
  Top 0.254: v155.94,173.19 155.94,128.99 156.96,127.98 C17.E2
  Route2 0.254: v155.94,173.19 169.66,186.91 B16.F2
N$31  (via drill 0.61)
  Top 0.254: v166.1,134.07 165.59,134.58 165.59,262.6 174.74,271.74 181.34,271.74 181.34,265.65 182.36,264.63 A15.D2 182.87,263.61 185.41,261.07 A15.E2
  Route2 0.254: v166.1,134.07 156.45,124.42 154.42,124.42 C17.F2
N$32  (via drill 0.61)
  Route2 0.254: v148.32,121.37 148.32,122.9 148.83,123.41 148.83,127.98 162.55,141.69 163.56,141.69 169.15,147.28 172.2,147.28 175.75,150.84 180.33,150.84 187.95,158.46 190.99,158.46 191.5,158.97 B15.S1
  Route15 0.254: v148.32,121.37 157.97,111.72 160.01,111.72 C17.L1
N$33  (via drill 0.61)
  Top 0.254: v276.34,191.99 276.34,215.86 280.4,219.93 280.4,222.47 A08.U2
  Route2 0.254: v249.41,166.59 254.49,171.67 254.49,172.17 255,172.68 257.03,172.68 v276.34,191.99
  Route15 0.254: v249.41,166.59 252.97,166.59 258.56,161 258.56,159.47 B10.S1
N$34
  Top 0.254: D16.T2 169.66,23.33 161.53,31.46 161.53,100.04 157.47,100.04 157.47,95.97 C17.S2
N$35  (via drill 0.61)
  Top 0.254: v257.03,104.61 257.03,120.36 254.49,122.9 254.49,126.96 255,127.47 255,128.99 254.49,129.5 v254.49,140.68 | v273.8,138.65 273.8,197.07 274.81,198.08 v274.81,229.58
  Route2 0.254: v257.03,104.61 254.49,102.07 252.97,102.07 C10.P2 | v274.81,229.58 274.81,230.09 275.83,231.1 275.83,233.13 v287,244.31
  Route15 0.254: v287,244.31 278.88,252.44 275.32,252.44 271.76,255.99 270.24,255.99 268.72,257.52 A09.F1
  Bottom 0.254: v254.49,140.68 257.03,138.14 273.29,138.14 v273.8,138.65
N$36
  Top 0.254: C14.P1 205.22,102.58 206.23,103.59 206.23,128.49 207.76,130.01 C13.D2
N$37
  Route15 0.254: B16.R2 170.17,161.51 170.67,161.51 172.71,159.47 B16.S2
N$38
  Top 0.254: C15.H1 192.52,121.37 193.53,122.39 193.53,128.49 192.01,130.01 192.01,133.57 C15.C1
N$39
  Top 0.254: C15.J1 188.45,118.33 188.45,123.91 C15.F1
N$40
  Top 0.254: D14.V2 196.07,16.73 197.6,18.25 197.6,37.55 198.11,38.06 D14.M2
N$41
  Route2 0.254: D14.V1 202.17,16.73 202.17,20.79 203.19,21.81 203.19,30.44 204.71,31.97 D14.P1
N$42
  Bottom 0.254: C11.L1 243.32,112.23 245.35,114.26 245.86,114.26 C11.K1
N$43
  Top 0.254: A12.T2 223.51,226.53 222.49,227.55 222.49,237.2 223.51,238.21 A12.N2
N$44  (via drill 0.61)
  Top 0.254: v241.79,121.37 241.79,106.13 242.3,105.63 C11.N1 | v236.71,126.45 235.19,127.98 v235.19,147.79
  Route15 0.254: v241.79,121.37 v236.71,126.45 | v235.19,147.79 233.67,147.79 230.62,150.84 229.09,150.84 227.57,152.36 B12.U2
N$45
  Top 0.254: A12.U2 226.55,222.97 226.55,228.56 A12.S2
N$46
  Top 0.254: A10.K1 259.06,248.37 263.64,248.37 263.64,249.39 265.16,250.91 267.7,250.91 A09.J1
N$47  (via drill 0.61)
  Top 0.254: v242.3,157.44 241.79,157.95 241.79,163.54 242.3,164.05 242.3,166.59 240.78,168.11 240.78,183.35 240.27,183.86 B11.H2
  Route2 0.254: v242.3,157.44 236.21,151.35 235.19,151.35 225.03,141.19 223.51,141.19 217.92,135.6 217.92,134.07 C13.C1
N$48  (via drill 0.61)
  Top 0.254: v240.27,105.63 240.78,106.13 240.78,117.31 237.73,120.36 237.73,150.84 233.67,154.9 233.67,158.46 B12.S1
  Route2 0.254: v240.27,105.63 243.32,102.58 245.86,102.58 C11.P1
N$49  (via drill 0.61)
  Top 0.254: v229.09,188.94 229.09,175.73 229.6,175.22 B12.L1
  Bottom 0.254: v229.09,188.94 229.6,189.45 235.19,189.45 236.21,190.46 239.25,190.46 B11.E2
N$50  (via drill 0.61)
  Route15 0.254: v193.53,99.02 192.01,100.55 192.01,101.56 C15.P1
  Bottom 0.254: v193.53,99.02 193.53,97.5 221.47,97.5 223,95.97 226.05,95.97 C12.S2
N$51  (via drill 0.61)
  Top 0.254: v228.59,143.22 228.59,125.95 229.6,124.93 C12.F1
  Route15 0.254: v228.59,143.22 228.59,144.23 224.01,148.81 B12.V2
N$52  (via drill 0.61)
  Top 0.254: v235.7,102.07 234.68,103.09 234.68,122.39 233.67,123.41 233.67,126.96 C12.E1
  Route15 0.254: v235.7,102.07 241.79,95.97 245.86,95.97 C11.S1
N$53
  Top 0.254: C15.R1 188.45,99.53 188.45,104.61 C15.N1
N$54
  Bottom 0.254: C12.H1 233.67,121.37 236.21,123.91 C11.F2
N$55
  Top 0.254: B12.E1 233.67,190.97 236.21,193.51 B11.D2
N$56
  Route2 0.254: B11.F2 236.71,187.92 238.75,187.92 240.78,189.95 240.78,191.99 242.3,193.51 B11.D1
N$58  (via drill 0.61)
  Top 0.254: v244.33,187.92 244.33,202.15 243.32,203.16 243.32,218.91 A11.V1
  Route15 0.254: v244.33,187.92 260.59,171.67 260.59,167.6 269.73,158.46 269.73,157.44 277.35,149.82 B08.V2
N$59
  Bottom 0.254: C13.V1 214.87,85.81 215.89,84.8 235.19,84.8 236.21,85.81 C11.V2
N$60
  Top 0.254: C12.N1 230.11,105.63 231.12,106.64 231.12,120.36 225.03,126.45 225.03,152.36 224.52,152.87 224.52,153.89 225.54,154.9 225.54,176.75 226.55,177.76 B12.K2
N$61  (via drill 0.61)
  Top 0.254: v203.69,111.21 203.69,137.12 206.23,139.66 206.23,147.28 203.69,149.82 203.69,156.43 v204.71,157.44