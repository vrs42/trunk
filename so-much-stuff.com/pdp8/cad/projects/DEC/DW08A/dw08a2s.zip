# EAGLE board dw08a2s (EAGLE 4.11), part 3 of 3
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
I_MB03  (via drill 0.61) (continued)
  Top 0.203: v220.46,106.13 221.35,106.13 v234.17,93.31 | v248.14,108.93 246.62,110.45 A06.J1 | v276.72,66.38 v300.21,42.89 | v309.1,103.09 308.47,103.09 301.61,109.94 299.96,109.94 299.2,110.71 A02.J1 | v250.18,109.69 251.19,109.69 v285.48,75.4
  Bottom 0.203: v220.46,106.13 215.63,101.31 215.63,101.05 214.62,100.04 214.62,99.02 A08.N2 | v234.17,93.31 236.59,93.31 247.25,103.97 247.25,108.04 v248.14,108.93 248.52,109.18 249.67,109.18 v250.18,109.69 | v300.21,42.89 299.07,41.74 299.07,41.62 B02.J1 | v276.72,66.38 276.72,67.02 285.29,75.59 | 285.29,75.59 297.29,87.59 297.67,87.59 307.58,97.5 307.58,99.4 309.1,100.93 v309.1,103.09 | v285.48,75.4 285.29,75.59
I_MB03\  (via drill 0.61)
  Top 0.203: v307.32,34.51 304.91,36.92 304.91,38.19 301.99,41.11 301.99,43.52 B02.H1 | v292.34,18.89 292.34,17.62 292.85,17.11 292.85,16.6 293.23,16.22 293.23,15.2 290.56,12.54 289.42,13.68 277.86,13.68 274.94,16.6 273.8,16.6 273.54,16.85 265.67,16.85 262.49,20.03 259.06,20.03 251.19,27.9 251.19,28.16 v249.79,29.55 | v239.38,24.09 237.09,26.38 236.84,26.38 235.32,27.9 235.32,28.16 214.87,48.6 212.46,48.6 211.06,50 211.06,51.65 208.27,54.45 207.38,54.45 204.07,57.75 204.07,62.57 204.84,63.34 203.69,64.48 203.19,64.48 v195.82,71.84 | v207.5,84.54 207.5,86.96 202.04,92.42 202.04,95.59 204.07,97.62 v205.09,96.61 | v219.19,111.85 219.19,111.98 217.79,113.37 A08.H2 | v243.7,109.44 242.81,110.32 242.81,111.47 v230.62,123.66 | v273.67,132.3 290.69,115.28 295.77,115.28 296.53,114.52 300.85,114.52 A02.H1
  Bottom 0.203: v307.32,34.51 305.8,32.98 305.8,32.35 v292.34,18.89 | v249.79,29.55 248.91,29.55 243.44,24.09 v239.38,24.09 | v195.82,71.84 195.82,72.86 v207.5,84.54 | v205.09,96.61 206.36,96.61 210.68,100.93 210.68,103.34 v219.19,111.85 219.19,112.23 v230.62,123.66 | v243.7,109.44 244.84,110.58 244.84,111.47 247.13,113.75 248.52,113.75 A06.H1 249.92,114.01 251.7,115.79 253.1,115.79 266.18,128.87 267.19,128.87 268.84,130.52 269.35,130.52 271.13,132.3 v273.67,132.3
I_MB04  (via drill 0.61)
  Top 0.203: v218.81,100.29 216.9,100.29 215.63,101.56 215.63,101.82 213.98,103.47 213.73,103.47 212.84,104.36 210.93,104.36 210.55,104.74 210.55,105.12 205.22,110.45 205.22,110.96 203.57,112.61 203.57,113.37 A09.H2 | v232.78,114.13 v246.49,100.42 | v301.1,34.76 301.23,34.63 301.23,32.35 B02.M1 | v304.15,37.81 299.45,42.51 299.45,43.14 297.55,45.05 297.17,45.05 276.97,65.24 276.59,65.24 v275.45,66.38 | v306.82,97.88 305.29,99.4 304.02,99.4 302.37,101.05 A02.M1 | v235.44,117.69 229.86,123.28 229.86,125.44 228.97,126.33 228.97,128.49 v229.09,128.61 | v262.75,137.5 282.94,137.5 310.63,109.82 311.52,109.82 v312.15,109.18
  Bottom 0.203: v218.81,100.29 218.93,100.29 v232.78,114.13 233.03,114.52 233.03,115.28 v235.44,117.69 | v246.49,100.42 247.89,100.42 248.52,101.05 A06.M1 | v304.15,37.81 v301.1,34.76 | v275.45,66.38 275.45,66.51 v306.82,97.88 306.82,102.07 312.15,107.4 v312.15,109.18 | v229.09,128.61 229.73,128.61 237.35,136.23 239.38,136.23 240.27,137.12 247.25,137.12 247.64,137.5 v262.75,137.5
I_MB04\  (via drill 0.61)
  Top 0.203: v219.82,80.86 218.68,82 218.17,82 A08.U2 | v296.28,32.98 296.28,33.62 295.13,34.76 294.5,34.76 v259.57,69.68 253.22,76.03 252.72,76.03 v233.67,95.08
  Bottom 0.203: v219.82,80.86 220.08,80.86 233.98,94.77 | 233.98,94.77 239,99.78 239.51,99.78 242.3,102.58 243.57,102.58 245.35,104.36 A06.L1 | v296.28,32.98 297.67,34.38 B02.L1 | 233.98,94.77 v233.67,95.08 | v259.57,69.68 259.7,69.68 273.29,83.27 273.67,83.27 275.96,85.56 276.21,85.56 298.18,107.53 299.07,106.64 299.07,105.75 298.82,105.5 298.82,105.37 A02.L1
I_MB05  (via drill 0.61)
  Top 0.203: v205.47,83.65 v209.66,79.46 | v233.41,101.82 233.41,101.18 243.7,90.89 244.84,90.89 245.35,90.39 247.25,90.39 248.52,89.12 A06.S1 249.54,87.97 251.19,86.32 251.19,85.05 253.99,82.26 253.99,81.75 259.7,76.03 259.7,71.21 269.86,61.05 270.62,61.05 271,60.67 271,60.54 271.32,60.22 | v303.13,21.93 303.13,27.78 277.1,53.81 277.1,54.45 271.32,60.22 | 271.32,60.22 v271.51,60.41
  Bottom 0.203: v205.47,83.65 204.58,82.77 203.95,82.77 A09.U2 | v209.66,79.46 210.93,79.46 224.01,92.54 224.52,92.54 232.65,100.67 232.65,101.05 v233.41,101.82 | v303.13,21.93 301.99,20.79 301.99,19.65 B02.S1 | v271.51,60.41 276.72,65.62 277.1,65.62 289.42,77.94 289.42,79.21 297.42,87.21 297.8,87.21 298.94,88.35 300.85,88.35 A02.S1
I_MB05\  (via drill 0.61)
  Top 0.203: v212.58,77.69 204.33,85.94 204.33,89.24 201.53,92.04 201.53,92.54 200.39,93.69 200.39,97.5 A09.N2 | v241.03,99.4 v247,93.43 247.25,93.05 255.26,85.05 v255.26,83.91 | 270.18,60.22 259.32,71.08 259.32,75.27 v254.37,80.23 | 270.18,60.22 301.23,29.17 301.23,26 B02.P1 | v304.4,100.29 304.4,101.94 v297.04,109.31 | v278.62,89.88 279,89.88 281.54,87.34 281.54,86.96 283.83,84.67 284.97,84.67 285.35,84.29 285.48,84.29 285.86,83.91 285.86,83.53 v287.39,82 | v272.53,65.88 272.53,65.49 v273.54,64.48 | 270.18,60.22 v270.24,60.29
  Bottom 0.203: v212.58,77.69 216.01,77.69 218.68,75.02 223.51,79.84 224.52,79.84 225.41,80.73 225.41,82.26 228.2,85.05 228.2,88.48 234.05,94.32 234.17,94.32 235.32,95.47 235.32,95.59 239.13,99.4 v241.03,99.4 | v247,93.43 247.25,93.43 248.52,94.7 A06.P1 | v254.37,80.23 254.37,83.02 v255.26,83.91 | v304.4,100.29 301.99,97.88 301.99,95.85 A02.P1 | v297.04,109.31 294.62,109.31 288.91,103.59 288.91,103.09 284.59,98.77 284.59,95.47 279.89,90.77 279.51,90.77 v278.62,89.88 | v287.39,82 286.88,82 284.59,79.72 284.59,78.7 273.04,67.14 273.04,66.38 v272.53,65.88 | v273.54,64.48 273.54,63.59 v270.24,60.29
I_MB06  (via drill 0.61)
  Top 0.203: v189.09,100.04 v203.19,85.94 | 256.59,85.24 253.73,88.1 253.73,88.86 251.19,91.4 251.19,91.66 249.16,93.69 247.89,93.69 v231.25,110.32 | 256.59,85.24 260.46,81.37 260.72,81.37 274.94,67.14 277.1,67.14 281.04,63.21 281.04,62.57 292.59,51.02 294.5,51.02 B02.E2 | 256.59,85.24 v256.78,85.43
  Bottom 0.203: v189.09,100.04 187.95,98.89 187.95,98.77 A10.N2 | v203.19,85.94 204.58,85.94 208.9,90.26 209.92,90.26 224.52,104.86 225.54,104.86 231.06,110.39 | 231.06,110.39 239.13,118.45 240.52,118.45 242.17,120.1 A06.E2 | v231.25,110.32 231.12,110.32 231.06,110.39 | v256.78,85.43 291.45,120.1 294.5,120.1 A02.E2
I_MB06\  (via drill 0.61)
  Top 0.203: v208.52,134.33 211.95,134.33 225.41,120.87 226.05,120.87 228.84,118.07 230.87,118.07 231.57,117.37 | 231.57,117.37 234.17,114.77 v234.3,114.77 | 261.67,85.88 254.62,92.93 253.1,92.93 246.62,99.4 246.37,99.4 245.73,100.04 245.73,100.29 233.92,112.1 233.67,112.1 232.01,113.75 232.01,114.64 231.51,115.15 231.51,117.31 231.57,117.37 | 261.67,85.88 283.7,63.84 284.85,63.84 292.47,56.22 292.47,54.57 B02.D2 | 261.67,85.88 v261.73,85.94
  Bottom 0.203: v208.52,134.33 190.36,116.17 190.36,114.9 A10.H2 | v234.3,114.77 234.3,115.91 234.81,116.42 235.32,116.42 236.21,117.31 236.21,118.45 237.73,119.98 237.73,121.25 239.38,122.9 A06.D2 | v261.73,85.94 266.56,90.77 267.19,90.77 273.16,96.74 273.67,96.74 287.77,110.83 288.02,110.83 296.53,119.34 296.53,120.99 294.24,123.28 292.85,123.28 A02.D2
I_MB07  (via drill 0.61)
  Top 0.203: v262.49,73.62 298.69,37.43 296.91,35.65 296.15,35.65 295.64,36.16 295.64,37.17 B02.K2 | v249.16,112.61 249.16,112.48 267.7,93.94 268.21,93.94 v275.83,86.32 | v177.02,109.82 177.4,109.82 207.5,79.72 207.5,79.34 v209.15,77.69
  Bottom 0.203: v262.49,73.62 263.13,73.62 273.16,83.65 273.54,83.65 276.02,86.13 | 276.02,86.13 290.69,100.8 290.69,101.56 293.23,104.1 293.23,105.37 294.88,107.02 A02.K2 | v249.16,112.61 247.25,110.71 247.25,110.45 246.62,109.82 246.49,109.82 244.84,108.17 243.57,108.17 A06.K2 242.17,107.4 240.52,105.75 239.13,105.75 225.16,91.78 225.16,91.4 223.63,89.88 223.25,89.88 211.06,77.69 v209.15,77.69 | v275.83,86.32 276.02,86.13 | v177.02,109.82 177.4,110.2 177.4,113.37 A11.H2
I_MB07\  (via drill 0.61)
  Top 0.203: v200.01,75.91 194.8,81.11 191.63,81.11 190.99,81.75 A10.U2 | 244.21,92.42 243.83,92.42 238.49,97.75 238.49,101.18 v232.78,106.9 | 244.21,92.42 244.46,92.42 244.84,92.04 244.84,91.4 245.48,90.77 247.38,90.77 248.27,89.88 249.79,89.88 254.37,85.31 254.37,81.88 261.86,74.38 262.88,74.38 265.54,71.72 267.19,71.72 268.97,69.94 269.23,69.94 271.64,67.53 272.02,67.53 275.07,64.48 276.72,64.48 284.59,56.6 284.59,53.3 285.48,52.41 285.99,52.41 287.77,50.63 287.77,50.13 293.23,44.67 294.5,44.67 B02.H2 | v281.04,101.18 278.12,101.18 270.37,108.93 265.92,108.93 v264.53,110.32 | 244.21,92.42 v244.21,92.93
  Bottom 0.203: v200.01,75.91 200.39,75.91 212.71,88.23 212.96,88.23 220.08,95.34 221.85,95.34 233.09,106.58 | 233.09,106.58 239,112.48 240.9,112.48 242.17,113.75 A06.H2 | 233.09,106.58 v232.78,106.9 | v281.04,101.18 281.42,101.56 281.42,101.94 286.12,106.64 289.42,106.64 294.88,112.1 294.88,113.37 A02.H2 | v264.53,110.32 261.86,110.32 244.84,93.31 244.59,93.31 v244.21,92.93
I_MB08  (via drill 0.61)
  Top 0.203: v183.12,89.88 184.64,89.88 188.45,86.07 188.45,82.77 193.15,78.07 196.71,78.07 v203.19,71.59 | v306.06,37.43 306.06,38.19 303.64,40.6 303.64,43.4 v303.26,43.78 | v311.13,52.29 310.5,52.29 304.66,58.13 304.66,58.64 300.47,62.83 300.47,63.72 297.42,66.76 297.42,67.02 v291.7,72.73 | v284.85,67.02 281.67,67.02 v277.86,70.83 | v234.43,88.23 234.43,88.1 v263.51,59.02
  Bottom 0.203: v183.12,89.88 178.17,84.92 178.17,83.15 A11.U2 | v203.19,71.59 204.96,71.59 208.9,75.53 210.68,75.53 211.06,75.91 217.16,75.91 219.57,73.49 234.36,88.29 | 234.36,88.29 239.13,93.05 240.52,93.05 242.17,94.7 A06.P2 | v306.06,37.43 304.53,35.9 304.28,35.9 295.64,27.27 295.64,26 B02.P2 | v303.26,43.78 303.51,43.78 310.12,50.38 310.12,51.27 v311.13,52.29 | v291.7,72.73 290.56,72.73 v284.85,67.02 | v277.86,70.83 277.35,70.83 273.42,66.89 273.42,65.62 272.91,65.11 272.15,65.11 270.81,66.45 | 270.81,66.45 270.5,66.76 288.91,85.18 289.67,85.18 291.2,86.7 291.2,87.85 297.55,94.2 297.55,94.96 296.53,95.97 296.02,95.47 A02.P2 | v263.51,59.02 263.51,59.14 270.81,66.45 | 234.36,88.29 v234.43,88.23
I_MB08\  (via drill 0.61)
  Top 0.203: v294.75,34 294.88,33.87 294.88,32.35 B02.M2 | v296.53,36.41 296.53,39.08 281.8,53.81 281.54,53.81 270.5,64.86 269.99,64.86 v268.46,66.38 | v296.78,94.58 296.78,96.35 v293.74,99.4 | v207.76,128.23 212.84,128.23 228.46,112.61 230.11,112.61 232.14,110.58 232.14,110.45 239.13,103.47 240.52,103.47 242.17,101.82 A06.M2 | v275.45,74.89 275.32,74.89 270.75,79.46 270.37,79.46 268.72,81.11 267.7,81.11 262.11,86.7 261.35,86.7 v245.1,102.96
  Bottom 0.203: v294.75,34 294.75,34.63 v296.53,36.41 | v268.46,66.38 269.1,66.38 276.53,73.81 | 276.53,73.81 288.4,85.69 288.4,86.19 v296.78,94.58 | v293.74,99.4 293.74,99.53 294.88,100.67 A02.M2 | v207.76,128.23 178.17,98.64 175.37,98.64 A11.N2 | v245.1,102.96 244.71,102.96 243.57,101.82 A06.M2 | v275.45,74.89 276.53,73.81
I_MB09  (via drill 0.61)
  Top 0.203: v306.56,32.6 306.56,34.63 305.29,35.9 304.91,35.9 303.39,37.43 303.39,38.06 299.07,42.38 299.07,43.02 297.42,44.67 297.04,44.67 276.85,64.86 275.83,64.86 v274.18,66.51 273.92,66.89 273.92,67.65 270.88,70.7 270.37,70.7 256.02,85.05 256.02,85.31 253.35,87.97 253.35,88.35 v248.78,92.93 | v168.39,115.79 172.2,115.79 209.92,78.07 211.06,78.07 212.2,76.92 215.25,76.92 v222.87,69.3
  Bottom 0.203: v306.56,32.6 295.64,21.68 295.64,19.65 B02.S2 | v274.18,66.51 274.43,66.51 275.07,67.14 275.32,67.14 293.23,85.05 293.23,86.32 294.88,87.97 A02.S2 | v168.39,115.79 167.12,114.52 165.85,114.52 A12.H2 | v222.87,69.3 223.51,69.3 224.01,69.81 225.28,69.81 231.51,76.03 231.89,76.03 240.9,85.05 240.9,86.32 242.56,87.97 A06.S2 243.57,89.12 245.22,90.77 246.62,90.77 v248.78,92.93
I_MB10  (via drill 0.61)
  Top 0.203: v163.69,96.35 162.42,97.62 A12.N2 | v175.63,108.29 177.66,106.26 178.04,106.26 178.42,105.88 178.42,105.37 179.06,104.74 179.06,104.23 212.46,70.83 212.96,70.83 v217.41,66.38 | v238.11,87.08 239.13,86.07 A06.T2 | 255.95,52.73 250.68,58 250.56,58 250.18,58.38 250.18,59.02 239.89,69.3 239.25,69.3 v229.86,78.7 | 255.95,52.73 263.64,45.05 264.4,45.05 292.47,16.98 292.47,16.47 B02.T2 | v290.43,87.08 291.45,86.07 A02.T2 | 255.95,52.73 v256.02,52.79
  Bottom 0.203: v163.69,96.35 v175.63,108.29 | 229.79,78.77 v238.11,87.08 | v217.41,66.38 229.79,78.77 | 229.79,78.77 v229.86,78.7 | v290.43,87.08 290.31,87.08 v256.02,52.79
I_MB11  (via drill 0.61)
  Top 0.203: v315.45,35.4 315.45,40.35 v310.63,45.17 | v316.6,55.33 316.6,56.35 314.82,58.13 314.56,58.13 313.29,59.4 313.29,59.65 308.47,64.48 306.69,64.48 292.59,78.57 A02.V2 | v209.92,46.7 209.28,46.7 195.82,60.16 195.31,60.16 190.99,64.48 189.47,64.48 184.26,69.68 182.23,69.68 181.72,70.19 178.93,70.19 168.77,80.35 167.5,80.35 165.85,82 A12.U2 | v287.77,74.38 287.77,72.35 v289.55,70.57 | v271.64,55.72 268.46,55.72 264.02,60.16 263.38,60.16 260.72,62.83 260.72,63.34 248.78,75.27 v248.78,75.4 | v245.98,73.49 245.73,73.49 240.4,78.83 A06.V2
  Bottom 0.203: v315.45,35.4 292.47,12.41 292.47,10.12 B02.V2 | v310.63,45.17 310.63,45.3 312.28,46.95 312.28,49.87 312.53,50.13 312.53,51.27 v316.6,55.33 | v209.92,46.7 209.92,46.83 217.41,54.32 218.04,54.32 218.68,54.95 218.68,57.11 220.58,59.02 221.22,59.02 231.12,68.92 231.12,69.68 239.38,77.94 239.38,78.45 A06.V2 | v287.77,74.38 291.7,78.32 291.7,78.45 A02.V2 | v289.55,70.57 285.23,66.26 283.83,66.26 281.8,64.22 280.15,64.22 v271.64,55.72 | v248.78,75.4 247.89,75.4 v245.98,73.49
I_MBINCR  (via drill 0.61)
  Top 0.203: v262.88,17.23 264.02,16.09 265.92,16.09 B04.T2 | v241.41,3.01 238.11,3.01 237.73,2.63 237.22,2.63 236.59,3.26 236.59,3.39 229.09,10.88 v228.97,10.88 | 161.78,2.5 145.02,2.5 144.64,2.88 144,2.88 143.24,3.65 130.29,3.65 v107.55,26.38 | v213.73,2.5 161.78,2.5 | v101.08,25.11 100.19,25.11 86.22,39.08 82.92,39.08 71.87,50.13 71.87,51.4 70.22,53.05 B19.D2 | v257.16,75.91 254.62,75.91 v253.73,76.8 | v248.02,69.3 247.76,69.3 v245.22,71.84 | v243.7,71.84 243.06,71.84 v234.55,80.35 | 161.78,2.5 v161.78,6.57
  Bottom 0.203: v262.88,17.23 258.43,17.23 250.18,8.98 247.38,8.98 v241.41,3.01 | v228.97,10.88 226.3,10.88 218.3,2.88 214.11,2.88 v213.73,2.5 | v107.55,26.38 102.35,26.38 v101.08,25.11 | v257.16,75.91 266.18,84.92 A04.T2 | v253.73,76.8 253.73,76.16 253.6,76.03 253.6,74.89 v248.02,69.3 | v243.7,71.84 v245.22,71.84 | v234.55,80.35 232.78,80.35 213.09,60.67 213.09,58.64 211.44,56.98 211.44,56.1 208.27,52.92 207.63,52.92 206.74,52.03 206.23,52.03 202.93,48.73 202.8,48.73 202.42,48.35 202.42,47.21 v161.78,6.57
I_RUN  (via drill 0.61)
  Top 0.203: v247.38,50.38 247.38,50.25 261.86,35.78 261.86,35.27 262.24,34.89 262.37,34.89 275.57,21.68 275.96,21.68 280.78,16.85 286.24,16.85 286.37,16.73 287,17.36 287,18.12 286.62,18.5 283.32,18.5 B03.S2 | v144.26,36.41 138.42,42.25 138.42,43.52 B14.H2 | v193.79,75.53 208.77,60.54 210.04,60.54 225.66,44.92 225.66,44.16 228.2,41.62 228.2,40.35 229.86,38.7 B07.K2
  Bottom 0.203: B07.K2 230.87,37.55 232.52,37.55 245.35,50.38 v247.38,50.38 247.38,52.54 265.03,70.19 267.19,70.19 281.67,84.67 281.67,85.31 282.18,85.81 282.18,87.97 A03.S2 | v144.26,36.41 153.4,36.41 156.45,39.46 157.59,39.46 173.47,55.33 173.47,55.72 180.2,62.45 180.71,62.45 v193.79,75.53
I_SKIP  (via drill 0.61)
  Top 0.203: v141.59,99.78 v137.02,99.78 | v169.28,121.63 v182.48,121.63 | v230.49,138.9 260.08,138.9 277.42,121.56 | 277.42,121.56 v285.74,113.25 | v313.42,53.3 316.09,50.63 316.09,48.73 317.87,46.95 317.87,20.79 311.64,14.57 304.28,14.57 299.58,19.27 299.58,22.57 284.59,37.55 283.32,37.55 B03.K2 | v315.96,67.53 315.96,68.29 v309.61,74.64 | v316.72,82.64 316.72,90.77 297.42,110.07 295.39,110.07 289.16,116.29 288.53,116.29 283.19,121.63 277.48,121.63 277.42,121.56
  Bottom 0.203: v137.02,99.78 136.64,99.4 134.35,99.4 105.52,70.57 103.87,70.57 98.16,64.86 97.78,64.86 94.98,62.06 94.47,62.06 88.5,56.1 88,56.1 86.09,54.19 83.3,54.19 B18.D2 | v141.59,99.78 141.59,100.29 143.88,102.58 147.69,102.58 148.7,101.56 160.51,113.37 161.02,113.37 v169.28,121.63 | v182.48,121.63 183.12,121.63 196.2,134.71 199.5,134.71 201.41,136.61 202.55,136.61 205.6,139.66 229.73,139.66 v230.49,138.9 | v285.74,113.25 285.74,112.61 284.59,111.47 284.59,110.2 282.94,108.55 A03.K2 | v313.42,53.3 313.42,53.94 316.6,57.11 316.6,58 316.98,58.38 316.98,62.7 317.61,63.34 317.61,65.88 v315.96,67.53 | v309.61,74.64 309.61,75.53 v316.72,82.64
I_TS1  (via drill 0.61)
  Top 0.203: v249.29,35.14 250.05,35.14 v250.81,34.38 | v269.61,52.54 270.37,52.54 273.1,49.81 | 273.1,49.81 278.12,44.79 278.12,44.54 299.96,22.7 299.96,22.19 302.75,19.39 302.75,18.12 304.4,16.47 B01.T2 | v305.67,83.02 305.17,83.53 305.17,84.8 A01.T2 | 273.1,49.81 v273.16,49.87
  Bottom 0.203: v249.29,35.14 246.75,35.14 B06.L1 | v250.81,34.38 250.81,35.01 254.87,39.08 254.87,39.71 266.94,51.78 268.84,51.78 v269.61,52.54 | v305.67,83.02 305.67,82.64 291.7,68.67 291.7,68.41 v273.16,49.87
I_TS3  (via drill 0.61)
  Top 0.203: v247.76,39.97 247,40.73 246.75,40.73 B06.J1 | v258.94,50.89 259.95,50.89 v264.53,46.32 264.78,45.94 270.24,40.48 270.24,39.71 285.86,24.09 v286.75,24.09 | v297.55,26.25 304.53,19.27 307.2,19.27 B01.S2
  Bottom 0.203: v247.76,39.97 248.02,39.97 v258.94,50.89 | v264.53,46.32 268.46,46.32 272.78,50.63 273.16,50.63 296.28,73.75 296.28,74.89 306.94,85.56 306.94,87.34 307.58,87.97 A01.S2 | v297.55,26.25 297.55,25.87 295.77,24.09 v286.75,24.09
I_TT_INST  (via drill 0.61)
  Top 0.203: v269.73,8.85 268.84,8.85 267.19,10.5 266.94,10.5 249.03,28.41 247.76,28.41 v236.71,39.46 | v158.61,7.96 155.18,11.39 150.23,11.39 135.24,26.38 135.24,27.65 B14.N2 | v207.88,53.68 208.14,53.68 210.68,51.14 210.68,49.37 226.43,33.62 227.82,33.62 229.47,31.97 B07.M2 | v268.34,80.35 v270.62,78.07 | v243.95,46.7 v239.51,51.14
  Bottom 0.203: v269.73,8.85 276.21,15.33 278.62,15.33 B03.T2 | B07.M2 230.49,32.35 232.14,34 232.14,35.27 236.33,39.46 v236.71,39.46 236.71,39.84 243.57,46.7 v243.95,46.7 | v158.61,7.96 162.16,7.96 194.8,40.6 194.8,43.9 202.68,51.78 205.47,51.78 206.11,52.41 206.61,52.41 v207.88,53.68 | v270.62,78.07 273.54,78.07 279,83.53 279,84.8 A03.T2 | v268.34,80.35 266.18,80.35 265.54,79.72 265.54,77.81 256.27,68.54 256.27,67.65 240.14,51.52 239.89,51.52 v239.51,51.14
I_WCOV  (via drill 0.61)
  Top 0.203: v236.46,8.6 229.73,15.33 227.7,15.33 B07.T2 | v145.65,11.39 143.88,11.39 138.67,16.6 137.15,16.6 134.35,19.39 133.84,19.39 125.59,27.65 124.57,27.65 124.19,28.03 122.92,28.03 B15.N2 | v177.15,40.09 178.55,40.09 197.72,20.92 197.72,20.54 v210.04,8.22 | v254.37,92.04 254.49,92.04 260.34,86.19 260.34,85.69 263.13,82.89 263.13,80.61 v267.7,76.03 | v245.73,51.4 245.73,50.89 256.65,39.97 256.65,38.95 v260.08,35.52
  Bottom 0.203: v236.46,8.6 237.22,8.6 251.83,23.2 253.22,23.2 254.87,24.85 B05.P2 255.89,26 256.53,26.63 256.53,27.39 256.91,27.78 256.91,29.3 260.08,32.47 v260.08,35.52 | v145.65,11.39 146.29,11.39 160.13,25.23 162.29,25.23 v177.15,40.09 | v210.04,8.22 216.27,8.22 216.65,8.6 218.17,8.6 223.25,13.68 224.65,13.68 226.3,15.33 B07.T2 | v254.37,92.04 255.26,92.93 255.26,94.32 A05.P2 | v267.7,76.03 267.7,73.37 v245.73,51.4
N$1  (via drill 0.61)
  Top 0.203: v227.7,57.49 227.95,57.49 229.6,55.84 v231.89,55.84
  Bottom 0.203: v227.7,57.49 222.62,52.41 222.62,51.78 218.93,48.09 218.93,47.21 217.79,46.06 217.79,45.05 B08.H2 | v231.89,55.84 240.02,55.84 242.3,58.13 243.7,58.13 245.35,59.78 B06.B1
N$2  (via drill 0.61)
  Top 0.203: v218.68,26.89 217.54,28.03 215,28.03 B08.N2
  Bottom 0.203: v218.68,26.89 222.87,26.89 243.44,47.46 244.33,47.46 245.48,48.6 246.87,48.6 248.52,50.25 B06.E1
N$3
  Bottom 0.203: B08.U2 218.17,12.92 219.57,12.92 247.25,40.6 247.25,41.87 248.91,43.52 B06.H1
N$4  (via drill 0.61)
  Top 0.203: v212.84,51.52 v236.08,28.28
  Bottom 0.203: v236.08,28.28 245.35,37.55 248.52,37.55 B06.K1 | v212.84,51.52 211.82,51.52 211.06,50.76 211.06,50.51 206.87,46.32 205.6,46.32 203.95,44.67 B09.H2
N$5  (via drill 0.61)
  Top 0.203: v217.79,47.71 217.79,47.08 229.98,34.89 230.74,34.89 v239.25,26.38
  Bottom 0.203: v217.79,47.71 217.66,47.71 200.39,30.44 200.39,29.17 B09.N2 | v239.25,26.38 240.78,26.38 241.16,26.76 242.68,26.76 245.48,29.55 246.87,29.55 248.52,31.2 B06.M1
N$6  (via drill 0.61)
  Top 0.203: v213.98,19.27 213.98,18.89 223.25,9.61 223.89,9.61 v226.93,6.57
  Bottom 0.203: v213.98,19.27 207.63,12.92 203.95,12.92 B09.U2 | v226.93,6.57 242.94,22.57 244.33,22.57 245.35,23.58 246.87,23.58 248.52,25.23 B06.P1
O_3CYCLE  (via drill 0.61)
  Top 0.203: v74.66,48.6 74.66,52.54 67.55,59.65 67.55,60.8 65.52,62.83 65.52,69.05 65.39,69.18 65.39,71.72 62.21,74.89 62.21,76.67 60.44,78.45 60.44,78.96 35.29,104.1 35.29,105.37 33.64,107.02 A22.K2
  Bottom 0.203: v74.66,48.6 73.39,47.33 73.39,45.05 B19.H2
O_AC00  (via drill 0.61)
  Top 0.203: v73.39,96.61 81.39,88.61 81.39,85.05 83.55,82.89 83.55,82.38 112.38,53.56 112.38,51.4 B16.E2
  Bottom 0.203: v73.39,96.61 73.39,100.16 93.2,119.98 93.2,121.25 94.85,122.9 A17.D2
O_AC01  (via drill 0.61)
  Top 0.203: v133.59,65.75 133.59,66.64 131.94,68.29 131.94,72.61 94.09,110.45 94.09,117.82 97.39,121.12 97.65,120.87 A17.E2
  Bottom 0.203: v133.59,65.75 132.95,65.11 132.95,62.83 124.06,53.94 124.06,53.18 115.55,44.67 113.4,44.67 B16.H2
O_AC02  (via drill 0.61)
  Top 0.203: v114.03,40.73 114.03,44.79 91.04,67.78 91.04,69.05 81.39,78.7 81.39,83.91 v75.04,90.26
  Bottom 0.203: v114.03,40.73 113.02,39.71 113.02,38.7 B16.K2 | v75.04,90.26 75.04,92.42 94.73,112.1 96,112.1 97.65,113.75 A17.H2
O_AC03  (via drill 0.61)
  Top 0.203: v117.46,40.98 117.46,42.63 100.44,59.65 100.44,63.34 v88.25,75.53 | v102.73,103.59 102.73,105.12 102.09,105.75 100.82,105.75 99.17,107.4 A17.K2
  Bottom 0.203: v117.46,40.98 113.02,36.54 113.02,32.35 B16.M2 | v88.25,75.53 88.25,76.92 99.55,88.23 99.55,100.42 v102.73,103.59
O_AC04  (via drill 0.61)
  Top 0.203: v119.36,34 119.36,34.25 113.27,40.35 113.27,42 108.32,46.95 108.32,49.37 v105.52,52.16 | v120,73.24 120,73.37 111.49,81.88 111.49,85.69 109.71,87.46 109.71,88.48 100.44,97.75 100.44,99.02 98.79,100.67 A17.M2
  Bottom 0.203: v119.36,34 113.02,27.65 113.02,26 B16.P2 | v105.52,52.16 105.52,56.1 105.9,56.48 105.9,59.52 113.65,67.27 114.03,67.27 v120,73.24
O_AC05  (via drill 0.61)
  Top 0.203: v120.38,34.76 120.38,41.24 108.32,53.3 108.32,55.33 103.11,60.54 103.11,61.81 88.63,76.29 88,76.29 v85.58,78.7
  Bottom 0.203: v120.38,34.76 120.25,34.63 120.25,31.08 113.02,23.84 113.02,19.65 B16.S2 | v85.58,78.7 85.58,80.61 96.38,91.4 96.38,92.67 98.03,94.32 A17.P2
O_AC06  (via drill 0.61)
  Top 0.203: v82.15,69.43 85.2,66.38 85.58,66.38 98.03,53.94 98.03,51.4 B17.E2
  Bottom 0.203: v82.15,69.43 82.15,74.13 94.73,86.7 96,86.7 97.65,88.35 A17.S2
O_AC07  (via drill 0.61)
  Top 0.203: v114.03,66.51 114.03,66.76 109.84,70.95 109.84,72.61 98.92,83.53 97.65,83.53 96,85.18 A17.T2
  Bottom 0.203: v114.03,66.51 106.28,58.76 106.28,51.78 105.9,51.4 105.9,50.13 100.44,44.67 99.17,44.67 B17.H2
O_AC08  (via drill 0.61)
  Top 0.203: v102.73,44.79 102.09,44.79 95.23,51.65 95.23,52.16 94.09,53.3 94.09,56.73 v85.2,65.62
  Bottom 0.203: v102.73,44.79 98.79,40.86 98.79,38.7 B17.K2 | v85.2,65.62 85.2,68.8 94.85,78.45 A17.V2
O_AC09  (via drill 0.61)
  Top 0.203: v57.26,88.48 59.17,86.58 59.17,81.88 60.82,80.23 60.82,78.57 77.71,61.68 77.71,60.41 84.57,53.56 84.57,50.13 90.54,44.16 90.54,43.65 90.92,43.27 90.92,41.11 98.03,34 98.03,32.35 B17.M2
  Bottom 0.203: v57.26,88.48 57.26,90.39 74.15,107.28 74.15,113.63 80.5,119.98 80.5,121.25 82.15,122.9 A18.D2
O_AC10  (via drill 0.61)
  Top 0.203: v103.11,28.28 103.11,29.43 91.3,41.24 91.3,43.4 90.92,43.78 90.92,47.97 88.5,50.38 88.5,52.54 87.74,53.3 87.74,56.98 v78.34,66.38 | v93.2,92.29 93.2,104.48 87.36,110.32 87.36,110.83 84.57,113.63 84.57,118.96 85.33,119.72 A18.E2
  Bottom 0.203: v103.11,28.28 100.44,25.62 99.17,25.62 B17.P2 | v78.34,66.38 78.34,72.86 84.06,78.57 84.06,83.15 v93.2,92.29
O_AC11  (via drill 0.61)
  Top 0.203: v69.45,38.19 72.88,34.76 73.52,34.76 78.72,29.55 83.04,29.55 84.19,28.41 86.09,28.41 95.23,19.27 97.65,19.27 B17.S2 | v104.89,78.83 104.89,80.61 103.62,81.88 103.62,94.07 100.06,97.62 100.06,98.13 87.74,110.45 87.74,111.72 86.09,113.37 A18.H2
  Bottom 0.203: v69.45,38.19 69.45,39.08 77.33,46.95 77.33,51.27 v104.89,78.83
O_ACCEPT  (via drill 0.61)
  Top 0.203: v62.85,89.88 102.35,50.38 103.36,50.38 v110.09,43.65
  Bottom 0.203: v62.85,89.88 62.09,89.12 61.07,89.12 A20.S2 | v110.09,43.65 110.35,43.65 118.48,51.78 119.87,51.78 121.52,53.43 B15.D2
O_ACCLR  (via drill 0.61)
  Top 0.203: v68.69,55.46 68.69,53.3 71.49,50.51 71.49,50 83.17,38.32 84.95,38.32 B18.K2 | v93.2,80.73 93.2,85.94 87.74,91.4 87.74,92.67 86.09,94.32 A18.P2
  Bottom 0.203: v68.69,55.46 69.33,55.46 89.01,75.15 89.01,76.54 v93.2,80.73
O_ADD00  (via drill 0.61)
  Top 0.203: v86.85,87.08 86.85,92.29 84.57,94.58 84.57,106.77 74.66,116.67 74.66,117.18 71.87,119.98 71.87,121.25 70.22,122.9 A19.D2
  Bottom 0.203: v86.85,87.08 83.68,83.91 83.68,78.7 70.98,66 70.98,59.65 62.34,51.02 61.07,51.02 B20.E2
O_ADD01  (via drill 0.61)
  Top 0.203: v58.41,46.32 59.8,44.92 B20.H2 | v90.41,91.78 90.41,101.43 75.04,116.8 75.04,118.07 73.39,119.72 A19.E2
  Bottom 0.203: v58.41,46.32 58.41,58 77.33,76.92 77.33,78.7 v90.41,91.78
O_ADD02  (via drill 0.61)
  Top 0.203: v30.72,70.07 55.99,44.79 55.99,40.6 58.28,38.32 59.55,38.32 B20.K2
  Bottom 0.203: v30.72,70.07 30.72,70.19 70.98,110.45 70.98,111.72 72.63,113.37 A19.H2
O_ADD03  (via drill 0.61)
  Top 0.203: v32.37,66.13 41.64,56.86 41.64,46.95 46.34,42.25 49.77,42.25 56.12,35.9 57.64,35.9 59.93,33.62 59.93,32.35 B20.M2
  Bottom 0.203: v32.37,66.13 32.37,67.02 53.58,88.23 53.58,90 69.33,105.75 70.6,105.75 72.25,107.4 A19.K2
O_ADD04  (via drill 0.61)
  Top 0.203: v28.94,54.83 28.94,46.95 43.16,32.73 46.59,32.73 53.71,25.62 59.55,25.62 B20.P2
  Bottom 0.203: v28.94,54.83 63.61,89.5 63.61,90.39 70.98,97.75 70.98,99.02 72.63,100.67 A19.M2
O_ADD05  (via drill 0.61)
  Top 0.203: v103.87,60.92 103.87,61.56 83.17,82.26 83.17,82.77 81.01,84.92 81.01,85.43 75.04,91.4 75.04,92.67 73.39,94.32 A19.P2
  Bottom 0.203: v103.87,60.92 103.87,60.8 85.33,42.25 82.03,42.25 80.12,40.35 79.61,40.35 60.69,21.43 60.69,19.65 B20.S2
O_ADD06  (via drill 0.61)
  Top 0.203: v76.82,83.15 76.82,83.27 75.04,85.05 75.04,86.32 73.39,87.97 A19.S2
  Bottom 0.203: v76.82,83.15 46.34,52.67 46.34,51.4 B21.E2
O_ADD07  (via drill 0.61)
  Top 0.203: v76.57,77.3 76.44,77.3 71.87,81.88 71.87,83.15 70.22,84.8 A19.T2
  Bottom 0.203: v76.57,77.3 46.34,47.08 46.34,45.05 B21.H2
O_ADD08  (via drill 0.61)
  Top 0.203: v71.74,75.91 71.74,76.92 70.22,78.45 A19.V2
  Bottom 0.203: v71.74,75.91 67.3,71.46 67.3,69.3 61.45,63.46 61.45,62.83 43.55,44.92 45.7,42.76 45.7,38.7 B21.K2
O_ADD09  (via drill 0.61)
  Top 0.203: v19.42,80.73 23.86,76.29 23.86,66.13 24.24,65.75 24.24,62.83 28.18,58.89 28.18,54.45 28.56,54.06 28.56,46.83 43.42,31.97 45.32,31.97 B21.M2
  Bottom 0.203: v19.42,80.73 19.42,84.16 20.18,84.92 20.18,86.07 57.01,122.9 A20.D2
O_ADD10  (via drill 0.61)
  Top 0.203: v23.48,62.95 25.13,61.3 25.13,59.52 25.38,59.27 25.38,56.35 28.18,53.56 28.18,46.7 45.7,29.17 45.7,26 B21.P2
  Bottom 0.203: v23.48,62.95 23.48,63.97 25.77,66.26 25.77,66.76 47.23,88.23 47.23,92.54 58.66,103.97 58.66,110.83 61.45,113.63 61.45,118.96 60.69,119.72 A20.E2
O_ADD11  (via drill 0.61)
  Top 0.203: v15.48,53.05 45.7,22.82 45.7,19.65 B21.S2
  Bottom 0.203: v15.48,53.05 15.48,61.3 58.28,104.1 58.28,111.72 59.93,113.37 A20.H2
O_BAC00  (via drill 0.61)
  Top 0.203: v158.74,109.69 147.94,120.48 147.94,122.9 A13.D2 | v197.98,65.88 v158.74,105.12
  Bottom 0.203: v158.74,105.12 v158.74,109.69 | v197.98,65.88 197.72,65.88 189.34,57.49 189.34,57.11 188.2,55.97 188.2,55.08 187.69,54.57 B10.D2
O_BAC01  (via drill 0.61)
  Top 0.203: v201.03,69.43 157.47,112.99 156.58,112.99 151.12,118.45 151.12,119.72 A13.E2 | v183.75,47.21 183.75,46.32 188.45,41.62 188.45,40.35 190.1,38.7 B10.K2
  Bottom 0.203: v201.03,69.43 200.39,69.43 197.22,66.26 197.22,65.88 188.96,57.62 188.96,57.24 186.17,54.45 186.17,49.62 v183.75,47.21
O_BAC02  (via drill 0.61)
  Top 0.203: v186.29,72.22 182.1,76.42 181.47,76.42 175.88,82 175.88,82.64 175.75,82.77 175.75,86.07 159.5,102.32 159.5,103.09 151.12,111.47 151.12,113.37 A13.H2 | v164.7,47.71 164.7,46.32 188.45,22.57 188.45,21.3 190.1,19.65 B10.S2
  Bottom 0.203: v186.29,72.22 186.29,70.45 186.17,70.32 186.17,70.07 178.29,62.19 176.13,62.19 175.88,61.94 173.98,61.94 169.28,57.24 169.28,56.48 167.12,54.32 167.12,50.13 v164.7,47.71
O_BAC03  (via drill 0.61)
  Top 0.203: v186.93,69.94 151.12,105.75 151.12,107.02 A13.K2 | v172.83,56.22 172.83,55.97 174.23,54.57 B11.D2
  Bottom 0.203: v186.93,69.94 186.55,69.94 v172.83,56.22
O_BAC04  (via drill 0.61)
  Top 0.203: v134.48,81.75 160.77,55.46 160.77,53.3 175.75,38.32 177.02,38.32 B11.K2
  Bottom 0.203: v134.48,81.75 135.24,81.75 149.46,95.97 149.46,99.66 150.48,100.67 A13.M2
O_BAC05  (via drill 0.61)
  Top 0.203: v125.33,68.03 148.58,44.79 148.58,44.29 162.55,30.32 163.56,30.32 166.1,27.78 166.74,27.78 175.25,19.27 177.02,19.27 B11.S2
  Bottom 0.203: v125.33,68.03 125.46,68.03 148.83,91.4 148.83,92.67 150.48,94.32 A13.P2
O_BAC06  (via drill 0.61)
  Top 0.203: v141.72,76.16 148.58,69.3 148.58,68.16 161.53,55.21 161.53,54.57 B12.D2
  Bottom 0.203: v141.72,76.16 141.72,77.05 144,79.34 144,79.72 146.04,81.75 146.04,82.26 148.83,85.05 148.83,86.32 150.48,87.97 A13.S2
O_BAC07  (via drill 0.61)
  Top 0.203: v171.56,45.81 149.46,67.91 149.34,67.91 148.96,68.29 148.96,69.43 143.62,74.77 143.62,79.34 v143.24,79.72
  Bottom 0.203: v171.56,45.81 171.18,45.43 170.93,45.43 165.47,39.97 165.47,38.7 B12.K2 | v143.24,79.72 143.5,79.72 145.65,81.88 145.65,83.15 147.31,84.8 A13.T2
O_BAC08  (via drill 0.61)
  Top 0.203: v126.48,61.43 126.6,61.3 129.14,61.3 136.89,53.56 136.89,50.13 154.16,32.86 154.16,32.35 159.88,26.63 159.88,23.71 160.77,22.82 160.77,21.55 162.04,20.28 162.55,20.28 163.56,19.27 164.32,19.27 B12.S2
  Bottom 0.203: v126.48,61.43 127.11,61.43 132.95,67.27 135.37,67.27 146.92,78.83 A13.V2
O_BAC09  (via drill 0.61)
  Top 0.203: v110.73,90.77 110.73,87.72 112.89,85.56 112.89,84.8 133.08,64.6 134.61,64.6 137.4,61.81 137.91,61.81 143.88,55.84 145.27,55.84 146.92,54.19 B13.D2
  Bottom 0.203: v110.73,90.77 111.11,91.15 111.11,95.72 134.61,119.21 134.61,122.9 A14.D2
O_BAC10  (via drill 0.61)
  Top 0.203: v108.32,86.45 108.32,82.64 112.38,78.57 113.02,78.57 123.17,68.41 123.81,68.41 139.18,53.05 139.18,51.27 148.83,41.62 148.83,40.35 150.48,38.7 B13.K2
  Bottom 0.203: v108.32,86.45 111.49,89.62 111.49,95.59 136,120.1 137.4,120.1 A14.E2
O_BAC11  (via drill 0.61)
  Top 0.203: v154.04,26.63 153.4,26.63 149.46,30.57 149.08,30.57 148.83,30.82 148.45,30.82 v109.84,69.43 | v144.13,104.61 144.13,106.39 140.07,110.45 140.07,111.72 138.42,113.37 A14.H2
  Bottom 0.203: v154.04,26.63 151.12,23.71 151.12,19.65 B13.S2 | v109.84,69.43 110.22,69.43 137.78,96.99 137.78,98.26 v144.13,104.61
O_BREAK
  Top 0.203: A20.P2 60.69,94.32 60.69,93.56 61.33,92.93 61.33,90.13 69.07,82.38 69.07,81.62 70.98,79.72 70.98,78.19 72.12,77.05 72.12,76.67 72.5,76.29 72.5,74.38 78.6,68.29 78.6,67.78 102.35,44.03 103.36,44.03 104.25,43.14 109.2,43.14 118.6,33.74 118.6,33.62 118.98,33.24 122.03,33.24 134.35,20.92 135.75,20.92 137.4,19.27 B14.S2
O_BRKRQ  (via drill 0.61)
  Top 0.203: v101.71,39.46 101.58,39.46 94.09,46.95 94.09,51.78 78.22,67.65 78.22,68.16 70.98,75.4 70.98,76.42 68.69,78.7 68.69,82.26 60.95,90 60.95,92.8 59.17,94.58 v59.17,103.09
  Bottom 0.203: v101.71,39.46 98.16,35.9 94.73,35.9 86.09,27.27 86.09,26 B18.P2 | v59.17,103.09 59.17,106.26 59.93,107.02 A20.K2
O_CAINCR
  Top 0.203: B19.K2 72.25,38.32 70.98,38.32 55.99,53.3 55.99,57.11 42.28,70.83 42.28,77.56 41.26,78.57 41.26,91.78 35.29,97.75 35.29,99.02 33.64,100.67 A22.M2
O_DATA00  (via drill 0.61)
  Top 0.203: v19.04,85.43 19.42,85.05 19.42,81.88 24.24,77.05 24.24,66.26 24.62,65.88 24.62,62.95 33.01,54.57 33.01,51.4 B22.E2
  Bottom 0.203: v19.04,85.43 19.04,97.62 31.73,110.32 31.73,110.83 40.88,119.98 40.88,121.25 42.53,122.9 A21.D2
O_DATA01  (via drill 0.61)
  Top 0.203: v61.58,78.96 61.58,85.31 55.61,91.27 55.61,95.97 47.61,103.97 47.61,104.48 41.64,110.45 41.64,114.39 46.34,119.09 45.7,119.72 A21.E2
  Bottom 0.203: v61.58,78.96 52.31,69.68 52.31,65.75 33.64,47.08 33.64,45.05 B22.H2
O_DATA02  (via drill 0.61)
  Top 0.203: v16.24,81.5 16.24,59.65 18.65,57.24 18.65,55.72 24.75,49.62 24.75,49.11 28.94,44.92 28.94,40.6 31.23,38.32 32.62,38.32 B22.K2
  Bottom 0.203: v16.24,81.5 19.8,85.05 19.8,86.19 44.05,110.45 44.05,111.72 45.7,113.37 A21.H2
O_DATA03  (via drill 0.61)
  Top 0.203: v72.88,71.34 72.88,72.99 70.6,75.27 70.6,76.29 68.31,78.57 68.31,79.08 55.99,91.4 55.99,96.1 47.99,104.1 47.99,105.37 46.34,107.02 A21.K2
  Bottom 0.203: v72.88,71.34 59.17,57.62 59.17,45.94 52.69,39.46 51.67,39.46 48.12,35.9 42.28,35.9 38.34,31.97 34.02,31.97 B22.M2
O_DATA04
  Bottom 0.203: B22.P2 32.62,25.62 28.31,25.62 19.16,34.76 18.02,33.62 16.75,33.62 4.94,45.43 6.33,46.83 6.33,53.68 44.05,91.4 44.05,99.02 45.7,100.67 A21.M2
O_DATA05
  Bottom 0.203: B22.S2 32.62,19.27 30.46,19.27 1.51,48.22 1.51,55.21 22.34,76.03 22.34,79.46 45.45,102.58 46.72,102.58 49.26,100.04 47.99,98.77 47.99,97.5 46.34,95.85 A21.P2
O_DATA06
  Bottom 0.203: B23.E2 19.92,51.02 18.53,51.02 16.24,53.3 16.24,60.67 42.28,86.7 43.67,86.7 45.32,88.35 A21.S2
O_DATA07  (via drill 0.61)
  Top 0.203: v43.04,71.34 43.04,77.3 41.64,78.7 41.64,83.91 42.53,84.8 A21.T2
  Bottom 0.203: v43.04,71.34 20.94,49.24 20.94,45.05 B23.H2
O_DATA08  (via drill 0.61)
  Top 0.203: v52.56,61.68 52.31,61.68 51.17,62.83 51.17,65.37 50.78,65.75 50.78,70.83 43.16,78.45 A21.V2
  Bottom 0.203: v52.56,61.68 29.96,39.08 26.4,39.08 25.64,38.32 21.32,38.32 B23.K2
O_DATA09
  Top 0.203: B23.M2 20.3,32.35 20.3,36.54 19.42,37.43 19.42,42.76 18.4,43.78 18.4,44.79 16.24,46.95 16.24,51.14 14.72,52.67 14.72,54.83 6.72,62.83 6.72,115.4 21.7,130.39 26.4,125.69 27.8,125.69 29.45,124.04 A22.D2
O_DATA10
  Bottom 0.203: B23.P2 19.92,25.62 18.53,25.62 1.13,43.02 1.13,86.58 31.35,116.8 31.35,118.07 33.01,119.72 A22.E2
O_DATA11  (via drill 0.61)
  Top 0.203: v3.41,58.26 19.04,42.63 19.04,37.3 19.42,36.92 19.42,24.73 20.3,23.84 20.3,19.65 B23.S2
  Bottom 0.203: v3.41,58.26 3.41,82.51 31.35,110.45 31.35,111.72 33.01,113.37 A22.H2
O_DATAIN  (via drill 0.61)
  Top 0.203: v82.15,26.51 85.33,23.33 85.33,19.65 B18.S2 | v102.73,51.14 102.73,55.59 90.66,67.65 90.66,68.16 76.06,82.77 76.06,83.53 74.66,84.92 74.66,85.43 62.34,97.75 62.34,99.02 60.69,100.67 A20.M2
  Bottom 0.203: v82.15,26.51 80.12,28.54 v102.73,51.14
O_EXTA0  (via drill 0.61)
  Top 0.203: v15.48,106.9 15.86,106.52 15.86,91.27 37.7,69.43 37.7,68.41 55.61,50.51 55.61,46.83 75.93,26.51 73.39,23.96 73.39,19.65 B19.S2
  Bottom 0.203: v15.48,106.9 15.48,107.28 18.65,110.45 18.65,111.72 20.3,113.37 A23.H2
O_EXTA1
  Top 0.203: B19.P2 72.63,26 72.63,29.3 55.23,46.7 55.23,50.38 37.32,68.29 37.32,69.3 15.48,91.15 15.48,104.86 13.07,107.28 13.07,121.12 17.38,125.44 18.65,124.17 18.65,122.9 20.3,121.25 A23.E2
O_EXTA2
  Top 0.203: B19.M2 72.25,31.97 70.98,31.97 55.99,46.95 55.99,50.63 38.09,68.54 38.09,69.56 16.24,91.4 16.24,122.01 17.13,122.9 A23.D2
O_INIT  (via drill 0.61)
  Top 0.203: v144.64,70.45 136.26,78.83 135.62,78.83 A14.V2 | v153.78,73.88 156.45,73.88 v176.64,53.68 | v178.93,53.68 193.03,39.59 193.53,39.59 197.98,35.14 198.11,35.14 198.87,34.38 198.87,34.25 200.52,32.6 200.65,32.6 202.04,31.2 202.04,31.08 207.5,25.62 v207.63,25.62
  Bottom 0.203: v144.64,70.45 150.35,70.45 v153.78,73.88 | v176.64,53.68 v178.93,53.68 | v207.63,25.62 207.63,24.98 205.22,22.57 205.22,21.3 203.57,19.65 B09.S2
O_IOP1  (via drill 0.61)
  Top 0.203: v196.84,39.97 193.15,39.97 179.82,53.3 179.82,53.94 179.31,54.45 177.53,54.45 175.75,56.22 175.25,56.22 133.72,97.75 v133.72,103.72
  Bottom 0.203: v196.84,39.97 209.03,52.16 209.79,52.16 211.06,53.43 213.6,53.43 B08.D2 | v133.72,103.72 133.72,105.12 134.35,105.75 135.75,105.75 137.4,107.4 A14.K2
O_IOP2  (via drill 0.61)
  Top 0.203: v146.16,108.93 151.37,108.93 160.77,99.53 160.77,97.75 166.1,92.42 166.1,91.91 175.5,82.51 175.5,81.88 186.68,70.7 187.31,70.7 212.84,45.17 212.84,44.92 217.16,40.6 217.16,38.7 B08.K2
  Bottom 0.203: v146.16,108.93 143.88,108.93 140.07,105.12 140.07,103.85 138.42,102.2 A14.M2
O_IOP4  (via drill 0.61)
  Top 0.203: v139.81,92.8 138.42,94.2 138.42,94.32 A14.P2 | v139.56,89.62 139.56,88.99 148.83,79.72 148.83,78.07 148.96,77.94 148.96,76.92 152.77,73.11 153.66,73.11 189.98,36.79 193.03,36.79 v193.41,36.41 | v198.36,38.44 198.36,38.06 210.68,25.74 210.68,23.96 213.73,20.92 215.12,20.92 216.77,19.27 B08.S2
  Bottom 0.203: v139.81,92.8 139.81,89.88 v139.56,89.62 | v193.41,36.41 196.96,36.41 197.98,37.43 197.98,38.06 v198.36,38.44
O_IRQ  (via drill 0.61)
  Top 0.203: v62.98,75.27 65.77,72.48 65.77,69.3 71.87,63.21 71.87,62.83 84.19,50.51 84.19,50 85.33,48.86 85.33,45.05 B18.H2
  Bottom 0.203: v62.98,75.27 62.98,77.05 83.68,97.75 83.68,99.02 85.33,100.67 A18.M2
O_LINE  (via drill 0.61)
  Top 0.203: v66.41,59.78 67.93,58.26 67.93,55.08 68.31,54.7 68.31,53.18 71.11,50.38 71.11,49.87 85.33,35.65 85.33,32.35 B18.M2
  Bottom 0.203: v66.41,59.78 66.41,61.43 67.8,62.83 67.8,64.1 82.15,78.45 A18.V2
O_MB00  (via drill 0.61)
  Top 0.203: v139.18,110.45 126.35,123.28 122.92,123.28 A15.D2 | v183.88,138.9 187.06,138.9 187.95,139.79 203.95,139.79 205.6,138.14 210.81,138.14 223.25,125.69 224.65,125.69 226.3,124.04 A07.D2
  Bottom 0.203: v139.18,110.45 139.18,110.58 143.88,115.28 148.45,115.28 158.74,125.56 159.88,125.56 164.7,130.39 166.48,130.39 167.62,131.53 172.71,131.53 176.77,135.6 180.58,135.6 v183.88,138.9
O_MB01  (via drill 0.61)
  Top 0.203: v194.04,134.33 200.39,127.98 203.69,127.98 210.04,121.63 218.04,121.63 229.86,109.82 229.86,108.55 A07.K2 | v146.29,105.63 144.38,103.72 143.88,103.72 129.14,118.45 127.75,118.45 126.1,120.1 A15.E2
  Bottom 0.203: v194.04,134.33 180.58,134.33 178.29,132.04 174.86,132.04 173.59,130.77 173.09,130.77 170.04,127.72 168.39,127.72 v146.29,105.63
O_MB02  (via drill 0.61)
  Top 0.203: v182.48,127.98 184.64,127.98 190.61,122.01 191.12,122.01 197.98,115.15 200.77,115.15 202.04,113.88 202.04,113.63 204.84,110.83 204.84,110.32 210.17,104.99 210.17,104.61 219.44,95.34 220.84,95.34 223.63,92.54 224.78,92.54 225.16,92.16 225.16,92.04 228.08,89.12 229.47,89.12 A07.S2 | v148.32,103.21 145.15,103.21 145.02,103.34 138.03,103.34 129.27,112.1 127.75,112.1 126.1,113.75 A15.H2
  Bottom 0.203: v182.48,127.98 180.58,127.98 178.29,125.69 171.94,125.69 162.42,116.17 161.28,116.17 v148.32,103.21
O_MB03  (via drill 0.61)
  Top 0.203: v189.47,136.61 206.87,119.21 207.76,119.21 215.5,111.47 215.5,110.2 217.16,108.55 A08.K2
  Bottom 0.203: v189.47,136.61 186.42,139.66 183.5,139.66 179.94,136.11 176.77,136.11 176.64,135.98 174.86,135.98 173.85,134.96 170.8,134.96 170.17,134.33 164.58,134.33 158.61,128.36 156.45,128.36 153.66,125.56 153.15,125.56 147.05,119.47 145.15,119.47 128.51,102.83 128,102.83 126.98,101.82 126.1,101.82 A15.M2
O_MB03\  (via drill 0.61)
  Top 0.203: v167.5,138.9 181.98,138.9 v185.02,135.85 | v198.36,135.85 198.87,135.85 209.03,125.69 211.95,125.69 213.6,124.04 A08.D2
  Bottom 0.203: v167.5,138.9 159.75,131.15 153.4,131.15 148.07,125.82 147.31,125.82 129.65,108.17 126.1,108.17 A15.K2 | v185.02,135.85 v198.36,135.85
O_MB04  (via drill 0.61)
  Top 0.203: v165.09,129.63 166.48,129.63 170.8,125.31 171.31,125.31 174.1,122.52 184.39,122.52 v191.12,115.79
  Bottom 0.203: v165.09,129.63 157.08,121.63 156.58,121.63 148.83,113.88 148.83,110.45 127.49,89.12 126.1,89.12 A15.S2 | v191.12,115.79 191.12,116.42 196.33,121.63 197.6,121.63 199.25,123.28 A09.D2
O_MB04\  (via drill 0.61)
  Top 0.203: v189.22,118.83 213.98,94.07 213.98,93.56 214.49,93.05 214.87,93.05 217.16,90.77 217.16,89.5 A08.S2 | v141.34,81.24 137.53,81.24 127.37,91.4 127.37,92.67 125.72,94.32 A15.P2
  Bottom 0.203: v189.22,118.83 187.18,118.83 177.4,109.05 174.36,109.05 162.42,97.12 160.89,97.12 157.72,93.94 154.04,93.94 v141.34,81.24
O_MB05  (via drill 0.61)
  Top 0.203: v125.33,78.07 124.57,78.83 122.92,78.83 A15.V2 | v172.58,117.69 172.58,116.93 174.99,114.52 175.75,114.52 186.8,103.47 190.1,103.47 201.15,92.42 201.15,91.15 202.8,89.5 A09.S2
  Bottom 0.203: v125.33,78.07 132.07,78.07 156.58,102.58 157.47,102.58 v172.58,117.69
O_MB05\  (via drill 0.61)
  Top 0.203: v121.02,91.02 121.91,90.13 121.91,86.32 A15.T2 | v168.01,132.42 170.55,132.42 170.93,132.04 176.77,132.04 183.5,125.31 184.01,125.31 199.5,109.82 200.77,109.82 202.42,108.17 A09.K2
  Bottom 0.203: v121.02,91.02 121.02,93.43 138.8,111.21 139.3,111.21 143.75,115.66 148.32,115.66 158.61,125.95 159.75,125.95 164.58,130.77 166.36,130.77 v168.01,132.42
O_MB06  (via drill 0.61)
  Top 0.203: v175.37,115.28 178.29,115.28 185.41,108.17 189.72,108.17 A10.K2 | v157.34,98.39 155.56,98.39 125.97,127.98 112,127.98 109.46,125.44 110.73,124.17 110.73,122.9 112.38,121.25 A16.E2
  Bottom 0.203: v175.37,115.28 174.23,115.28 v157.34,98.39
O_MB06\
  Top 0.203: A16.D2 109.2,124.42 109.2,125.18 109.08,125.31 109.08,125.56 123.3,139.79 158.61,139.79 160.26,138.14 171.18,138.14 183.63,125.69 184.9,125.69 186.55,124.04 A10.D2
O_MB07  (via drill 0.61)
  Top 0.203: v153.4,137.5 158.86,137.5 165.59,130.77 165.85,130.77 170.93,125.69 172.2,125.69 173.85,124.04 A11.D2
  Bottom 0.203: v153.4,137.5 144.64,128.74 137.27,128.74 116.7,108.17 113.4,108.17 A16.K2
O_MB07\  (via drill 0.61)
  Top 0.203: v141.46,134.33 177.02,98.77 178.55,98.77 188.2,89.12 189.72,89.12 A10.S2
  Bottom 0.203: v141.46,134.33 134.61,134.33 116.44,116.17 115.05,116.17 113.4,114.52 A16.H2
O_MB08  (via drill 0.61)
  Top 0.203: v145.65,118.71 145.91,118.45 148.19,118.45 160.77,105.88 160.77,104.1 175.75,89.12 177.02,89.12 A11.S2
  Bottom 0.203: v145.65,118.71 144.89,118.71 128.64,102.45 128.13,102.45 125.97,100.29 119.62,100.29 116.44,97.12 115.05,97.12 113.4,95.47 A16.P2
O_MB08\  (via drill 0.61)
  Top 0.203: v149.08,127.98 153.4,127.98 154.04,127.34 154.93,127.34 156.58,125.69 157.08,125.69 158.74,124.04 158.99,124.04 168.01,115.02 168.9,115.02 174.1,109.82 175.37,109.82 177.02,108.17 A11.K2
  Bottom 0.203: v149.08,127.98 137.53,127.98 113.02,103.47 113.02,102.2 A16.M2
O_MB09  (via drill 0.61)
  Top 0.203: v159.12,124.8 160.39,124.8 161.15,124.04 A12.D2
  Bottom 0.203: v159.12,124.8 146.16,111.85 143.62,111.85 142.48,110.71 142.48,110.45 121.91,89.88 118.48,89.88 117.71,89.12 113.4,89.12 A16.S2
O_MB10  (via drill 0.61)
  Top 0.203: v144,111.09 145.78,111.09 147.05,109.82 151.62,109.82 v158.74,102.7
  Bottom 0.203: v144,111.09 119.62,86.7 115.3,86.7 114.54,85.94 110.22,85.94 A16.T2 | v158.74,102.7 158.74,103.09 161.4,105.75 162.67,105.75 164.32,107.4 A12.K2
O_MB11  (via drill 0.61)
  Top 0.203: v125.21,65.24 111.62,78.83 110.22,78.83 A16.V2 | v157.72,91.02 158.48,91.02 160.13,89.37 164.07,89.37 164.32,89.12 A12.S2
  Bottom 0.203: v125.21,65.24 128.13,65.24 132.32,69.43 136.13,69.43 v157.72,91.02
O_MBINCR  (via drill 0.61)
  Top 0.203: v53.45,80.61 65.14,68.92 65.14,62.7 67.17,60.67 67.17,59.52 72.63,54.06 72.63,51.4 B19.E2
  Bottom 0.203: v53.45,80.61 53.45,81.5 56.75,84.8 A20.T2
O_RUN  (via drill 0.61)
  Top 0.203: v125.84,48.48 106.54,67.78 105.01,67.78 86.09,86.7 86.09,87.97 A18.S2
  Bottom 0.203: v125.84,48.48 127.87,48.48 131.18,51.78 132.57,51.78 134.22,53.43 B14.D2
O_SKIP  (via drill 0.61)
  Top 0.203: v62.34,83.02 72.12,73.24 72.12,70.95 78.09,64.99 78.09,60.54 85.33,53.3 85.33,51.4 B18.E2
  Bottom 0.203: v62.34,83.02 62.6,83.02 83.68,104.1 83.68,105.37 85.33,107.02 A18.K2
O_TS1  (via drill 0.61)
  Top 0.203: v137.53,85.18 138.92,85.18 v149.21,74.89 | v155.43,74.89 156.07,74.89 175.12,55.84 175.63,55.84 178.55,52.92 179.18,52.92 v197.72,34.38
  Bottom 0.203: v137.53,85.18 135.62,85.18 A14.T2 | v149.21,74.89 v155.43,74.89 | v197.72,34.38 197.98,34.38 199.5,35.9 200.77,35.9 202.42,37.55 B09.K2
O_TS3  (via drill 0.61)
  Top 0.203: v148.7,96.35 151.24,96.35 158.35,89.24 158.35,86.07 163.05,81.37 163.82,81.37 173.98,71.21 174.61,71.21 193.15,52.67 197.6,52.67 v197.98,52.29
  Bottom 0.203: v148.7,96.35 141.21,88.86 138.8,88.86 A14.S2 | v197.98,52.29 198.11,52.29 199.25,53.43 B09.D2
O_TT_INST
  Top 0.203: A18.T2 82.92,84.8 82.92,84.04 83.93,83.02 83.93,82.51 115.17,51.27 115.3,51.27 126.35,40.22 127.75,40.22 128,39.97 131.94,39.97 134.86,42.89 136.13,41.62 136.13,40.35 137.78,38.7 B14.K2
O_WCOV  (via drill 0.61)
  Top 0.203: v54.47,112.1 59.04,112.1 74.15,96.99 74.15,96.35 97.9,72.61 98.79,72.61 120.25,51.14 120.25,47.46 v126.73,40.98
  Bottom 0.203: v54.47,112.1 37.83,95.47 34.02,95.47 A22.P2 | v126.73,40.98 126.73,39.71 125.72,38.7 B15.K2
VCC  (via drill 0.61)
  Top 0.381: v80.12,67.4 81.27,67.4 84.95,63.72 B18.A2 | v91.81,68.16 96.25,63.72 97.65,63.72 B17.A2 | v25,66.64 29.7,66.64 32.62,63.72 B22.A2 | v39.1,68.67 44.05,63.72 45.32,63.72 B21.A2 | v51.55,67.4 55.23,63.72 59.55,63.72 B20.A2 | v66.53,69.68 72.38,63.84 B19.A2 | 224.9,137.76 229.47,133.19 A07.A2 | 224.9,137.76 223.63,139.03 218.17,133.57 A08.A2 | A06.A2 242.17,133.57 241.41,133.57 237.86,137.12 232.9,137.12 232.52,137.5 227.7,137.5 227.32,137.88 225.03,137.88 224.9,137.76 | v175.25,135.22 175.37,135.22 177.02,133.57 A11.A2 | 188.96,135.85 188.58,136.23 188.58,137 190.87,139.28 196.71,139.28 202.42,133.57 A09.A2 | 188.96,135.85 190.1,134.71 190.1,133.95 A10.A2 | 188.96,135.85 v188.2,135.09 | v122.67,65.49 122.92,65.49 124.7,63.72 B15.A2 | v140.45,65.49 148.32,65.49 150.1,63.72 B13.A2 | v133.21,68.16 137.53,63.84 B14.A2 | v224.39,69.05 229.6,63.84 B07.A2 | v237.35,68.8 242.3,63.84 B06.A2 | v169.15,65.62 175.37,65.62 177.15,63.84 B11.A2 | v183.75,68.8 188.83,63.72 189.72,63.72 B10.A2 | v196.84,69.56 202.55,63.84 B09.A2 | B08.A2 216.77,63.72 215.63,63.72 v210.55,68.8 210.68,69.18 201.28,78.57 201.28,79.72 195.31,85.69 195.31,86.19 193.28,88.23 193.28,88.61 177.79,104.1 v177.66,104.1 | v162.93,64.99 163.05,64.99 164.32,63.72 B12.A2 | v105.52,68.54 107.17,68.54 112,63.72 B16.A2
  Bottom 0.381: v80.12,67.4 79.23,66.51 79.23,66 76.95,63.72 73.77,63.72 B19.A2 | v91.81,68.16 90.41,68.16 86.22,63.97 B18.A2 | v25,66.64 22.08,63.72 21.32,63.72 B23.A2 | v39.1,68.67 38.97,68.67 34.02,63.72 B22.A2 | v51.55,67.4 50.4,67.4 46.72,63.72 B21.A2 | v66.53,69.68 60.82,63.97 B20.A2 | v175.25,135.22 174.48,134.46 170.93,134.46 170.04,133.57 165.85,133.57 A12.A2 | v188.2,135.09 187.95,134.84 180.45,134.84 179.18,133.57 178.55,133.57 A11.A2 | 204.2,133.69 203.95,133.44 A09.A2 | 204.2,133.69 207.5,137 210.93,133.57 216.77,133.57 A08.A2 | v122.67,65.49 121.78,64.6 118.48,64.6 117.59,63.72 113.4,63.72 B16.A2 | v140.45,65.49 138.8,63.84 138.8,63.72 B14.A2 | v133.21,68.16 128.76,63.72 126.1,63.72 B15.A2 | v224.39,69.05 219.06,63.72 218.17,63.72 B08.A2 | v237.35,68.8 235.95,68.8 230.87,63.72 B07.A2 | v169.15,65.62 167.24,63.72 165.85,63.72 B12.A2 | v183.75,68.8 183.63,68.8 178.55,63.72 B11.A2 | v196.84,69.56 191.12,63.84 B10.A2 | v210.55,68.8 208.52,68.8 203.69,63.97 B09.A2 | v162.93,64.99 162.55,64.6 156.58,64.6 155.69,63.72 151.5,63.72 B13.A2 | v177.66,104.1 205.73,132.17 204.2,133.69 | v105.52,68.54 102.98,66 102.35,66 100.06,63.72 99.17,63.72 B17.A2