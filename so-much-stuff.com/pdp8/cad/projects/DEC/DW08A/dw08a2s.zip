# EAGLE board dw08a2s (EAGLE 4.11), part 2 of 3
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
I_ACCLR  (via drill 0.61) (continued)
  Bottom 0.203: v258.05,2.12 264.15,8.22 267.19,8.22 274.05,15.08 274.94,15.08 282.18,22.31 282.18,24.47 B03.P2 | A03.P2 281.8,94.7 280.15,93.05 278.88,93.05 276.72,90.89 275.96,90.89 261.73,76.67 261.73,75.91 250.43,64.6 250.43,62.83 248.14,60.54 248.14,60.03 240.02,51.91 239.13,51.91 239,51.78 235.95,51.78 218.68,34.51 218.68,31.08 217.28,29.68 v217.03,29.68 216.9,29.3 210.93,23.33 210.93,22.82 194.8,6.69 187.18,6.69 181.72,1.23 159.88,1.23 v157.85,3.26
I_ADD00  (via drill 0.61)
  Top 0.203: v80.12,39.59 67.04,52.67 62.98,52.67 62.21,53.43 57.9,53.43 B20.D2 | v113.02,69.05 117.97,69.05 124.83,62.19 128.89,62.19 v138.42,52.67 | v197.47,99.53 203.44,99.53 v223.89,79.08 | v303.13,85.56 303.13,89.24 v298.94,93.43 | v311.26,108.29 309.87,108.29 302.25,115.91 301.48,115.91 298.94,118.45 288.66,118.45 274.05,133.06 273.29,133.06 271.89,131.66 272.78,130.77 A04.B1
  Bottom 0.203: v80.12,39.59 83.68,39.59 113.02,68.92 v113.02,69.05 | v138.42,52.67 150.23,64.48 151.75,64.48 154.29,67.02 160.89,67.02 161.15,67.27 165.21,67.27 v197.47,99.53 | v223.89,79.08 224.52,79.08 232.78,87.34 232.78,88.35 235.7,91.27 235.7,91.91 238.24,94.45 238.87,94.45 248.65,104.23 248.91,104.23 271,126.33 271,127.6 272.65,129.25 A04.B1 | v303.13,85.56 291.45,73.88 291.2,73.88 290.81,73.49 290.31,73.49 284.97,68.16 284.34,68.16 281.93,65.75 281.04,65.75 280.4,65.11 280.02,65.11 275.45,60.54 273.8,60.54 B04.B1 | v298.94,93.43 298.94,94.45 300.72,96.23 300.72,97.75 v311.26,108.29
I_ADD01  (via drill 0.61)
  Top 0.203: v107.05,14.44 100.57,20.92 94.73,20.92 79.23,36.41 78.72,36.41 78.34,36.79 72.5,36.79 71.36,37.94 70.85,37.94 61.71,47.08 57.9,47.08 B20.F2 | v176.9,73.37 182.36,73.37 186.55,69.18 187.69,69.18 v189.34,67.53 | v202.55,75.91 202.68,75.91 v207.76,70.83 | 234.17,81.11 235.57,81.11 244.46,72.22 244.46,71.08 264.27,51.27 264.27,51.14 v266.3,49.11 | v231,81.11 234.17,81.11 | v249.03,103.47 248.91,103.47 246.62,105.75 243.44,105.75 243.32,105.88 242.68,105.88 v239.51,109.05 | v231.89,101.05 232.4,101.05 240.9,92.54 240.9,90.13 v241.03,90 | 234.17,81.11 v234.17,81.75
  Bottom 0.203: v107.05,14.44 116.32,14.44 158.35,56.48 158.35,58.26 164.58,64.48 166.1,64.48 168.51,66.89 170.42,66.89 v176.9,73.37 | v189.34,67.53 193.91,67.53 194.3,67.91 194.3,68.16 196.45,70.32 196.96,70.32 v202.55,75.91 | v207.76,70.83 219.57,70.83 223.63,74.89 224.78,74.89 v231,81.11 | v266.3,49.11 266.69,49.11 269.35,51.78 270.62,51.78 272.27,53.43 B04.D1 | v249.03,103.47 258.18,112.61 258.18,112.99 268.46,123.28 272.27,123.28 A04.D1 | v239.51,109.05 233.16,102.7 233.03,102.7 232.65,102.32 232.65,101.82 v231.89,101.05 | v241.03,90 241.03,88.61 v234.17,81.75
I_ADD02  (via drill 0.61)
  Top 0.203: v63.48,36.79 59.55,40.73 57.9,40.73 B20.J2 | v104.63,69.43 108.7,69.43 v126.22,51.91 | v189.47,104.23 191.88,104.23 v192.64,103.47 | v228.33,136.11 231,136.11 231.63,135.47 232.14,135.47 233.67,133.95 234.05,133.95 235.95,132.04 240.65,132.04 259.7,112.99 259.7,112.36 v260.21,111.85 | v236.84,86.96 238.49,85.31 238.49,85.05 239.63,83.91 239.63,83.4 263.26,59.78 263.89,59.78 269.99,53.68 270.24,53.68 272.91,51.02 275.45,51.02 B04.E1
  Bottom 0.203: v63.48,36.79 69.2,36.79 84.95,52.54 85.46,52.54 94.6,61.68 95.11,61.68 97.9,64.48 99.68,64.48 v104.63,69.43 | v126.22,51.91 129.91,51.91 141.46,63.46 142.86,63.46 143.88,64.48 146.67,64.48 153.02,70.83 153.02,71.08 157.72,75.78 161.02,75.78 v189.47,104.23 | v192.64,103.47 194.17,103.47 210.68,119.98 210.68,121.75 223.25,134.33 226.55,134.33 v228.33,136.11 | 262.88,111.85 265.92,111.85 272.53,118.45 273.8,118.45 275.45,120.1 A04.E1 | v260.21,111.85 262.88,111.85 | v236.84,86.96 240.65,90.77 240.9,90.77 243.83,93.69 244.71,93.69 262.88,111.85
I_ADD03  (via drill 0.61)
  Top 0.203: v98.28,73.37 98.92,73.37 v129.02,43.27 | v202.8,92.8 202.8,92.67 v208.39,87.08 | v210.55,87.21 210.93,87.21 213.73,84.42 217.41,84.42 223.51,78.32 224.27,78.32 230.81,71.78 | 230.81,71.78 239.76,62.83 239.76,62.57 v257.92,44.41 | v265.03,51.52 271.13,45.43 274.69,45.43 275.45,44.67 B04.H1 | v246.75,89.62 246.75,88.61 v247.38,87.97 | 230.81,71.78 v230.74,71.72
  Bottom 0.203: v98.28,73.37 60.06,35.14 57.9,35.14 B20.L2 | v129.02,43.27 134.35,48.6 146.54,48.6 156.45,58.51 157.59,58.51 164.32,65.24 164.83,65.24 167.37,67.78 169.02,67.78 173.98,72.73 175.12,72.73 176.52,74.13 177.66,74.13 181.47,77.94 187.69,77.94 188.45,78.7 188.45,82 189.98,83.53 193.53,83.53 v202.8,92.8 | v208.39,87.08 210.42,87.08 v210.55,87.21 | v257.92,44.41 258.56,44.41 264.27,50.13 264.27,50.76 v265.03,51.52 | v246.75,89.62 248.91,91.78 249.29,91.78 271.26,113.75 275.45,113.75 A04.H1 | v247.38,87.97 246.75,87.97 238.49,79.72 238.49,79.34 234.81,75.65 234.81,75.4 231.63,72.22 231.25,72.22 v230.74,71.72
I_ADD04  (via drill 0.61)
  Top 0.203: v87.23,14.57 84.82,16.98 72.25,16.98 61.2,28.03 57.9,28.03 B20.N2 | v166.86,74.77 v157.85,74.77 | v196.2,99.4 197.09,100.29 205.98,100.29 210.68,95.59 210.68,93.31 224.14,79.84 224.27,79.84 224.65,79.46 224.65,79.34 v231,72.99 231.25,72.61 234.05,69.81 234.05,69.05 250.94,52.16 250.94,51.91 257.67,45.17 258.3,45.17 266.05,37.43 266.3,37.43 v267.45,36.28
  Bottom 0.203: v87.23,14.57 97.65,14.57 v157.85,74.77 | v166.86,74.77 171.82,74.77 194.8,97.75 194.8,98.01 v196.2,99.4 | v231,72.99 231.25,72.99 247,88.73 247.51,88.73 261.35,102.58 261.61,102.58 265.92,106.9 266.69,106.9 269.35,109.56 271.26,109.56 272.27,110.58 A04.J1 | v267.45,36.28 267.96,36.79 270.5,36.79 273.04,39.33 B04.J1
I_ADD05  (via drill 0.61)
  Top 0.203: v54.59,16.98 54.59,10.25 v57.9,6.95 | v159.5,36.16 159.5,35.52 161.4,33.62 164.2,33.62 164.45,33.36 165.21,33.36 v193.41,5.17 | v219.31,8.6 219.7,8.6 220.08,8.22 223,8.22 v227.95,3.26 | v246.24,13.93 v250.3,13.93 | v295.51,74.13 290.94,78.7 290.94,79.21 290.05,80.1 290.05,82.89 289.29,83.65 288.91,83.65 286.88,85.69 286.88,86.07 284.97,87.97 284.72,87.97 283.7,88.99 283.7,89.24 282.81,90.13 282.81,90.64 271,102.45 272.53,103.97 A04.L1 | v291.7,55.84 v284.47,63.08
  Bottom 0.203: v54.59,16.98 56.75,19.14 56.75,21.3 B20.R2 | v57.9,6.95 104.76,6.95 105.14,6.57 120.38,6.57 120.76,6.95 122.54,6.95 122.79,7.2 129.65,7.2 131.81,9.36 132.7,9.36 v159.5,36.16 | v193.41,5.17 200.52,5.17 202.04,6.69 208.14,6.69 208.9,7.46 209.66,7.46 210.04,7.07 215.63,7.07 216.77,8.22 218.93,8.22 v219.31,8.6 | v227.95,3.26 233.67,3.26 234.81,4.41 236.71,4.41 v246.24,13.93 | v250.3,13.93 253.48,13.93 260.34,20.79 261.35,20.79 261.73,21.17 262.11,21.17 266.18,25.23 266.18,26.25 271,31.08 271,32.35 272.65,34 B04.L1 273.8,35.14 275.45,36.79 276.72,36.79 290.94,51.02 290.94,54.32 291.7,55.08 v291.7,55.84 | v284.47,63.08 v295.51,74.13
I_ADD06  (via drill 0.61)
  Top 0.203: v274.31,33.87 275.83,32.35 B04.M1 | v296.78,60.03 296.4,60.03 277.86,78.57 277.86,79.08 275.07,81.88 275.07,82.38 274.18,83.27 273.67,83.27 268.72,88.23 268.72,88.48 267.19,90 266.94,90 v265.16,91.78 | v110.98,108.93 120.25,108.93 v135.88,93.31 | v200.52,136.87 v209.92,136.87 | v226.93,137 230.62,137 231.76,135.85 237.35,135.85 v237.73,135.47 | v248.02,136.74 250.43,134.33 251.06,134.33 262.37,123.02 262.62,123.02 271,114.64 271,110.58 v277.1,104.48
  Bottom 0.203: v274.31,33.87 291.32,50.89 291.32,51.4 293.23,53.3 293.23,57.87 294.62,59.27 296.02,59.27 v296.78,60.03 | v265.16,91.78 265.16,92.8 269.23,96.86 269.48,96.86 270.88,98.26 271.38,98.26 272.53,99.4 273.8,99.4 275.45,101.05 A04.M1 276.59,102.2 277.1,102.7 v277.1,104.48 | v110.98,108.93 108.19,106.13 100.95,106.13 87.87,93.05 82.03,93.05 53.45,64.48 51.8,64.48 43.16,55.84 43.16,54.57 B21.D2 | v135.88,93.31 138.03,93.31 142.48,97.75 142.48,99.15 143.5,100.16 147.81,100.16 160.64,112.99 161.78,112.99 167.62,118.83 171.56,118.83 171.94,119.21 178.93,119.21 182.1,122.39 183.37,122.39 196.07,135.09 198.74,135.09 v200.52,136.87 | v209.92,136.87 226.81,136.87 v226.93,137 | v237.73,135.47 239.13,135.47 240.4,136.74 v248.02,136.74
I_ADD07  (via drill 0.61)
  Top 0.203: v281.42,33.49 281.42,34.63 v279.38,36.66 | v297.04,61.3 295.64,61.3 278.24,78.7 278.24,82 273.54,86.7 273.04,86.7 v271.51,88.23 | B04.P1 276.59,26 v276.59,28.66 276.21,28.92 270.37,34.76 v268.46,34.76 | v57.01,37.94 47.86,47.08 43.55,47.08 B21.F2 | v116.32,82.51 116.32,81.88 133.21,64.99 134.73,64.99 137.53,62.19 141.34,62.19 141.59,61.94 142.48,61.94 147.56,56.86 149.21,56.86 153.4,52.67 157.21,52.67 157.72,52.16 158.99,52.16 159.12,52.03 159.5,52.03 159.75,51.78 161.78,51.78 v195.82,17.74 | v210.3,30.19 210.81,30.19 220.08,20.92 224.14,20.92 v226.68,18.38 | v236.97,27.39 237.09,27.39 239,25.49 239.76,25.49 v243.44,21.81 | v248.02,23.58 v251.83,19.77
  Bottom 0.203: v276.59,28.66 v281.42,33.49 | v279.38,36.66 279.38,37.55 280.53,38.7 281.04,38.7 293.74,51.4 293.74,53.81 299.58,59.65 299.58,60.67 298.56,61.68 298.31,61.43 297.17,61.43 v297.04,61.3 | v271.51,88.23 271.51,88.73 274.18,91.4 274.18,92.67 275.83,94.32 A04.P1 | v57.01,37.94 57.52,37.94 76.69,57.11 77.07,57.11 80.25,60.29 81.01,60.29 101.08,80.35 114.16,80.35 v116.32,82.51 | v195.82,17.74 197.85,17.74 v210.3,30.19 | v226.68,18.38 227.44,18.38 234.3,25.23 234.81,25.23 v236.97,27.39 | v243.44,21.81 244.08,21.81 245.48,23.2 247.64,23.2 v248.02,23.58 | v251.83,19.77 252.59,19.77 257.41,24.6 257.41,25.11 259.06,26.76 259.95,26.76 261.1,27.9 261.61,27.9 v268.46,34.76
I_ADD08  (via drill 0.61)
  Top 0.203: v293.61,38.44 293.61,41.24 283.07,51.78 282.69,51.78 v281.42,53.05 | v294.12,68.29 294.12,69.18 278.24,85.05 278.24,86.32 276.59,87.97 A04.S1 | v89.14,13.81 85.58,17.36 72.38,17.36 52.94,36.79 51.8,36.79 47.86,40.73 43.55,40.73 B21.J2 | v174.36,71.97 176.64,71.97 178.8,69.81 181.6,69.81 v224.27,27.14 | v228.71,27.14 229.6,27.14 229.73,27.01 230.74,27.01 231.51,26.25 232.14,26.25 249.41,8.98 251.06,8.98 251.83,8.22 256.02,8.22 v259.32,4.92
  Bottom 0.203: v293.61,38.44 276.59,21.43 276.59,19.65 B04.S1 275.45,18.5 273.8,16.85 272.53,16.85 264.27,8.6 264.02,8.6 260.34,4.92 v259.32,4.92 | v281.42,53.05 281.42,54.19 290.05,62.83 290.05,64.22 v294.12,68.29 | v89.14,13.81 98.03,13.81 101.08,16.85 115.3,16.85 156.58,58.13 157.72,58.13 164.45,64.86 164.96,64.86 167.5,67.4 169.78,67.4 v174.36,71.97 | v228.71,27.14 v224.27,27.14
I_ADD09  (via drill 0.61)
  Top 0.203: v160.64,138.9 163.69,138.9 164.58,139.79 181.85,139.79 183.5,138.14 183.88,138.14 199.95,122.07 | 199.95,122.07 209.03,112.99 209.79,112.99 211.82,110.96 211.82,110.07 212.96,108.93 212.96,108.42 233.92,87.46 234.55,87.46 251.19,70.83 251.19,69.05 252.21,68.03 252.59,68.03 266.18,54.45 B04.D2 | v253.35,114.52 253.22,114.52 246.62,121.12 243.95,121.12 243.44,121.63 239,121.63 229.86,130.77 227.95,130.77 227.57,131.15 226.17,131.15 225.54,131.79 220.08,131.79 v219.06,132.8 | 199.95,122.07 v200.01,122.14
  Bottom 0.203: v160.64,138.9 150.48,128.74 147.81,128.74 147.43,128.36 137.4,128.36 105.9,96.86 105.9,94.58 99.93,88.61 99.93,88.1 93.97,82.13 93.97,80.35 89.39,75.78 89.39,75.02 53.45,39.08 51.8,39.08 47.86,35.14 43.55,35.14 B21.L2 | v253.35,114.52 262.11,123.28 265.92,123.28 A04.D2 | v219.06,132.8 218.81,132.8 218.04,132.04 209.79,132.04 208.27,130.52 208.27,130.26 200.14,122.14 v200.01,122.14
I_ADD10  (via drill 0.61)
  Top 0.203: v64.25,23.84 63.99,24.09 45.45,24.09 43.16,26.38 43.16,27.65 B21.N2 | v144.38,75.15 150.48,69.05 150.48,68.8 154.42,64.86 160.01,64.86 v177.02,47.84 | v259.95,128.36 263.64,128.36 267.83,124.17 267.83,122.9 269.48,121.25 A04.E2 | v267.32,51.02 269.1,51.02 B04.E2 | v255.89,39.59 255.89,40.09 244.97,51.02 244.97,51.52 219.44,77.05 219.44,77.18 218.17,78.45 217.54,78.45 v211.57,84.42
  Bottom 0.203: v64.25,23.84 80.63,23.84 102.35,45.55 102.86,45.55 105.14,47.84 107.68,47.84 108.82,48.98 109.33,48.98 112.13,51.78 116.19,51.78 122.67,58.26 124.44,58.26 133.08,66.89 136.13,66.89 v144.38,75.15 | v177.02,47.84 177.15,47.84 192.01,62.7 192.01,63.08 207.5,78.57 207.5,82 209.03,83.53 210.55,83.53 211.5,84.48 | 211.5,84.48 239.13,112.1 242.56,112.1 244.08,113.63 244.08,117.06 248.65,121.63 251.95,121.63 252.59,120.99 v259.95,128.36 | v267.32,51.02 266.94,51.02 257.54,41.62 257.54,41.24 v255.89,39.59 | 211.5,84.48 v211.57,84.42
I_ADD11  (via drill 0.61)
  Top 0.203: v137.02,97.37 140.45,97.37 140.7,97.12 145.65,97.12 178.93,63.84 178.93,63.34 v180.58,61.68 | v250.81,133.06 251.06,133.06 263.13,120.99 263.13,119.21 266.18,116.17 267.45,116.17 269.1,114.52 A04.H2 | v271.51,46.19 271,46.19 266.56,50.63 266.56,51.14 265.42,52.29 264.4,52.29 253.99,62.7 253.99,64.6 v249.29,69.3 | v250.43,70.45 250.43,70.7 234.05,87.08 233.79,87.08 232.4,88.48 232.14,88.48 224.39,96.23 220.08,96.23 v214.87,101.43
  Bottom 0.203: v137.02,97.37 111.75,72.1 110.22,72.1 103.62,65.49 102.47,65.49 98.28,61.3 94.73,61.3 85.58,52.16 85.08,52.16 65.64,32.73 59.8,32.73 58.28,31.2 57.26,31.2 52.44,26.38 51.8,26.38 47.86,22.44 43.55,22.44 B21.R2 | v180.58,61.68 180.83,61.68 183.63,64.48 183.88,64.48 194.55,75.15 194.55,78.45 210.68,94.58 210.68,97.5 214.68,101.5 | 214.68,101.5 220.08,106.9 221.22,106.9 229.6,115.28 229.86,115.28 230.24,115.66 230.24,115.91 242.3,127.98 245.73,127.98 v250.81,133.06 | v271.51,46.19 270.37,45.05 270.37,44.92 B04.H2 | v250.43,70.45 v249.29,69.3 | v214.87,101.43 214.74,101.43 214.68,101.5
I_BAC00  (via drill 0.61)
  Top 0.203: v193.41,43.4 192.9,43.9 191.25,43.9 B10.H2 | v218.81,68.92 220.84,68.92 228.2,61.56 231.63,61.56 232.65,60.54 B07.B1 | v315.83,66.26 316.72,67.14 316.72,68.67 312.15,73.24 312.15,73.62 285.42,100.35 | 285.42,100.35 v284.59,101.18 | v259.83,90.13 v262.62,90.13 | v274.31,101.82 274.31,101.69 275.7,100.29 285.35,100.29 285.42,100.35
  Bottom 0.203: v193.41,43.4 193.41,43.52 v218.81,68.92 | v315.83,66.26 314.06,64.48 313.8,64.48 311.52,62.19 311.52,60.92 B01.B1 | v284.59,101.18 284.59,101.31 295.26,111.98 295.26,112.48 309.1,126.33 309.1,127.6 310.75,129.25 A01.B1 | v259.83,90.13 228.71,59.02 229.6,58.13 230.36,58.13 232.01,59.78 232.65,59.78 B07.B1 | v262.62,90.13 262.62,90.77 269.1,97.24 269.35,97.24 270.75,98.64 271.13,98.64 v274.31,101.82
I_BAC01  (via drill 0.61)
  Top 0.203: v196.58,20.41 194.8,22.19 194.8,22.57 189.34,28.03 188.07,28.03 B10.N2 | v306.06,59.27 306.82,58.51 306.82,56.48 309.1,54.19 310.37,54.19 B01.D1 | v314.82,73.37 314.82,78.7 v303.39,90.13 | v314.56,105.88 317.74,109.05 313.17,113.63 313.17,121.25 311.52,122.9 A01.D1 | v229.98,58.89 233.03,55.84 233.03,54.57 B07.D1 | v278.37,108.17 278.75,108.17 v312.15,74.77
  Bottom 0.203: v196.58,20.41 196.71,20.41 209.03,32.73 210.04,32.73 229.47,52.16 231,52.16 232.65,53.81 B07.D1 | v306.06,59.27 306.06,64.6 v314.82,73.37 314.44,73.62 313.29,74.77 v312.15,74.77 | v303.39,90.13 303.39,92.8 308.21,97.62 308.21,98.26 308.34,98.39 308.34,99.66 v314.56,105.88 | v229.98,58.89 229.98,59.78 256.4,86.19 257.03,86.19 273.04,102.2 273.04,102.45 277.99,107.4 277.99,107.78 v278.37,108.17
I_BAC02  (via drill 0.61)
  Top 0.203: v229.09,53.3 231,53.3 v234.81,49.49 | v316.22,52.79 315.58,52.79 294.75,73.62 294.75,74.26 v290.18,78.83 | v296.15,84.8 v288.4,92.54 | v257.03,68.16 258.81,68.16 v259.57,67.4 | v265.8,72.61 267.83,72.61 v270.5,69.94 | v275.19,73.62 279.38,73.62 v282.81,70.19
  Bottom 0.203: v229.09,53.3 196.96,21.17 196.2,21.17 190.87,15.84 190.87,13.3 B10.U2 | v234.81,49.49 235.06,49.49 235.82,50.25 B07.E1 237.22,50.38 239.89,50.38 240.27,50.76 240.27,51.14 256.65,67.53 256.65,67.78 v257.03,68.16 | v316.22,52.79 314.82,51.4 314.82,51.27 B01.E1 | v296.15,84.8 296.02,84.8 290.18,78.96 v290.18,78.83 290.43,78.45 282.81,70.83 v282.81,70.19 | v288.4,92.54 288.53,92.54 306.31,110.32 306.31,110.83 312.28,116.8 312.28,118.07 313.93,119.72 A01.E1 | v259.57,67.4 260.59,67.4 v265.8,72.61 | v270.5,69.94 271.51,69.94 v275.19,73.62
I_BAC03  (via drill 0.61)
  Top 0.203: v206.74,68.54 209.66,68.54 220.84,57.37 220.84,57.11 233.54,44.41 235.82,44.41 B07.H1 236.84,45.05 v236.84,47.46 | v315.58,46.7 315.58,49.24 v315.33,49.49 | v316.6,51.27 289.42,78.45 289.42,78.83 286.62,81.62 286.62,82 v285.1,83.53 | v287.64,86.19 v285.1,88.73 | v260.46,71.59 263.38,71.59 v265.54,69.43 | v280.27,81.88 v281.42,80.73
  Bottom 0.203: v206.74,68.54 187.18,48.98 186.68,48.98 182.36,44.67 178.55,44.67 B11.H2 | v315.58,46.7 314.69,45.81 314.69,45.05 B01.H1 | v315.33,49.49 315.33,50 v316.6,51.27 | v287.64,86.19 286.88,85.43 286.88,85.05 285.35,83.53 v285.1,83.53 284.97,83.15 282.56,80.73 v281.42,80.73 | v285.1,88.73 285.74,88.73 301.48,104.48 301.99,104.48 307.2,109.69 308.21,109.69 310.63,112.1 311.9,112.1 313.55,113.75 A01.H1 | v236.84,47.46 237.48,47.46 257.8,67.78 257.8,69.05 260.34,71.59 v260.46,71.59 | v265.54,69.43 267.83,69.43 v280.27,81.88
I_BAC04  (via drill 0.61)
  Top 0.203: v209.15,61.3 209.92,61.3 210.3,60.92 210.68,60.92 226.05,45.55 227.19,45.55 229.6,43.14 231,43.14 232.65,41.49 B07.J1 | v309.48,42.89 310.63,41.74 B01.J1 | v314.44,47.84 314.44,48.86 313.17,50.13 313.17,52.41 312.66,52.92 312.66,54.7 v282.43,84.92 282.43,85.31 v280.78,86.96
  Bottom 0.203: v209.15,61.3 186.42,38.57 186.42,37.43 177.79,28.79 175.37,28.79 B11.N2 | v314.44,47.84 v309.48,42.89 | v282.43,84.92 301.61,104.1 302.12,104.1 304.15,106.13 304.66,106.13 307.45,108.93 308.72,108.93 310.37,110.58 A01.J1 | v280.78,86.96 280.53,86.7 278.88,86.7 274.56,82.38 274.56,82.13 272.78,80.35 272.53,80.35 271,78.83 270.24,78.83 268.21,76.8 267.32,76.8 260.34,69.81 260.34,69.3 255.51,64.48 255,64.48 233.67,43.14 233.67,41.87 B07.J1
I_BAC05  (via drill 0.61)
  Top 0.203: 313.93,30.44 314.82,30.44 317.49,33.11 317.49,39.46 309.99,46.95 309.99,50.25 301.74,58.51 v301.61,58.51 | 313.93,30.44 313.8,30.44 311.52,32.73 311.52,34 B01.L1 | v305.8,68.92 v305.8,72.22 | v216.9,48.6 218.04,48.6 218.55,48.09 218.55,46.83 223.38,42 223.76,42 227.95,37.81 228.59,37.81 229.6,36.79 231,36.79 232.65,35.14 B07.L1 | v313.93,27.14 313.93,30.44 | v296.53,10.38 292.72,10.38 292.59,10.5 268.46,10.5 260.72,18.25 260.72,18.63 v260.34,19.01 | v251.45,11.39 247.51,11.39 232.27,26.63 231.63,26.63 229.09,29.17 v228.97,29.17
  Bottom 0.203: v301.61,58.51 301.61,61.68 302.75,62.83 302.75,65.88 v305.8,68.92 | v305.8,72.22 315.45,81.88 315.45,83.91 315.71,84.16 315.71,85.31 316.72,86.32 316.72,104.99 314.94,106.77 314.82,106.64 313.55,106.64 311.9,104.99 A01.L1 | v216.9,48.6 215.89,47.59 215.89,46.83 214.36,45.3 214.36,44.92 202.04,32.6 199.88,32.6 180.2,12.92 178.55,12.92 B11.U2 | v313.93,27.14 313.29,27.14 v296.53,10.38 | v260.34,19.01 259.06,19.01 v251.45,11.39 | v228.97,29.17 229.47,29.17 231.38,31.08 231.38,32.35 233.03,34 B07.L1
I_BAC06  (via drill 0.61)
  Top 0.203: v313.68,35.9 316.09,33.49 314.82,32.22 B01.M1 | v315.96,42.25 315.96,44.67 310.63,50 310.63,50.63 298.31,62.95 297.67,62.95 v295.77,64.86 | v314.31,83.91 314.31,85.43 v313.17,86.58 | v230.49,35.65 234.17,31.97 235.82,31.97 B07.M1 | v208.27,15.96 207.76,15.96 206.87,16.85 203.57,16.85 182.99,37.43 182.99,40.73 v174.36,49.37 | v265.92,36.66 264.91,36.66 v262.11,39.46 | v238.49,33.11 v246.49,25.11
  Bottom 0.203: v313.68,35.9 313.93,35.9 315.45,37.43 315.45,41.74 v315.96,42.25 | v314.31,83.91 314.18,83.91 309.99,79.72 309.99,79.59 295.77,65.37 v295.77,64.86 295.39,64.6 294.12,64.6 281.8,52.29 281.54,52.29 v265.92,36.66 | v313.17,86.58 313.17,99.91 313.93,100.67 A01.M1 | v230.49,35.65 230.49,35.01 226.43,30.95 224.9,30.95 221.22,27.27 219.44,27.27 218.68,28.03 217.92,27.27 217.92,26.51 219.19,25.23 214.87,20.92 213.22,20.92 v208.27,15.96 | v174.36,49.37 171.82,49.37 168.77,46.32 167.5,46.32 165.85,44.67 B12.H2 | v262.11,39.46 260.84,39.46 v246.49,25.11 | v238.49,33.11 238.36,33.11 237.22,31.97 B07.M1
I_BAC07  (via drill 0.61)
  Top 0.203: v246.37,30.95 247.25,30.95 259.95,18.25 260.21,18.25 268.34,10.12 270.62,10.12 272.53,8.22 v295.64,8.22 | v178.17,42.38 178.17,41.74 203.44,16.47 203.95,16.47 205.85,14.57 209.79,14.57 v212.96,11.39 | v294.75,65.75 296.02,65.75 311.01,50.76 311.01,50.13 v316.72,44.41 | v309.87,37.3 309.87,33.62 313.04,30.44 313.04,26.89 313.93,26 B01.P1
  Bottom 0.203: v246.37,30.95 242.56,27.14 238.87,27.14 237.35,25.62 237.22,25.62 B07.P1 235.82,24.85 234.17,23.2 232.78,23.2 226.81,17.23 226.3,17.23 223.51,14.44 223,14.44 219.95,11.39 v212.96,11.39 | v295.64,8.22 310.63,23.2 311.9,23.2 313.55,24.85 B01.P1 | v178.17,42.38 164.58,28.79 162.67,28.79 B12.N2 | v294.75,65.75 295.01,66 295.01,66.89 295.39,67.27 296.02,67.27 315.2,86.45 315.2,87.21 316.34,88.35 314.69,90 314.69,94.32 A01.P1 | v316.72,44.41 316.72,44.16 v309.87,37.3
I_BAC08  (via drill 0.61)
  Top 0.203: v212.71,3.26 187.06,3.26 183.25,7.07 178.8,7.07 174.48,11.39 170.93,11.39 170.17,12.15 165.85,12.15 B12.U2 | v234.3,16.98 v231.89,16.98 | 299.13,38 295.39,41.74 v295.39,41.87 | 299.13,38 313.93,23.2 313.93,19.65 B01.S1 | v257.67,5.42 251.7,5.42 240.27,16.85 238.87,16.85 237.22,18.5 B07.S1 | v315.96,86.7 314.69,87.97 A01.S1 | v311.77,50.51 v295.77,66.51 | 299.13,38 v299.45,38.32
  Bottom 0.203: v212.71,3.26 218.17,3.26 v231.89,16.98 | v234.3,16.98 235.82,18.5 B07.S1 | v295.39,41.87 295.26,41.87 259.19,5.8 258.05,5.8 v257.67,5.42 | v295.77,66.51 v315.96,86.7 | v311.77,50.51 311.64,50.51 v299.45,38.32
I_BAC09  (via drill 0.61)
  Top 0.203: v314.44,66 313.8,66 v290.43,89.37 | v312.66,110.83 312.66,114.13 306.82,119.98 306.82,121.25 305.17,122.9 A01.D2 | v155.43,45.43 161.78,45.43 v173.59,33.62 | v216.27,68.67 218.17,66.76 218.17,65.49 v228.2,55.46 | v300.34,48.35 300.34,47.97 v314.82,33.49 | v266.43,1.99 264.53,1.99 258.3,8.22 258.18,8.22 241.67,24.73 241.67,28.79 v232.14,38.32 | v233.92,45.17 228.97,50.13 228.97,51.4 227.32,53.05 B07.D2
  Bottom 0.203: v314.44,66 305.17,56.73 305.17,54.57 B01.D2 304.4,53.05 304.4,51.78 302.12,49.49 301.48,49.49 v300.34,48.35 | v290.43,89.37 290.43,92.42 301.74,103.72 302.25,103.72 304.28,105.75 307.58,105.75 v312.66,110.83 | v155.43,45.43 154.67,44.67 151.5,44.67 B13.H2 | v173.59,33.62 177.66,33.62 208.9,64.86 212.46,64.86 v216.27,68.67 | v228.2,55.46 227.32,54.57 B07.D2 | v314.82,33.49 316.98,31.33 308.47,22.82 307.71,22.82 292.72,7.84 289.16,7.84 289.04,7.71 286.75,7.71 286.5,7.46 284.97,7.46 280.53,3.01 278.75,3.01 277.23,1.49 273.8,1.49 273.67,1.36 267.07,1.36 v266.43,1.99 | v232.14,38.32 232.14,43.4 v233.92,45.17
I_BAC10  (via drill 0.61)
  Top 0.203: v314.06,59.78 314.06,60.41 v310.63,63.84 | v154.93,32.73 159.24,32.73 162.04,29.93 163.43,29.93 v166.36,27.01 | v214.87,66.13 216.39,66.13 228.2,54.32 228.2,53.05 229.86,51.4 B07.E2 | v275.57,20.92 275.57,21.17 273.54,23.2 266.56,23.2 254.75,35.01 254.49,35.01 v236.08,53.43
  Bottom 0.203: v314.06,59.78 309.99,55.72 309.61,55.72 308.34,54.45 308.34,51.4 B01.E2 307.2,50.25 304.91,50.25 295.77,41.11 295.13,41.11 292.85,38.82 292.85,38.19 v275.57,20.92 | v310.63,63.84 310.63,67.27 316.22,72.86 316.22,79.34 317.74,80.86 317.74,118.71 312.79,123.66 311.64,122.52 310.37,122.52 308.72,120.87 A01.E2 | v154.93,32.73 150.99,28.79 148.32,28.79 B13.N2 | v166.36,27.01 171.05,27.01 173.98,29.93 174.48,29.93 209.03,64.48 213.22,64.48 v214.87,66.13 | v236.08,53.43 235.57,53.43 233.67,51.52 231.38,51.52 230.87,51.02 B07.E2
I_BAC11  (via drill 0.61)
  Top 0.203: v284.08,68.92 287.77,65.24 287.77,62.83 289.8,60.8 289.8,60.03 305.17,44.67 307.2,44.67 B01.H2 | v306.31,93.94 v297.55,102.7 297.29,103.09 v281.42,118.96 | v170.29,8.22 161.4,8.22 158.23,11.39 156.58,11.39 155.81,12.15 151.5,12.15 B13.U2 | B07.H2 229.47,44.67 228.2,45.94 226.3,45.94 217.66,54.57 v217.66,55.08 217.28,54.95 210.93,61.3 210.42,61.3 209.54,62.19 209.03,62.19 206.49,64.73 v206.49,65.37 | v274.18,116.04 270.11,116.04 262.75,123.41 262.49,123.41 v250.81,135.09 | v217.92,111.72 216.65,111.72 v206.61,121.75 | v183.5,97.12 184.14,97.12 192.77,88.48 192.77,88.1 194.8,86.07 194.8,82.26 200.77,76.29 200.77,75.15 203.95,71.97 203.95,70.19 v207.63,66.51
  Bottom 0.203: v284.08,68.92 284.08,69.56 305.93,91.4 305.93,93.56 v306.31,93.94 | v297.55,102.7 298.18,102.7 305.93,110.45 305.93,111.72 307.58,113.37 A01.H2 | v170.29,8.22 209.54,47.46 210.04,47.46 v217.66,55.08 | v281.42,118.96 277.1,118.96 v274.18,116.04 | v250.81,135.09 241.54,135.09 239.63,133.19 239,133.19 229.86,124.04 229.86,123.66 v217.92,111.72 | v206.61,121.75 202.8,121.75 198.87,117.82 198.87,112.48 v183.5,97.12 | v206.49,65.37 v207.63,66.51
I_BREAK  (via drill 0.61)
  Top 0.203: B23.V2 18.15,8.98 22.46,8.98 23.23,8.22 28.69,8.22 29.45,8.98 B22.V2 30.85,8.98 32.75,7.07 v54.34,7.07 | v128.51,18.63 134.22,12.92 137.4,12.92 B14.U2 138.8,12.15 139.69,12.15 140.83,11.01 142.99,11.01 143.62,10.38 144.89,10.38 147.05,8.22 150.23,8.22 150.35,8.09 152.51,8.09 153.15,7.46 154.93,7.46 158.61,3.77 v161.02,3.77 | v228.97,23.58 236.08,16.47 236.71,16.47 v248.4,4.79 | v280.91,85.69 271.89,94.7 270.62,94.7 A04.P2 | v266.81,70.95 266.81,70.07 279,57.87 279.38,57.87 v285.61,51.65 | v263.76,28.41 267.83,24.35 268.59,24.35 269.1,24.85 B04.P2 | v190.23,10.5 195.95,10.5 v198.11,8.34
  Bottom 0.203: v128.51,18.63 126.86,18.63 119.62,11.39 113.27,11.39 110.09,8.22 55.48,8.22 v54.34,7.07 | v248.4,4.79 250.94,4.79 251.57,5.42 252.21,5.42 263.64,16.85 263.64,17.36 267.83,21.55 267.83,22.82 269.48,24.47 B04.P2 | B07.P2 229.86,24.47 v228.97,23.58 228.59,23.33 228.46,23.2 226.43,23.2 220.08,16.85 213.73,16.85 210.55,13.68 209.03,13.68 202.42,7.07 201.92,7.07 200.65,5.8 v198.11,8.34 | v280.91,85.69 280.91,84.92 266.94,70.95 v266.81,70.95 | v285.61,51.65 285.61,50.25 v263.76,28.41 | v161.02,3.77 183.25,3.77 186.93,7.46 187.18,7.46 v190.23,10.5
I_BRKRQ  (via drill 0.61)
  Top 0.203: v112,1.99 85.96,28.03 83.3,28.03 B18.N2 | v233.28,52.29 233.28,52.16 v242.68,42.76 245.48,39.97 245.98,39.97 v246.87,39.08 | v263.51,50.51 263.51,48.86 271.76,40.6 271.76,40.22 v272.27,39.71 | v284.21,85.43 268.46,101.18 268.46,101.69 269.48,102.7 269.48,107.02 A04.K2
  Bottom 0.203: v112,1.99 133.08,1.99 133.84,1.23 153.78,1.23 156.96,4.41 157.97,4.41 160.77,1.61 181.6,1.61 187.06,7.07 187.95,7.07 207.25,26.38 207.63,26.38 215.5,34.25 215.5,37.68 229.6,51.78 231.12,51.78 231.25,51.91 232.9,51.91 v233.28,52.29 | v246.87,39.08 252.08,39.08 256.78,43.78 256.78,44.41 257.54,45.17 258.18,45.17 v263.51,50.51 | v272.27,39.71 272.02,39.71 270.62,38.32 B04.K2 | v284.21,85.43 284.08,85.43 282.18,83.53 282.05,83.53 281.42,82.89 281.42,81.88 280.66,81.11 280.66,78.83 279.89,78.07 277.48,78.07 269.73,70.32 269.73,68.8 252.84,51.91 252.84,51.78 248.52,47.46 247.76,47.46 243.44,43.14 243.06,43.14 v242.68,42.76
I_CAINCR  (via drill 0.61)
  Top 0.203: v242.05,36.66 242.81,35.9 246.62,35.9 250.56,31.97 254.87,31.97 B05.M2 | v232.27,29.93 228.97,29.93 v213.6,45.3 | v228.59,62.32 228.59,63.72 223.63,68.67 223.63,70.7 217.92,76.42 217.92,77.56 v217.79,77.69 | v236.33,99.53 236.33,99.4 v244.08,91.66 | v82.66,36.79 78.85,36.79 74.92,40.73 70.6,40.73 B19.J2 | v143.75,97.88 145.53,97.88 188.58,54.83 190.36,54.83 192.9,52.29 193.53,52.29 199.5,46.32 203.31,46.32 v206.49,43.14
  Bottom 0.203: v242.05,36.66 239,36.66 v232.27,29.93 | v213.6,45.3 213.85,45.3 215.5,46.95 215.5,48.35 215.69,48.54 | 215.69,48.54 216.52,49.37 217.92,49.37 228.2,59.65 228.2,61.94 v228.59,62.32 | v217.79,77.69 217.79,80.99 222.49,85.69 222.49,85.81 224.27,87.59 224.39,87.59 225.66,88.86 225.66,88.99 227.44,90.77 227.57,90.77 v236.33,99.53 | v244.08,91.66 251.83,99.4 253.22,99.4 254.87,101.05 A05.M2 | v82.66,36.79 82.66,37.05 119.62,74 120,74 139.05,93.05 139.05,93.18 v143.75,97.88 | v206.49,43.14 206.74,43.14 209.03,45.43 210.55,45.43 213.73,48.6 215.63,48.6 215.69,48.54
I_DATA00  (via drill 0.61)
  Top 0.203: v98.92,118.45 111.87,118.45 v152.26,78.07 | v174.1,95.21 174.1,94.58 188.83,79.84 188.83,79.34 193.41,74.77 194.04,74.77 v212.2,56.6 | v231.89,75.27 232.78,75.27 239.13,68.92 239.76,68.92 241.67,67.02 241.67,66.76 248.14,60.29 248.14,59.78 250.43,57.49 250.43,57.11 v252.21,55.33 | v252.59,122.14 252.59,121.12 v267.83,105.88 | v248.52,83.91 245.98,83.91 243.57,86.32 v243.57,86.45
  Bottom 0.203: v98.92,118.45 45.7,65.24 45.2,65.24 44.44,64.48 39.1,64.48 30.46,55.84 30.46,54.57 B22.D2 | v152.26,78.07 156.96,78.07 v174.1,95.21 | v212.2,56.6 213.22,56.6 v231.89,75.27 232.27,75.53 237.22,80.48 237.86,80.48 240.4,83.02 240.78,83.02 243.57,85.81 v243.57,86.45 | v252.21,55.33 255,58.13 256.4,58.13 258.05,59.78 B05.B1 | v252.59,122.14 258.43,127.98 258.43,129.25 A05.B1 | v267.83,105.88 267.83,103.21 v248.52,83.91
I_DATA01  (via drill 0.61)
  Top 0.203: v57.64,30.44 48.12,39.97 42.28,39.97 35.16,47.08 30.85,47.08 B22.F2 | v110.6,71.34 117.46,71.34 v121.52,67.27 | v188.33,122.26 189.85,122.26 190.49,121.63 190.99,121.63 199.31,113.31 | 199.31,113.31 210.68,101.94 210.68,100.16 232.78,78.07 234.05,78.07 239,73.11 239,72.35 239.38,71.97 239.38,71.46 255,55.84 256.27,55.84 258.05,54.06 B05.D1 | v254.11,124.8 254.87,124.04 258.05,124.04 A05.D1 | v247,122.52 242.56,122.52 237.09,127.98 233.16,127.98 229.98,131.15 228.2,131.15 v225.79,133.57 | v212.58,122.52 210.3,122.52 v209.41,123.41 | 199.31,113.31 v200.39,114.39
  Bottom 0.203: v57.64,30.44 63.87,30.44 85.2,51.78 91.04,51.78 v110.6,71.34 | v121.52,67.27 125.72,67.27 140.96,82.51 141.34,82.51 154.42,95.59 155.43,95.59 156.45,96.61 157.34,96.61 169.28,108.55 169.53,108.55 170.67,109.69 171.18,109.69 177.15,115.66 181.72,115.66 v188.33,122.26 | v254.11,124.8 249.29,124.8 v247,122.52 | v225.79,133.57 225.79,133.44 214.87,122.52 v212.58,122.52 | v200.39,114.39 v209.41,123.41
I_DATA02  (via drill 0.61)
  Top 0.203: v63.36,20.54 60.18,23.71 45.32,23.71 34.53,34.51 34.53,38.44 32.24,40.73 30.85,40.73 B22.J2 | v105.9,35.4 107.17,35.4 108.95,33.62 113.78,33.62 114.92,32.47 115.43,32.47 118.22,29.68 123.05,29.68 124.7,28.03 125.72,28.03 133.97,19.77 134.48,19.77 137.27,16.98 141.97,16.98 150.48,8.47 152.64,8.47 153.27,7.84 155.69,7.84 v158.99,4.53 | v211.82,50.38 212.84,50.38 v213.73,49.49 | v238.75,74.51 239.89,74.51 v244.46,69.94 259.95,54.45 259.95,53.05 261.61,51.4 B05.E1 | v272.02,108.42 262.24,118.2 262.24,119.72 A05.E1 | v250.81,83.65 250.81,82.51 v252.59,80.73
  Bottom 0.203: v63.36,20.54 91.04,20.54 v105.9,35.4 | v158.99,4.53 165.47,4.53 188.58,27.65 189.22,27.65 211.82,50.25 v211.82,50.38 | v213.73,49.49 v238.75,74.51 | v272.02,108.42 272.02,106.9 251.19,86.07 251.19,84.04 v250.81,83.65 | v252.59,80.73 254.11,79.21 252.97,78.07 252.59,78.07 v244.46,69.94
I_DATA03  (via drill 0.61)
  Top 0.203: v70.34,17.74 45.45,17.74 30.46,32.73 30.46,34 B22.L2 | v164.32,76.92 v155.94,76.92 | v229.86,135.09 231.25,135.09 239,127.34 239.63,127.34 241.67,125.31 243.19,125.31 243.57,124.93 246.62,124.93 v258.94,112.61 | v271.26,47.97 271.26,50.89 270.37,51.78 266.43,51.78 265.54,52.67 264.53,52.67 254.37,62.83 254.37,65.37 249.67,70.07 249.67,70.95 233.92,86.7 233.03,86.7 v232.01,87.72 | v232.01,90.51 231.89,90.51 223.12,99.28 223.12,100.42 213.09,110.45 213.09,110.96 v210.81,113.25
  Bottom 0.203: v70.34,17.74 88.76,17.74 104.12,33.11 104.76,33.11 113.52,41.87 113.9,41.87 125.46,53.43 125.97,53.43 137.4,64.86 137.91,64.86 148.7,75.65 154.67,75.65 v155.94,76.92 | v164.32,76.92 180.45,93.05 185.79,93.05 191.76,99.02 192.77,99.02 199.5,105.75 202.8,105.75 210.55,113.5 | 210.55,113.5 210.68,113.63 210.68,116.42 215.5,121.25 216.01,121.25 v229.86,135.09 | v258.94,112.61 260.08,112.61 261.22,113.75 A05.H1 | v271.26,47.97 271.13,47.97 267.83,44.67 262.62,44.67 B05.H1 | v232.01,90.51 v232.01,87.72 | 210.55,113.5 v210.81,113.25
I_DATA04  (via drill 0.61)
  Top 0.203: v139.18,131.15 142.1,131.15 v161.02,112.23 | v201.66,135.72 211.69,135.72 212.46,134.96 213.47,134.96 223.12,125.31 223.63,125.31 226.43,122.52 227.57,122.52 227.63,122.58 | 227.63,122.58 229.47,124.42 229.47,125.31 228.59,126.2 228.59,127.98 228.33,128.23 228.33,128.99 229.73,130.39 240.02,120.1 240.02,118.71 240.9,117.82 240.9,114.39 243.83,111.47 243.95,111.47 244.84,110.58 244.84,110.45 245.48,109.82 246.75,109.82 247.38,109.18 247.38,107.91 251.83,103.47 v253.35,103.47 | v254.62,36.79 254.62,37.17 241.67,50.13 241.67,53.81 v218.68,76.8 | v214.74,93.94 v223.25,85.43 | v225.03,113.25 v225.03,104.1 | v228.84,119.72 228.84,121.37 227.63,122.58
  Bottom 0.203: v139.18,131.15 116.95,108.93 112.13,108.93 108.95,105.75 101.08,105.75 71.99,76.67 71.36,76.67 53.58,58.89 53.58,56.48 30.46,33.36 30.46,29.17 B22.N2 | v161.02,112.23 161.53,112.23 167.75,118.45 171.69,118.45 172.07,118.83 180.83,118.83 196.33,134.33 200.26,134.33 v201.66,135.72 | v253.35,103.47 253.35,103.85 256.78,107.28 256.78,108.55 258.43,110.2 A05.J1 | v254.62,36.79 256.14,36.79 258.43,39.08 258.43,40.35 B05.J1 | v218.68,76.8 218.68,80.86 v223.25,85.43 | v214.74,93.94 214.74,94.07 223.25,102.58 223.51,102.58 v225.03,104.1 | v225.03,113.25 225.03,113.63 228.2,116.8 228.2,119.09 v228.84,119.72
I_DATA05  (via drill 0.61)
  Top 0.203: v152.26,71.21 154.04,71.21 157.72,67.53 158.48,67.53 178.48,47.52 | v222.62,3.39 178.48,47.52 | v240.78,119.85 245.35,115.28 249.79,115.28 258.43,106.64 258.43,105.37 A05.L1 | v235.19,113.37 v235.19,115.66 | v228.97,99.66 v228.97,105.12 | 178.48,47.52 v178.29,47.33
  Bottom 0.203: v152.26,71.21 150.48,69.43 149.34,69.43 146.16,66.26 140.07,66.26 138.29,64.48 137.53,64.48 126.1,53.05 125.59,53.05 114.03,41.49 113.65,41.49 104.89,32.73 104.25,32.73 85.2,13.68 45.45,13.68 44.31,12.54 35.16,21.68 30.85,21.68 B22.R2 | v222.62,3.39 224.9,3.39 227.7,6.18 227.7,6.82 229.98,9.11 230.36,9.11 234.05,12.79 234.55,12.79 235.82,14.06 236.33,14.06 242.3,20.03 245.73,20.03 256.78,31.08 256.78,32.35 258.43,34 B05.L1 | v240.78,119.85 240.52,119.85 239.63,118.96 238.49,118.96 v235.19,115.66 | v235.19,113.37 235.19,111.59 235.06,111.47 235.06,110.96 230.74,106.64 230.49,106.64 v228.97,105.12 | v228.97,99.66 228.97,99.15 228.59,98.77 228.59,98.13 214.87,84.42 214.49,84.42 211.69,81.62 210.55,81.62 208.27,79.34 208.27,77.81 196.84,66.38 196.84,66 178.29,47.46 v178.29,47.33
I_DATA06  (via drill 0.61)
  Top 0.203: v268.21,25.11 262.37,30.95 B05.M1 | v284.21,36.03 v281.16,36.03 | v312.91,73.75 312.91,75.15 305.93,82.13 305.42,82.13 279.13,108.42 279.13,108.55 278.75,108.93 274.05,108.93 v273.8,109.18 | v120.13,131.92 142.23,131.92 142.99,131.15 143.37,131.15 164.96,109.56 165.72,109.56 176.9,98.39 178.42,98.39 v189.47,87.34 | v239.25,133.95 260.97,112.23 260.97,111.47 v266.3,106.13
  Bottom 0.203: v268.21,25.11 268.21,25.23 278.88,35.9 281.04,35.9 v281.16,36.03 | v284.21,36.03 284.59,36.03 296.66,48.09 296.66,49.87 296.78,50 296.78,50.51 302.75,56.48 302.75,61.56 303.9,62.7 303.9,64.73 v312.91,73.75 | v273.8,109.18 269.48,109.18 266.37,106.07 | 266.37,106.07 262.37,102.07 A05.M1 | v120.13,131.92 116.19,127.98 97.9,127.98 53.45,83.53 51.8,83.53 41.89,73.62 41.01,73.62 25.77,58.38 24.11,58.38 19.92,54.19 18.15,54.19 B23.D2 | v189.47,87.34 192.39,87.34 217.54,112.48 217.79,112.48 v239.25,133.95 | v266.3,106.13 266.37,106.07
I_DATA07  (via drill 0.61)
  Top 0.203: v303.01,70.95 303.01,71.97 272.4,102.58 v272.27,102.58 | B05.P1 261.61,26 261.61,27.01 v261.48,27.14 261.35,27.52 255.38,33.49 253.99,33.49 253.86,33.62 250.43,33.62 249.67,34.38 248.78,34.38 243.19,39.97 242.05,38.82 239.38,38.82 236.08,42.13 234.68,42.13 230.49,46.32 226.43,46.32 218.43,54.32 218.43,55.46 218.04,55.84 216.9,55.84 210.81,61.94 v210.81,62.06 | v56.5,6.18 18.78,43.9 18.78,44.92 17.77,45.94 17.77,46.7 B23.F2 | v121.14,6.18 122.03,6.18 122.92,5.3 128.13,5.3 130.16,3.26 143.11,3.26 v144.26,2.12
  Bottom 0.203: v261.48,27.14 261.48,27.27 263.38,29.17 264.02,29.17 281.67,46.83 281.67,48.09 283.7,50.13 283.7,50.89 285.23,52.41 285.99,52.41 296.4,62.83 296.4,64.35 v303.01,70.95 | v272.27,102.58 272.27,102.2 267.19,97.12 264.27,97.12 262.62,95.47 A05.P1 | v121.14,6.18 v56.5,6.18 | v144.26,2.12 151.62,2.12 186.8,37.3 186.8,37.94 209.41,60.54 209.54,60.54 209.92,60.92 209.92,61.18 v210.81,62.06
I_DATA08  (via drill 0.61)
  Top 0.203: v292.97,51.78 292.47,51.78 281.42,62.83 281.42,63.34 277.23,67.53 275.07,67.53 260.72,81.88 v260.72,83.53 | v124.44,128.74 138.54,128.74 158.35,108.93 159.24,108.93 188.45,79.72 188.45,76.67 v201.03,64.1 | v224.01,74.13 v239.51,58.64
  Bottom 0.203: v292.97,51.78 275.07,33.87 275.07,33.49 262.88,21.3 262.88,20.03 262.37,19.52 B05.S1 | A05.S1 261.61,87.97 260.72,87.08 v260.72,83.53 260.46,83.15 254.49,77.18 254.49,76.42 253.99,75.91 253.99,74.77 251.19,71.97 251.19,69.94 239.89,58.64 v239.51,58.64 | v124.44,128.74 111.36,115.66 97.78,115.66 94.98,112.86 94.47,112.86 61.71,80.1 61.07,80.1 45.83,64.86 45.32,64.86 39.99,59.52 39.23,59.52 36.56,56.86 36.05,56.86 20.69,41.49 18.15,41.49 B23.J2 | v201.03,64.1 201.15,64.1 206.36,69.3 208.52,69.3 209.66,70.45 220.33,70.45 v224.01,74.13
I_DATA09  (via drill 0.61)
  Top 0.203: v133.59,136.74 156.83,136.74 166.23,127.34 166.23,122.77 174.86,114.13 175.63,114.13 186.68,103.09 187.18,103.09 v190.87,99.4 | v232.14,136.61 237.73,136.61 248.65,125.69 250.05,125.69 251.7,124.04 A05.D2 | v234.81,69.43 241.29,62.95 241.29,62.7 249.79,54.19 251.7,54.19 B05.D2 | v238.24,71.46 224.01,85.69 224.01,85.81 214.74,95.08 214.11,95.08 v201.28,107.91
  Bottom 0.203: v133.59,136.74 112.13,115.28 97.9,115.28 95.11,112.48 94.6,112.48 61.83,79.72 61.2,79.72 45.96,64.48 45.45,64.48 40.12,59.14 39.35,59.14 36.69,56.48 36.18,56.48 17.77,38.06 17.77,35.52 B23.L2 | v190.87,99.4 192.64,99.4 201.22,107.98 | 201.22,107.98 225.66,132.42 225.79,132.42 229.22,135.85 231.38,135.85 v232.14,136.61 | v234.81,69.43 235.44,69.43 235.7,69.68 236.46,69.68 v238.24,71.46 | 201.22,107.98 v201.28,107.91
I_DATA10  (via drill 0.61)
  Top 0.203: v199.76,71.97 201.03,71.97 207.25,65.75 211.06,65.75 v217.66,59.14 | 238.17,72.67 239,71.84 239,71.08 v257.29,52.79 | v235.57,75.27 238.17,72.67 | v247.64,114.52 247.64,112.99 249.41,111.21 249.41,110.45 248.78,109.82 249.67,108.93 249.79,108.93 v260.97,97.75 | 238.17,72.67 v238.24,72.73
  Bottom 0.203: v199.76,71.97 197.6,69.81 197.6,69.18 191.63,63.21 191.63,62.83 177.4,48.6 174.1,48.6 172.07,46.57 171.18,46.57 157.34,32.73 156.58,32.73 132.83,8.98 131.94,8.98 129.78,6.82 122.92,6.82 118.86,2.76 111.62,2.76 110.09,1.23 46.59,1.23 19.8,28.03 18.15,28.03 B23.N2 | v217.66,59.14 217.66,59.78 218.68,60.8 219.57,60.8 223.25,64.48 224.78,64.48 v235.57,75.27 | v257.29,52.79 255.89,51.4 B05.E2 | v247.64,114.52 247.76,114.52 248.91,115.66 251.06,115.66 251.57,116.17 252.97,116.17 255.26,118.45 255.26,119.72 A05.E2 | v260.97,97.75 260.97,97.5 247.76,84.29 247.76,82.64 244.84,79.72 244.84,79.34 v238.24,72.73
I_DATA11  (via drill 0.61)
  Top 0.203: v45.96,14.57 42.78,17.74 20.05,17.74 17.77,20.03 17.77,21.3 B23.R2 | v177.15,134.84 186.17,134.84 199.63,121.37 200.14,121.37 210.93,110.58 v211.06,110.58 211.31,110.2 v211.31,105.12 | v240.78,135.98 241.79,135.98 v258.94,118.83 | v251.7,52.29 v257.41,46.57 | v248.14,52.16 244.84,52.16 221.85,75.15 221.85,75.27 211.95,85.18 211.44,85.18 v204.07,92.54
  Bottom 0.203: v45.96,14.57 53.33,14.57 79.49,40.73 80,40.73 81.9,42.63 82.41,42.63 104.25,64.48 106.03,64.48 110.6,69.05 110.6,69.3 138.16,96.86 138.16,97.5 145.53,104.86 145.53,106.64 149.21,110.32 149.21,110.83 158.35,119.98 158.35,121.75 167.75,131.15 173.47,131.15 v177.15,134.84 | v211.06,110.58 211.69,110.58 223.12,122.01 223.63,122.01 235.95,134.33 237.22,134.33 237.6,134.71 238.36,134.71 238.75,135.09 239.89,135.09 v240.78,135.98 | v258.94,118.83 260.46,117.31 259.32,116.17 257.92,116.17 256.27,114.52 A05.H2 | v257.41,46.57 255.89,45.05 B05.H2 | v251.7,52.29 248.27,52.29 v248.14,52.16 | v204.07,92.54 204.07,94.32 204.33,94.58 204.33,98.13 v211.31,105.12
I_DATAIN  (via drill 0.61)
  Top 0.203: v205.98,138.9 221.73,138.9 222.62,139.79 228.46,139.79 230.11,138.14 230.87,138.14 231.25,138.52 254.75,138.52 v280.66,112.61 | v272.53,26.89 270.24,29.17 270.24,30.82 B04.M2 | v298.69,57.62 298.05,57.62 296.02,59.65 296.02,59.91 277.23,78.7 277.23,79.08 v273.8,82.51 | v282.05,90.26 282.05,90.89 273.54,99.4 272.27,99.4 270.62,101.05 A04.M2
  Bottom 0.203: v205.98,138.9 191.63,124.55 191.63,119.98 177.91,106.26 177.28,106.26 175.75,104.74 175.75,104.1 162.42,90.77 162.29,90.77 113.78,42.25 113.4,42.25 108.06,36.92 106.28,36.92 92.57,23.2 88.38,23.2 87.61,22.44 83.3,22.44 B18.R2 | v280.66,112.61 280.66,110.58 279.89,109.82 278.88,109.82 277.61,108.55 277.61,107.53 273.54,103.47 272.02,103.47 270.5,101.94 A04.M2 | v272.53,26.89 273.16,26.89 286.88,40.6 286.88,43.9 291.58,48.6 294.88,48.6 296.4,50.13 296.4,55.33 v298.69,57.62 | v273.8,82.51 274.18,82.51 281.93,90.26 v282.05,90.26
I_EXTA0  (via drill 0.61)
  Top 0.203: v250.05,8.22 249.41,8.22 240.4,17.23 239.89,17.23 233.92,23.2 230.49,23.2 v212.71,40.98 | v221.85,52.16 221.85,54.32 v219.44,56.73 | v248.65,86.58 248.65,85.94 249.67,84.92 249.67,83.65 250.43,82.89 250.43,81.62 252.08,79.97 A05.V2 | v142.99,1.99 142.23,1.23 111.62,1.23 110.22,2.63 109.08,2.63 103.87,7.84 100.95,7.84 98.41,10.38 96.89,10.38 89.52,17.74 72.5,17.74 70.22,20.03 70.22,21.3 B19.R2 | v174.74,26.38 181.34,26.38 v190.36,17.36
  Bottom 0.203: v250.05,8.22 250.81,8.98 251.7,8.98 B05.V2 | v212.71,40.98 212.71,41.49 215.44,44.22 | 215.44,44.22 218.55,47.33 218.55,48.86 v221.85,52.16 | v219.44,56.73 231.51,68.8 231.51,69.56 234.55,72.61 234.81,72.61 248.65,86.45 v248.65,86.58 | v142.99,1.99 143.88,2.88 151.24,2.88 v174.74,26.38 | v190.36,17.36 191.88,17.36 196.07,21.55 196.45,21.55 215.5,40.6 215.5,44.16 215.44,44.22
I_EXTA1  (via drill 0.61)
  Top 0.203: v143.88,99.4 144.51,99.4 162.93,80.99 163.56,80.99 v188.96,55.59 | v210.17,74.38 211.69,74.38 217.03,69.05 217.03,68.41 v225.41,60.03 | v243.83,26.38 244.08,26.12 244.08,25.23 246.11,23.2 246.62,23.2 252.08,17.74 252.08,16.47 B05.T2 | v232.27,19.14 228.2,23.2 228.2,24.35 211.95,40.6 211.95,43.14 210.93,44.16 210.93,44.54 197.34,58.13 196.58,58.13 v195.31,59.4
  Bottom 0.203: v143.88,99.4 142.86,98.39 142.86,97.62 133.97,88.73 133.97,88.48 119.87,74.38 119.49,74.38 87.11,42 86.73,42 73.52,28.79 70.6,28.79 B19.N2 | v188.96,55.59 191.37,55.59 195.25,59.46 | 195.25,59.46 v210.17,74.38 | v225.41,60.03 225.41,60.29 229.6,64.48 231,64.48 235.82,69.3 236.71,69.3 236.97,69.56 238.24,69.56 250.43,81.75 250.43,82.13 251.57,83.27 251.57,84.29 252.08,84.8 A05.T2 | v243.83,26.38 241.29,26.38 240.78,25.87 240.14,25.87 239.76,25.49 238.49,25.49 237.09,24.09 236.84,24.09 236.21,23.46 236.21,23.08 v232.27,19.14 | v195.31,59.4 195.25,59.46
I_EXTA2  (via drill 0.61)
  Top 0.203: v259.32,23.71 259.32,24.98 v257.29,27.01 | v277.35,49.24 277.35,51.14 267.19,61.3 266.81,61.3 v252.84,75.27 | v259.95,84.54 259.95,86.07 259.32,86.7 257.92,86.7 256.27,88.35 A05.S2 | v105.39,7.46 85.58,27.27 82.03,27.27 80.12,29.17 78.6,29.17 73.39,34.38 70.6,34.38 B19.L2 | v159.5,39.71 161.66,39.71 170.93,30.44 177.28,30.44 180.45,27.27 182.61,27.27 v183.12,26.76 | v228.84,70.57 231,70.57 239,62.57 v239,62.45
  Bottom 0.203: v259.32,23.71 258.81,23.2 258.18,23.2 255.89,20.92 255.89,19.65 B05.S2 | v257.29,27.01 257.29,29.17 v277.35,49.24 | v259.95,84.54 252.84,77.43 v252.84,75.27 252.46,75.02 239.89,62.45 v239,62.45 | v105.39,7.46 117.21,7.46 118.35,8.6 119.75,8.6 137.53,26.38 143.88,26.38 156.58,39.08 158.86,39.08 v159.5,39.71 | v183.12,26.76 183.12,27.39 196.45,40.73 197.09,40.73 208.9,52.54 209.66,52.54 213.47,56.35 213.73,56.35 220.08,62.7 220.97,62.7 v228.84,70.57
I_INIT  (via drill 0.61)
  Top 0.203: B06.N1 246.75,28.03 248.91,28.03 266.81,10.12 B04.V2 267.45,9.11 273.92,2.63 v283.96,2.63 | v281.42,64.99 267.57,78.83 267.45,78.83 A04.V2 | v298.69,74 298.31,74 v295.64,76.67
  Bottom 0.203: v283.96,2.63 291.83,2.63 297.42,8.22 298.94,8.22 299.71,8.98 304.02,8.98 B01.V2 | B06.N1 246.75,28.79 248.4,30.44 249.79,30.44 250.56,31.2 250.56,31.59 250.81,31.84 250.05,32.6 250.05,34.76 254.49,39.2 254.49,39.84 274.81,60.16 275.57,60.16 280.15,64.73 280.53,64.73 280.78,64.99 v281.42,64.99 281.8,65.11 284.47,67.78 285.1,67.78 290.43,73.11 290.94,73.11 291.32,73.49 291.58,73.49 294.75,76.67 v295.64,76.67 | v298.69,74 302.37,77.69 303.01,77.69 304.02,78.7 304.15,78.7 A01.V2
I_IOP1  (via drill 0.61)
  Top 0.203: v296.66,112.1 301.99,112.1 304.28,109.82 305.55,109.82 307.2,108.17 A01.K2 | v295.39,30.06 294.12,30.06 273.54,50.63 272.78,50.63 270.11,53.3 268.84,53.3 267.19,54.95 266.43,54.95 v252.59,68.8
  Bottom 0.203: 253.03,68.35 261.35,76.67 261.35,76.8 v296.66,112.1 | 253.03,68.35 249.54,64.86 249.54,64.1 B06.A1 | v295.39,30.06 298.44,33.11 300.59,33.11 305.67,38.19 307.2,38.19 B01.K2 | 253.03,68.35 v252.59,68.8
I_IOP2  (via drill 0.61)
  Top 0.203: v286.24,17.74 280.4,17.74 262.56,35.59 | 262.56,35.59 251.19,46.95 251.19,50.38 248.65,52.92 247.25,52.92 246.75,53.43 B06.D1 | v309.87,99.15 308.34,100.67 A01.M2 | v298.82,82.38 298.82,82.26 v302.63,78.45 | 262.56,35.59 v262.62,35.65
  Bottom 0.203: v286.24,17.74 295.77,17.74 297.29,19.27 297.29,22.57 305.93,31.2 307.2,31.2 B01.M2 | v309.87,99.15 309.87,93.43 v298.82,82.38 | v302.63,78.45 301.99,78.45 292.09,68.54 292.09,68.16 275.07,51.14 275.07,47.84 267.19,39.97 266.94,39.97 v262.62,35.65
I_IOP4  (via drill 0.61)
  Top 0.203: v300.21,33.87 300.47,33.62 300.47,31.08 301.99,29.55 305.29,29.55 307.58,27.27 307.58,26 B01.P2 | v309.48,44.16 309.48,45.68 v303.26,51.91 | v306.31,66 306.31,67.02 305.04,68.29 305.04,70.19 | 305.04,70.19 305.04,70.95 297.29,78.7 v297.29,80.86 | v268.84,69.18 269.23,69.18 v271.64,66.76 | v289.29,84.42 289.42,84.42 299.45,74.38 299.45,73.37 302.63,70.19 305.04,70.19
  Bottom 0.203: v300.21,33.87 300.21,35.01 301.99,36.79 302.12,36.79 303.39,38.06 303.39,38.19 305.17,39.97 305.29,39.97 v309.48,44.16 | v303.26,51.91 300.98,51.91 298.69,49.62 297.93,49.62 297.17,50.38 303.13,56.35 303.13,61.43 304.28,62.57 304.28,63.97 v306.31,66 | v297.29,80.86 297.29,82.26 306.31,91.27 306.31,92.8 307.83,94.32 A01.P2 | v268.84,69.18 266.3,66.64 266.3,66 252.46,52.16 252.46,51.91 248.4,47.84 246.75,47.84 B06.F1 | v271.64,66.76 271.64,67.4 287,82.77 287.64,82.77 v289.29,84.42
I_IRQ  (via drill 0.61)
  Top 0.203: v283.96,27.14 282.94,28.16 282.94,30.82 B03.M2 | v262.11,2.63 258.81,2.63 258.56,2.88 249.03,2.88 v239,12.92 | v224.27,2.25 223.12,2.25 222.87,1.99 218.55,1.99 v214.62,5.93 | 198.87,5.93 194.3,5.93 193.91,6.31 193.28,6.31 177.79,21.81 177.79,22.19 173.98,26 173.98,26.25 v173.47,26.76 | v202.42,5.93 198.87,5.93 | v152.89,5.93 140.07,5.93 125.97,20.03 121.02,20.03 113.78,27.27 112.76,27.27 v89.27,50.76 | v274.69,105.75 278.5,101.94 281.42,101.94 281.54,101.82 281.8,101.82 A03.M2 | v267.7,101.43 266.69,101.43 v262.11,106.01 | v241.79,85.81 241.79,85.18 v251.32,75.65 | v220.58,45.94 220.58,45.81 223.63,42.76 v223.76,42.76 | 198.87,5.93 v198.87,11.9
  Bottom 0.203: v283.96,27.14 283.96,23.58 275.07,14.69 274.18,14.69 v262.11,2.63 | v239,12.92 238.62,12.92 233.92,8.22 233.16,8.22 228.97,4.03 226.05,4.03 v224.27,2.25 | v214.62,5.93 v202.42,5.93 | v173.47,26.76 173.47,25.62 162.42,14.57 161.53,14.57 v152.89,5.93 | v89.27,50.76 87.49,50.76 86.22,49.49 84.95,49.49 83.3,47.84 B18.F2 | v274.69,105.75 272.02,105.75 v267.7,101.43 | v262.11,106.01 261.86,106.01 259.32,103.47 258.94,103.47 257.03,101.56 257.03,101.05 254.11,98.13 254.11,97.12 249.16,92.16 248.52,92.16 246.75,90.39 246.37,90.39 v241.79,85.81 | v251.32,75.65 244.84,69.18 244.59,69.18 233.03,57.62 232.52,57.62 230.74,55.84 230.49,55.84 228.33,53.68 228.33,53.43 221.22,46.32 220.97,46.32 v220.58,45.94 | v223.76,42.76 223.76,41.62 215.25,33.11 215.25,31.08 213.09,28.92 213.09,26 210.55,23.46 210.55,23.08 200.01,12.54 199.5,12.54 v198.87,11.9
I_LINE  (via drill 0.61)
  Top 0.203: v316.22,37.3 v316.22,39.59 | v316.47,54.06 315.45,54.06 v298.31,71.21 | v292.85,68.16 290.81,68.16 280.15,78.83 A03.V2 | v92.06,41.62 93.08,41.62 104.25,30.44 105.27,30.44 118.35,17.36 118.86,17.36 121.65,14.57 125.97,14.57 v132.32,8.22 | v160.64,24.09 169.53,24.09 v187.69,5.93 | v229.22,40.6 232.14,40.6 246.87,25.87 247,25.87 248.02,24.85 248.02,24.73 v268.21,4.53
  Bottom 0.203: v316.22,37.3 290.05,11.14 289.29,11.14 288.66,10.5 285.23,10.5 284.47,9.74 280.15,9.74 B03.V2 278.62,8.98 274.18,4.53 v268.21,4.53 | v316.22,39.59 316.22,41.36 316.72,41.87 316.72,43.27 317.49,44.03 317.49,48.6 317.61,48.73 317.61,52.92 v316.47,54.06 | v298.31,71.21 295.9,71.21 v292.85,68.16 | v92.06,41.62 85.58,35.14 83.3,35.14 B18.L2 | v132.32,8.22 134.1,6.44 142.99,6.44 v160.64,24.09 | v187.69,5.93 194.55,5.93 v229.22,40.6
I_MB00  (via drill 0.61)
  Top 0.203: v230.49,117.31 230.49,114.9 A07.H2 | v295.01,58.51 295.01,59.14 283.19,70.95 282.94,70.95 267.19,86.7 266.18,86.7 v265.92,86.96 265.67,87.34 263.38,89.62 263.38,90.51 263,90.89 262.88,90.89 247.25,106.52 v246.24,106.52 | v232.27,115.53 232.52,115.53 233.54,114.52 233.54,113.88 239.13,108.29 239.76,108.29 v242.94,105.12
  Bottom 0.203: v230.49,117.31 231.12,117.31 242.17,128.36 244.08,128.36 245.35,129.63 A06.B1 | v295.01,58.51 295.39,58.89 296.15,58.89 296.53,59.27 297.17,59.27 297.67,59.78 B02.B1 | v265.92,86.96 265.92,89.5 266.43,90 267.7,90 296.91,119.21 296.91,128.11 298.05,129.25 A02.B1 | v232.27,115.53 231.25,114.52 230.87,114.52 A07.H2 | v242.94,105.12 244.84,105.12 v246.24,106.52
I_MB01  (via drill 0.61)
  Top 0.203: v225.79,100.55 226.68,99.66 226.68,99.02 A07.N2 | v299.32,56.48 298.69,56.48 273.04,82.13 273.04,83.02 v266.81,89.24 266.43,89.37 261.86,93.94 261.35,93.94 252.21,103.09 251.7,103.09 246.62,108.17 v246.62,108.8 | v241.67,117.31 241.67,117.06 v248.27,110.45
  Bottom 0.203: v225.79,100.55 225.79,100.8 229.73,104.74 229.73,105.12 235.44,110.83 235.44,111.34 241.48,117.37 | 241.48,117.37 244.08,119.98 244.08,121.25 245.73,122.9 A06.D1 | v299.32,56.48 298.82,55.97 298.82,54.57 B02.D1 | v266.81,89.24 267.45,89.24 297.29,119.09 297.29,122.14 298.05,122.9 A02.D1 | v241.67,117.31 241.54,117.31 241.48,117.37 | v248.27,110.45 v246.62,108.8
I_MB02  (via drill 0.61)
  Top 0.203: v224.39,91.78 229.86,86.32 229.86,83.15 A07.U2 | 266.5,87.91 251.7,102.7 251.57,102.7 v243.57,110.71 | 266.5,87.91 283.07,71.34 283.32,71.34 301.23,53.43 301.23,51.4 B02.E1 | v266.69,87.97 266.56,87.97 266.5,87.91
  Bottom 0.203: v224.39,91.78 224.65,91.78 238.75,105.88 238.75,106.39 241.29,108.93 241.29,110.32 242.62,111.66 | 242.62,111.66 244.46,113.5 244.46,114.01 247.25,116.8 247.25,118.07 248.91,119.72 A06.E1 | 242.62,111.66 v243.57,110.71 | v266.69,87.97 298.82,120.1 300.85,120.1 A02.E1
I_MB03  (via drill 0.61)