# EAGLE board dw08aholes (EAGLE 4.11), part 3 of 4
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
I_EXTA2  (via drill 0.61) (continued)
  Top 0.152: v232.14,42.76 232.27,42.63 232.27,40.6 239.38,33.49 240.14,33.49 241.79,31.84 241.79,31.08 243.32,29.55 246.49,29.55 255.26,20.79 255.26,19.65 B05.S2 | v236.84,48.48 236.84,48.73 235.44,50.13 235.44,51.78 235.32,51.91 235.32,53.68 234.3,54.7 234.3,55.33 v226.55,63.08 | v239.25,76.03 239.25,77.18 238.11,78.32 237.86,78.32 237.35,78.83 237.35,79.97 235.44,81.88 235.44,85.05 230.62,89.88 230.36,89.88 v229.22,91.02 | 240.27,102.32 v239.13,102.32 | 240.27,102.32 241.16,101.43 241.16,100.93 249.92,92.16 250.56,92.16 251.95,90.77 253.22,90.77 254.87,89.12 A05.S2 | v77.33,30.44 73.39,34.38 70.6,34.38 B19.L2 | v144.64,92.16 145.27,92.16 147.05,90.39 147.56,90.39 153.53,84.42 158.23,84.42 163.05,79.59 163.05,79.08 165.09,77.05 166.86,77.05 v168.13,75.78 | v219.44,122.14 219.44,121.63 223,118.07 226.05,118.07 226.93,118.96 231.25,114.64 231.25,111.34 240.27,102.32
  Bottom 0.152: v232.14,42.76 232.14,43.78 v236.84,48.48 | v226.55,63.08 226.55,63.34 v239.25,76.03 | v229.22,91.02 229.22,91.53 233.92,96.23 233.92,97.12 v239.13,102.32 | v77.33,30.44 86.09,30.44 86.85,31.2 86.85,34.25 104.38,51.78 105.01,51.78 140.83,87.59 140.83,87.97 142.86,90 142.86,90.39 v144.64,92.16 | v168.13,75.78 169.66,75.78 180.58,86.7 184.39,86.7 193.03,95.34 193.03,96.1 203.06,106.13 204.71,106.13 215.38,116.8 215.38,119.98 217.03,121.63 218.93,121.63 v219.44,122.14
I_INIT  (via drill 0.61)
  Top 0.152: v270.11,80.61 272.65,78.07 274.94,78.07 v275.19,77.81 | v281.93,84.42 282.56,84.42 v295.64,71.34 | B06.N1 246.37,27.65 246.62,27.39 246.62,26.63 248.14,25.11 248.14,24.73 253.86,19.01 253.86,18.12 262.24,9.74 265.92,9.74 B04.V2 267.45,8.98 271.64,4.79 285.48,4.79 286.5,3.77 v294.88,3.77 | v299.71,74 299.71,73.75 305.67,67.78 305.93,67.78 306.18,67.53 306.44,67.53 v315.58,58.38 | v312.53,52.79 312.53,48.6 316.22,44.92 316.22,41.36 v316.6,40.98
  Bottom 0.152: v270.11,80.61 269.73,80.23 269.23,80.23 268.59,79.59 267.45,79.59 A04.V2 | v275.19,77.81 275.32,77.81 v281.93,84.42 | v295.64,71.34 296.53,71.34 299.45,74.26 | 299.45,74.26 304.02,78.83 A01.V2 | v294.88,3.77 300.09,8.98 304.02,8.98 B01.V2 305.17,10.12 306.82,11.77 306.82,12.92 316.6,22.7 v316.6,40.98 | v299.71,74 299.45,74.26 | v315.58,58.38 315.58,55.84 v312.53,52.79
I_IOP1  (via drill 0.61)
  Top 0.152: v256.53,66 266.81,55.72 267.57,55.72 272.65,50.63 273.29,50.63 274.18,49.75 274.18,49.11 291.45,31.84 292.34,31.84 v295.26,28.92 | v315.45,98.64 308.34,105.75 308.34,107.02 A01.K2 | v293.99,67.27 293.99,66.64 299.96,60.67 299.96,57.49 300.47,56.98 300.47,56.6 302.37,54.7 302.37,52.54 v309.87,45.05
  Bottom 0.152: v256.53,66 256.14,65.62 255,65.62 254.24,64.86 251.45,64.86 250.3,63.72 249.92,63.72 B06.A1 | v295.26,28.92 295.39,28.79 302.5,35.9 303.9,35.9 304.28,36.28 305.93,36.28 307.2,37.55 B01.K2 308.34,38.7 308.72,39.08 308.72,41.74 309.87,42.89 v309.87,45.05 | v315.45,98.64 315.45,91.4 313.17,89.12 313.17,86.7 312.91,86.45 312.91,85.81 305.17,78.07 304.91,78.07 294.12,67.27 v293.99,67.27
I_IOP2  (via drill 0.61)
  Top 0.152: v248.27,55.59 v269.61,34.25 | v306.06,29.81 289.93,45.94 289.55,45.94 285.74,49.75 v285.48,49.75 285.23,50.13 284.21,51.14 v284.21,52.67 | v314.44,87.08 312.66,88.86 312.66,92.42 308.34,96.74 308.34,100.67 A01.M2
  Bottom 0.152: v248.27,55.59 246.87,54.19 246.75,54.19 B06.D1 | v269.61,34.25 269.86,34.25 276.34,40.73 276.34,41.36 282.18,47.21 282.94,47.21 v285.48,49.75 | v306.06,29.81 307.32,31.08 B01.M2 | v314.44,87.08 314.44,85.69 314.06,85.31 313.68,85.31 296.02,67.65 296.02,65.62 284.59,54.19 284.59,53.05 v284.21,52.67
I_IOP4  (via drill 0.61)
  Top 0.152: v297.8,36.66 298.18,36.28 299.07,36.28 305.29,30.06 305.29,29.43 306.44,28.28 306.44,27.78 307.58,26.63 307.58,26 B01.P2 | v293.36,32.22 291.58,32.22 276.85,46.95 276.85,47.59 v276.08,48.35 v273.04,51.4 | v257.92,37.81 257.29,37.81 252.84,42.25 252.33,42.25 250.3,44.29 250.3,44.79 249.67,45.43 249.16,45.43 246.75,47.84 B06.F1 | v313.68,86.07 312.28,87.46 312.28,92.29 309.87,94.7 308.72,94.7 A01.P2
  Bottom 0.152: v293.36,32.22 v297.8,36.66 | v273.04,51.4 272.91,51.4 263.38,41.87 261.99,41.87 v257.92,37.81 | v313.68,86.07 313.68,85.81 276.21,48.35 v276.08,48.35
I_IRQ  (via drill 0.61)
  Top 0.152: v280.66,32.35 281.04,31.97 281.8,31.97 B03.M2 | v264.4,15.2 261.61,15.2 v259.95,16.85 | v243.57,1.49 241.92,1.49 241.41,1.99 240.78,1.99 240.65,2.12 238.75,2.12 237.73,3.14 237.35,3.14 231.89,8.6 230.62,8.6 v204.71,34.51 | v190.1,21.81 190.1,21.93 v163.31,48.73 | v121.02,11.39 116.06,11.39 88.5,38.95 88.5,39.97 84.57,43.9 84.57,45.05 82.92,46.7 B18.F2 | v248.91,138.77 253.35,134.33 256.02,134.33 264.15,126.2 264.91,126.2 266.3,124.8 267.07,124.8 268.34,123.53 268.34,123.15 269.86,121.63 270.24,121.63 281.42,110.45 281.42,107.4 282.18,106.64 282.18,102.2 A03.M2 | v241.29,138.27 240.14,138.27 v238.75,139.66 | v155.81,70.7 155.81,66.26 158.23,63.84 158.23,61.05 v165.47,53.81
  Bottom 0.152: v280.66,32.35 280.66,31.71 277.86,28.92 277.86,28.66 v264.4,15.2 | v259.95,16.85 258.3,16.85 251.32,9.87 251.32,9.23 v243.57,1.49 | v204.71,34.51 202.8,34.51 v190.1,21.81 | v121.02,11.39 149.21,39.59 150.35,39.59 150.73,39.97 154.42,39.97 160.77,46.32 162.29,46.32 163.31,47.33 v163.31,48.73 163.56,49.11 163.94,49.49 163.94,51.02 165.47,52.54 v165.47,53.81 | v248.91,138.77 241.79,138.77 v241.29,138.27 | v238.75,139.66 237.22,139.66 236.71,140.17 222.87,140.17 213.22,130.52 213.22,130.01 210.81,127.6 210.81,126.58 201.03,116.8 201.03,115.79 155.94,70.7 v155.81,70.7
I_LINE  (via drill 0.61)
  Top 0.152: v294.5,27.14 294.5,28.28 v273.42,49.37 | v290.81,66.64 290.81,67.65 279.89,78.57 A03.V2 | v113.78,8.6 105.01,17.36 97.9,17.36 82.92,32.35 82.92,34 B18.L2 | v157.47,40.35 158.99,40.35 159.62,39.71 160.39,39.71 162.93,37.17 163.31,37.17 188.2,12.28 188.71,12.28 189.98,11.01 190.49,11.01 193.28,8.22 199.12,8.22 199.5,7.84 206.23,7.84 v210.93,3.14 | v237.86,10.76 239.89,10.76 240.78,9.87 240.78,8.34 246.87,2.25 248.14,2.25 248.27,2.12 249.67,2.12 249.79,1.99 254.49,1.99 v255.26,1.23
  Bottom 0.152: v294.5,27.14 293.23,25.87 293.23,21.68 290.69,19.14 290.69,18.38 282.05,9.74 280.15,9.74 B03.V2 278.62,8.98 270.37,0.72 261.35,0.72 260.84,1.23 v255.26,1.23 | v273.42,49.37 275.83,51.78 276.08,51.78 276.46,52.16 276.46,52.41 290.69,66.64 v290.81,66.64 | v113.78,8.6 113.78,8.85 115.43,10.5 121.78,10.5 137.65,26.38 143.5,26.38 v157.47,40.35 | v210.93,3.14 225.54,3.14 232.9,10.5 237.6,10.5 v237.86,10.76
I_MB00  (via drill 0.61)
  Top 0.152: v264.15,92.93 274.69,82.38 274.69,81.88 276.72,79.84 276.72,79.34 278.62,77.43 278.62,77.05 296.78,58.89 297.67,59.78 B02.B1 | v252.84,125.31 251.83,126.33 250.68,126.33 250.3,126.71 250.3,127.34 248.02,129.63 246.75,129.63 A06.B1
  Bottom 0.152: A07.H2 230.49,114.9 230.49,116.04 236.08,121.63 239.25,121.63 243.95,126.33 243.95,127.47 245.73,129.25 A06.B1 | v264.15,92.93 264.65,92.93 267.07,95.34 267.07,95.85 290.94,119.72 290.94,120.99 296.4,126.45 296.4,127.6 | 296.4,127.6 298.05,129.25 A02.B1 | v252.84,125.31 255.64,125.31 258.3,127.98 258.94,127.98 266.18,135.22 269.48,135.22 269.86,135.6 288.4,135.6 296.4,127.6
I_MB01  (via drill 0.61)
  Top 0.152: v237.6,87.08 237.09,87.59 236.08,87.59 234.68,88.99 234.68,89.62 234.43,89.88 234.43,92.42 228.97,97.88 227.7,97.88 A07.N2 | v254.49,105.12 253.6,105.12 v249.29,109.44 | A06.D1 246.37,122.9 248.14,121.12 248.14,119.98 249.41,118.71 249.79,118.71 250.3,118.2 250.3,117.82 v252.46,115.66 252.72,115.28 252.84,115.28 254.49,113.63 254.49,112.36 259.06,107.78 259.06,106.77 263.38,102.45 264.02,102.45 v269.73,96.74 | v299.32,56.48 298.69,56.48 278.24,76.92 278.24,77.3 276.34,79.21 276.34,79.59 v265.54,90.39
  Bottom 0.152: v237.6,87.08 237.6,87.34 245.48,95.21 246.75,95.21 252.59,101.05 252.97,101.05 254.49,102.58 v254.49,105.12 | v249.29,109.44 249.29,112.48 v252.46,115.66 | v299.32,56.48 298.82,55.97 298.82,54.57 B02.D1 | v265.54,90.39 264.27,90.39 263.51,91.15 263.51,91.4 264.15,92.04 264.53,92.04 269.48,96.99 | 269.48,96.99 275.83,103.34 276.08,103.34 277.48,104.74 277.99,104.74 294.88,121.63 296.02,121.63 297.67,123.28 A02.D1 | v269.73,96.74 269.48,96.99
I_MB02  (via drill 0.61)
  Top 0.152: v230.62,85.69 v224.52,91.78 | v251.06,118.33 250.94,118.33 249.54,119.72 A06.E1 | v243.7,110.71 268.34,86.07 | 268.34,86.07 271.64,82.77 271.89,82.77 301.23,53.43 301.23,51.4 B02.E1 | 268.34,86.07 v268.72,86.07
  Bottom 0.152: v230.62,85.69 230.49,85.56 230.49,83.15 A07.U2 | 243.57,110.83 v251.06,118.33 | v224.52,91.78 243.57,110.83 | 243.57,110.83 v243.7,110.71 | v268.72,86.07 301.23,118.58 301.23,119.72 A02.E1
I_MB03  (via drill 0.61)
  Top 0.152: v300.21,42.89 285.86,57.24 285.86,57.49 280.66,62.7 280.66,63.34 279.89,64.1 279.89,66.76 v277.23,69.43 | v277.23,75.15 275.83,76.54 274.05,76.54 273.67,76.92 272.65,76.92 269.35,80.23 269.35,81.37 265.54,85.18 265.54,87.85 250.05,103.34 249.41,103.34 246.62,106.13 245.98,106.13 244.33,107.78 244.33,108.93 v244.21,109.05 243.83,109.31 236.59,116.55 v236.46,116.55 | v216.14,96.23 214.74,97.62 A08.N2 | v277.23,84.92 277.23,82.89 277.35,82.77 277.35,80.23 277.48,80.1 277.48,79.59 279,78.07 279.26,78.07 v279.77,77.56
  Bottom 0.152: v300.21,42.89 299.07,41.74 299.07,41.62 B02.J1 | v277.23,69.43 v277.23,75.15 277.61,75.4 v279.77,77.56 | v244.21,109.05 244.21,109.18 245.48,110.45 A06.J1 | v216.14,96.23 v236.46,116.55 | v277.23,84.92 285.61,93.31 285.61,94.07 303.9,112.36 303.9,113.37 301.99,115.28 301.23,115.28 298.82,112.86 298.82,111.72 A02.J1
I_MB03\  (via drill 0.61)
  Top 0.152: v224.78,102.83 v216.27,111.34 | v235.19,109.94 236.97,109.94 v240.78,106.13 | v300.34,49.11 301.23,48.22 301.23,45.05 B02.H1 | v300.34,51.91 300.34,53.81 275.57,78.57 275.19,78.57 271.64,82.13 | 271.64,82.13 268.46,85.31 268.34,85.31 267.96,85.69 267.96,85.94 250.18,103.72 249.54,103.72 v245.1,108.17 | 271.64,82.13 v271.51,82
  Bottom 0.152: v216.27,111.34 217.16,112.23 217.16,113.37 A08.H2 | v224.78,102.83 228.08,102.83 v235.19,109.94 | v240.78,106.13 242.81,106.13 244.97,108.29 | 244.97,108.29 247.13,110.45 247.13,111.59 248.91,113.37 A06.H1 | v300.34,51.91 v300.34,49.11 | 244.97,108.29 v245.1,108.17 | v271.51,82 290.18,100.67 290.18,101.05 301.23,112.1 301.23,113.37 A02.H1
I_MB04  (via drill 0.61)
  Top 0.152: v261.86,67.4 261.99,67.4 272.65,56.73 273.16,56.73 302.63,27.27 302.63,26.63 303.39,25.87 304.15,26.63 304.15,27.39 301.99,29.55 301.99,30.82 B02.M1 | v266.43,72.73 266.43,75.02 255.76,85.69 255.76,87.34 257.54,89.12 v247.38,99.28 | v206.11,113.12 205.47,113.75 203.95,113.75 A09.H2 | v219.57,126.45 220.2,126.45 225.79,120.87 226.43,120.87 232.65,114.64 234.55,114.64 235.32,113.88 235.32,113.25 246.37,102.2 248.14,102.2 248.52,101.82 A06.M1 | v294.12,97.12 292.59,95.59 v291.58,96.61
  Bottom 0.152: v261.86,67.4 261.86,68.16 v266.43,72.73 266.81,72.99 269.1,75.27 269.61,75.27 272.4,78.07 273.42,78.07 278.5,83.15 278.75,83.15 291.58,95.97 v291.58,96.61 | v247.38,99.28 247.38,99.4 248.78,100.8 A06.M1 | v206.11,113.12 219.44,126.45 v219.57,126.45 | v294.12,97.12 298.05,101.05 300.85,101.05 A02.M1
I_MB04\  (via drill 0.61)
  Top 0.152: v219.95,82 218.17,82 A08.U2 | v261.61,69.94 268.34,63.21 268.34,62.83 288.91,42.25 288.91,42 295.77,35.14 297.67,35.14 B02.L1 | v265.29,74.64 265.29,75.65 255.38,85.56 255.38,86.07 v240.4,101.05 | v271.64,75.53 269.73,75.53 v269.23,76.03
  Bottom 0.152: v219.95,82 221.35,82 239.13,99.78 239.63,99.78 240.65,100.8 | 240.65,100.8 242.43,102.58 243.7,102.58 245.35,104.23 A06.L1 | v261.61,69.94 261.61,70.95 v265.29,74.64 265.67,74.89 266.81,76.03 v269.23,76.03 | 240.65,100.8 v240.4,101.05 | v271.64,75.53 292.85,96.74 292.85,96.99 292.97,97.12 292.97,97.62 296.91,101.56 296.91,102.07 298.05,103.21 298.05,103.85 A02.L1
I_MB05  (via drill 0.61)
  Top 0.152: v205.47,83.65 205.6,83.65 v210.42,78.83 | v233.41,101.82 v247.51,87.72 247.89,87.46 258.05,77.3 258.3,77.3 269.23,66.38 269.61,66.38 v275.19,60.8 | v272.78,55.97 275.45,53.3 276.08,53.3 297.29,32.09 297.29,28.03 301.23,24.09 301.23,19.65 B02.S1
  Bottom 0.152: v205.47,83.65 204.58,82.77 203.95,82.77 A09.U2 | v210.42,78.83 224.14,92.54 224.78,92.54 231.38,99.15 231.38,99.78 v233.41,101.82 | v247.51,87.72 247.89,87.72 248.52,88.35 A06.S1 | v272.78,55.97 272.78,58.38 v275.19,60.8 299.58,85.18 299.58,86.32 301.23,87.97 A02.S1
I_MB05\  (via drill 0.61)
  Top 0.152: v260.34,70.07 v303.39,27.01 | v261.99,76.42 261.99,78.32 v247.64,92.67 247.25,92.93 247.13,93.05 v244.46,93.05 | v207.5,93.43 204.07,96.86 201.79,96.86 200.77,97.88 A09.N2 | v204.84,88.48 204.96,88.48 210.68,82.77 210.68,81.24 v214.87,77.05 | v219.06,80.35 221.09,80.35 221.73,79.72 221.73,77.3 227.19,71.84 227.95,71.84 228.59,72.48 v228.59,75.02 | v292.59,83.4 290.18,83.4 v282.31,91.27
  Bottom 0.152: v303.39,27.01 302.25,25.87 302.25,25.74 B02.P1 | v260.34,70.07 260.34,74.77 260.46,74.89 | v261.99,76.42 260.46,74.89 | v247.64,92.67 247.64,93.05 248.91,94.32 A06.P1 | v207.5,93.43 207.5,91.15 v204.84,88.48 | v214.87,77.05 215.76,77.05 v219.06,80.35 | v228.59,75.02 228.59,77.18 229.73,78.32 229.98,78.32 238.36,86.7 238.36,86.96 v244.46,93.05 | v292.59,83.4 298.44,89.24 298.44,90.13 301.23,92.93 301.23,94.32 A02.P1 | v282.31,91.27 281.93,91.27 270.5,79.84 269.35,79.84 264.4,74.89 260.46,74.89
I_MB06  (via drill 0.61)
  Top 0.152: v203.19,86.07 189.34,99.91 188.07,98.64 A10.N2 | v216.14,97.88 216.9,97.88 v217.92,96.86 | v297.04,52.41 297.04,52.54 287,62.57 287,63.08 273.54,76.54 272.53,76.54 254.49,94.58 253.48,94.58 v234.55,113.5 | v262.49,137.76 264.65,135.6 270.62,135.6 271.89,134.33 276.59,134.33 290.05,120.87 294.5,120.87 A02.E2
  Bottom 0.152: v203.19,86.07 204.33,86.07 v216.14,97.88 | v217.92,96.86 217.92,97.12 234.43,113.63 | 234.43,113.63 236.08,115.28 236.33,115.28 237.22,116.17 237.22,116.42 239.25,118.45 240.52,118.45 242.17,120.1 A06.E2 243.19,121.25 244.97,123.02 244.97,124.17 258.56,137.76 v262.49,137.76 | v297.04,52.41 295.9,51.27 295.9,51.14 B02.E2 | 234.43,113.63 v234.55,113.5
I_MB06\  (via drill 0.61)
  Top 0.152: v195.44,118.71 195.95,118.71 v212.58,102.07 | v296.78,60.03 296.15,60.03 279,77.18 279,77.56 277.1,79.46 277.1,79.97 275.07,82 275.07,84.29 274.43,84.92 274.43,86.58 273.8,87.21 273.8,87.85 265.92,95.72 | 265.92,95.72 241.79,119.85 241.79,121.12 240.02,122.9 A06.D2 | 265.92,95.72 v266.3,95.72
  Bottom 0.152: v195.44,118.71 195.18,118.45 193.28,118.45 191.63,116.8 191.63,115.79 190.87,115.02 190.87,114.9 A10.H2 | v212.58,102.07 215.25,102.07 221.85,108.67 222.49,108.67 235.82,122.01 237.73,122.01 239,123.28 A06.D2 | v296.78,60.03 292.47,55.72 292.47,54.57 B02.D2 | v266.3,95.72 266.43,95.72 290.56,119.85 290.56,121.12 291.7,122.26 291.7,122.9 A02.D2
I_MB07  (via drill 0.61)
  Top 0.152: v294.37,40.35 294.88,39.84 294.88,38.7 B02.K2 | v299.58,45.94 299.58,48.73 296.28,52.03 296.28,52.79 283.19,65.88 282.56,65.88 v279.51,68.92 | v303.51,92.93 303.51,95.59 v293.48,105.63 | v228.2,94.32 228.08,94.32 226.55,95.85 225.92,95.85 212.33,109.44 211.57,109.44 203.44,117.56 201.28,117.56 200.39,118.45 197.34,118.45 196.07,119.72 193.91,119.72 v187.31,126.33 | v275.45,75.78 v280.91,70.32 | v273.04,75.78 272.53,75.78 263.13,85.18 262.75,85.18 v260.21,87.72 | v260.21,91.02 260.21,92.67 249.92,102.96 249.29,102.96 246.49,105.75 245.22,105.75 243.57,107.4 A06.K2
  Bottom 0.152: v294.37,40.35 294.37,40.73 v299.58,45.94 | v279.51,68.92 279.51,69.43 280.66,70.57 | 280.66,70.57 289.29,79.21 289.8,79.21 v303.51,92.93 | v293.48,105.63 294.88,107.02 A02.K2 | v228.2,94.32 229.09,95.21 229.09,95.59 240.9,107.4 242.17,107.4 A06.K2 | v187.31,126.33 187.31,125.69 179.44,117.82 179.44,116.17 178.17,114.9 A11.H2 | v280.91,70.32 280.66,70.57 | v273.04,75.78 v275.45,75.78 | v260.21,91.02 v260.21,87.72
I_MB07\  (via drill 0.61)
  Top 0.152: v200.77,76.67 199.38,78.07 193.28,78.07 190.87,80.48 190.87,81.62 A10.U2 | v293.48,45.68 294.5,44.67 B02.H2 | v289.67,42.38 289.29,42.38 268.72,62.95 268.72,63.97 258.05,74.64 257.8,74.64 257.41,75.02 257.16,75.02 257.03,75.15 256.78,75.15 256.65,75.27 256.02,75.27 255.89,75.4 254.62,75.4 253.99,76.03 253.35,76.03 252.59,76.8 | 252.59,76.8 251.7,77.69 249.92,77.69 v227.57,100.04 | 252.59,76.8 v254.24,78.45
  Bottom 0.152: v200.77,76.67 211.06,86.96 212.33,86.96 219.7,94.32 221.47,94.32 223.38,96.23 223.76,96.23 224.27,96.74 224.27,97.24 227.32,100.29 | 227.32,100.29 239.13,112.1 240.52,112.1 242.17,113.75 A06.H2 | v293.48,45.68 292.97,45.68 v289.67,42.38 | 227.32,100.29 v227.57,100.04 | v254.24,78.45 265.42,89.62 265.92,89.62 291.58,115.28 291.58,115.66 292.09,116.17 292.59,116.17 292.72,116.29 294.5,114.52 A02.H2
I_MB08  (via drill 0.61)
  Top 0.152: v249.54,71.59 257.16,63.97 257.67,63.97 266.69,54.95 267.07,54.95 272.65,49.37 272.65,48.98 273.04,48.6 273.42,48.6 293.74,28.28 293.74,26.76 294.62,25.87 294.62,25.74 B02.P2 | v251.19,73.24 251.19,75.91 248.02,79.08 247.76,79.08 236.97,89.88 236.59,89.88 v236.08,90.39 | v213.47,112.86 215.89,112.86 v220.08,108.67 232.4,96.35 232.4,96.23 237.35,91.27 v237.48,91.27 | v300.09,100.16 300.09,100.8 296.02,104.86 296.02,105.5 294.12,107.4 294.12,109.94 293.86,110.2 293.86,111.21 v270.24,134.84 | v250.43,135.47 v258.68,127.22
  Bottom 0.152: v251.19,73.24 v249.54,71.59 | v236.08,90.39 236.59,90.39 v237.48,91.27 239.25,93.05 240.52,93.05 242.17,94.7 A06.P2 | v213.47,112.86 210.04,109.44 209.15,109.44 177.79,78.07 177.79,77.69 177.02,76.92 176.26,77.69 176.26,78.45 177.4,79.59 177.4,81.62 A11.U2 | v300.09,100.16 299.58,99.66 299.58,97.88 297.17,95.47 296.02,95.47 A02.P2 | v270.24,134.84 266.3,134.84 v258.68,127.22 | v250.43,135.47 247.64,135.47 233.41,121.25 232.65,121.25 v220.08,108.67
I_MB08\  (via drill 0.61)
  Top 0.152: v209.15,71.46 209.15,71.59 201.53,79.21 201.53,79.72 193.66,87.59 190.1,87.59 187.95,89.75 187.44,89.75 179.31,97.88 175.37,97.88 A11.N2 | v275.7,52.54 275.83,52.54 279.38,48.98 279.89,48.98 294.88,34 294.88,32.35 B02.M2 | v307.96,84.92 v293.48,99.4 293.1,99.66 291.32,101.43 291.2,101.43 v269.1,123.53 | v244.71,100.8 244.46,101.05 243.57,101.05 A06.M2
  Bottom 0.152: v209.15,71.46 210.3,71.46 213.35,74.51 214.36,74.51 239.25,99.4 240.52,99.4 242.17,101.05 A06.M2 | v275.7,52.54 290.05,66.89 290.05,67.02 v307.96,84.92 | v293.48,99.4 293.48,99.53 294.75,100.8 A02.M2 | v244.71,100.8 245.35,100.8 261.22,116.67 262.24,116.67 v269.1,123.53
I_MB09  (via drill 0.61)
  Top 0.152: 271.89,53.43 273.16,52.16 273.42,52.16 275.07,50.51 275.07,50.25 276.21,49.11 276.46,49.11 276.97,48.6 279.77,48.6 294.12,34.25 294.12,31.2 296.91,28.41 296.91,27.9 297.29,27.52 297.29,21.68 300.09,18.89 299.32,18.12 298.56,18.12 298.18,18.5 296.02,18.5 B02.S2 | 271.89,53.43 271.89,56.48 266.56,61.81 v266.43,61.81 | v190.49,136.11 197.09,136.11 235.44,97.75 235.57,97.75 240.78,92.54 240.78,91.27 242.56,89.5 A06.S2 | v271,53.43 271.89,53.43 | v265.16,48.73 265.16,49.24 260.72,53.68 260.46,53.68 252.84,61.3 249.67,61.3 248.14,62.83 248.14,63.59 v241.92,69.81 | v235.19,67.14 235.06,67.14 v229.35,72.86
  Bottom 0.152: v266.43,61.81 266.81,61.81 269.48,64.48 273.67,64.48 274.56,65.37 274.81,65.37 283.7,74.26 283.7,75.65 293.23,85.18 293.23,86.32 294.88,87.97 A02.S2 | v190.49,136.11 168.9,114.52 165.85,114.52 A12.H2 | v271,53.43 269.86,53.43 v265.16,48.73 | v241.92,69.81 237.86,69.81 v235.19,67.14 | v229.35,72.86 229.35,73.62 240.78,85.05 240.78,85.56 243.19,87.97 A06.S2
I_MB10  (via drill 0.61)
  Top 0.152: v241.41,87.34 241.67,87.34 v249.16,79.84 | v253.48,83.53 253.48,82.89 258.3,78.07 259.19,78.07 261.61,75.65 261.86,75.65 265.16,72.35 265.54,72.35 v277.73,60.16 278.12,59.91 279.89,58.13 282.94,58.13 288.02,53.05 288.53,53.05 291.58,50 292.09,50 299.07,43.02 299.07,42.38 306.82,34.63 v305.04,32.86 | v293.86,78.32 293.86,83.4 292.47,84.8 A02.T2 | v169.91,108.93 175.12,108.93 177.4,106.64 177.66,106.64 178.42,105.88 178.42,105.37 179.06,104.74 179.06,104.48 206.36,77.18 206.87,77.18 v207.25,76.8 | v226.17,95.08 226.3,95.08 v237.6,83.78
  Bottom 0.152: v241.41,87.34 240.27,86.19 240.27,86.07 A06.T2 239,85.18 v237.6,83.78 | v249.16,79.84 249.79,79.84 v253.48,83.53 | v277.73,60.16 277.73,60.8 278.12,61.18 278.12,63.21 289.67,74.77 290.31,74.77 v293.86,78.32 | v305.04,32.86 292.47,20.28 292.47,16.47 B02.T2 | v169.91,108.93 169.02,108.04 169.02,107.91 163.69,102.58 163.69,102.32 162.29,100.93 162.29,99.02 A12.N2 | v207.25,76.8 210.04,79.59 210.68,79.59 v226.17,95.08
I_MB11  (via drill 0.61)
  Top 0.152: B02.V2 292.85,8.98 297.29,8.98 298.05,8.22 305.67,8.22 317.74,20.28 313.17,24.85 313.17,28.79 299.45,42.51 299.45,43.14 v277.86,64.73 277.48,64.99 v275.32,67.14 | v241.54,77.3 240.27,78.57 240.14,78.57 A06.V2 | v269.61,67.14 259.06,77.69 258.18,77.69 250.43,85.43 v250.43,86.07 250.05,86.32 210.68,125.69 209.15,125.69 201.92,132.93 v201.41,132.93 | v159.37,89.12 160.77,87.72 160.77,85.18 163.18,82.77 164.32,82.77 A12.U2
  Bottom 0.152: v277.86,64.73 278.62,64.73 292.34,78.45 A02.V2 | v241.54,77.3 241.67,77.3 v250.43,86.07 | v275.32,67.14 v269.61,67.14 | v159.37,89.12 159.37,90.89 v201.41,132.93
I_MBINCR  (via drill 0.61)
  Top 0.152: v82.03,56.98 82.66,56.98 98.41,41.24 99.05,41.24 v134.86,5.42 | v181.47,50.13 181.47,49.87 188.71,42.63 193.79,42.63 v200.01,36.41 205.47,30.95 206.11,30.95 v210.42,26.63 | v218.04,33.74 219.19,33.74 229.73,23.2 229.73,22.95 230.11,22.57 231.25,22.57 232.9,20.92 236.08,20.92 243.95,13.04 243.95,12.41 244.84,11.52 245.48,11.52 247.13,9.87 247.13,9.23 v252.46,3.9 | v262.62,84.42 258.18,84.42 v256.53,86.07 | v242.17,72.99 240.4,72.99 v238.87,74.51
  Bottom 0.152: v82.03,56.98 80,54.95 75.8,54.95 75.04,54.19 70.6,54.19 B19.D2 | v134.86,5.42 135.75,5.42 156.7,26.38 157.72,26.38 v181.47,50.13 | v210.42,26.63 210.93,26.63 v218.04,33.74 | v252.46,3.9 255,3.9 266.18,15.08 B04.T2 | v262.62,84.42 263.38,85.18 265.92,85.18 A04.T2 | v256.53,86.07 256.53,85.43 253.86,82.77 253.22,82.77 247.38,76.92 247.38,76.8 244.46,73.88 243.06,73.88 v242.17,72.99 | v238.87,74.51 238.87,74.26 226.05,61.43 225.79,61.43 223.89,59.52 223.63,59.52 212.96,48.86 212.46,48.86 v200.01,36.41
I_RUN  (via drill 0.61)
  Top 0.152: v241.29,24.09 235.95,29.43 237.6,31.08 237.6,32.09 232.65,37.05 231.51,37.05 231,37.55 230.87,37.55 B07.K2 | v257.03,35.14 257.03,34.51 266.69,24.85 268.72,24.85 269.48,24.09 269.73,24.09 271.13,22.7 272.15,22.7 274.31,24.85 282.05,17.11 282.81,17.11 285.35,14.57 | 285.35,14.57 286.12,14.57 287.26,15.71 286.12,16.85 284.97,16.85 283.32,18.5 B03.S2 | v177.66,74.38 181.98,74.38 184.64,71.72 185.79,71.72 194.8,62.7 195.95,62.7 196.45,62.19 201.66,62.19 212.46,51.4 212.71,51.4 v227.82,36.28 | v302.88,68.16 292.97,78.07 291.7,78.07 282.94,86.83 282.94,87.97 A03.S2 | v302.88,58 306.94,53.94 306.94,53.18 315.45,44.67 315.45,39.84 316.72,38.57 316.72,21.81 318.12,20.41 318.12,20.16 298.94,0.98 285.35,14.57
  Bottom 0.152: v241.29,24.09 243.83,24.09 247.25,27.52 249.41,27.52 v257.03,35.14 | v177.66,74.38 167.88,64.6 166.86,64.6 166.74,64.48 164.7,64.48 158.35,58.13 156.7,58.13 144.89,46.32 144,46.32 141.59,43.9 138.8,43.9 B14.H2 | v227.82,36.28 228.2,36.28 229.47,37.55 B07.K2 | v302.88,58 v302.88,68.16
I_SKIP  (via drill 0.61)
  Top 0.152: v141.46,4.66 134.48,4.66 130.92,8.22 128.13,8.22 110.09,26.25 108.06,26.25 82.92,51.4 82.92,53.05 B18.D2 | v160.64,18.12 162.55,18.12 167.5,13.17 169.28,13.17 174.23,8.22 180.07,8.22 180.45,7.84 182.1,7.84 v185.91,4.03 | v215.5,24.85 215.5,24.35 221.22,18.63 221.47,18.63 229.47,10.63 230.49,10.63 232.9,8.22 238.11,8.22 v239.25,7.07 | v251.19,14.57 252.97,14.57 253.86,13.68 253.86,12.66 258.3,8.22 260.84,8.22 v266.3,2.76 | B03.K2 281.8,38.32 281.04,39.08 280.15,38.19 280.15,37.43 290.56,27.01 v290.56,25.36 290.94,25.11 297.17,18.89 v298.94,18.89 | v290.94,100.67 290.05,101.56 290.05,101.82 284.47,107.4 283.32,107.4 A03.K2 | v292.97,102.7 292.97,102.2 304.4,90.77 307.45,90.77 312.28,85.94 312.28,83.91 313.04,83.15 313.04,82 v314.82,80.23 | v312.66,71.34 312.66,66.51 315.45,63.72 315.45,60.41 317.23,58.64 317.23,51.52 v317.87,50.89
  Bottom 0.152: v141.46,4.66 147.18,4.66 v160.64,18.12 | v185.91,4.03 193.15,4.03 209.15,20.03 210.68,20.03 v215.5,24.85 | v239.25,7.07 245.35,7.07 250.3,12.03 250.3,13.68 v251.19,14.57 | v266.3,2.76 268.84,2.76 275.45,9.36 275.45,9.74 287.26,21.55 287.26,22.06 v290.56,25.36 | v292.97,102.7 v290.94,100.67 | v314.82,80.23 314.82,73.49 v312.66,71.34 | v317.87,50.89 317.87,44.92 312.15,39.2 312.15,37.3 309.99,35.14 309.99,29.93 v298.94,18.89
I_TS1  (via drill 0.61)
  Top 0.152: v286.24,7.2 278.37,7.2 275.07,10.5 274.43,10.5 273.16,11.77 272.91,11.77 265.67,19.01 265.29,19.01 261.86,22.44 259.95,22.44 256.02,26.38 255.64,26.38 253.6,28.41 253.6,28.79 249.67,32.73 248.78,32.73 246.75,34.76 B06.L1 | v293.23,71.34 293.23,70.83 v296.78,67.27 | v275.57,41.11 266.05,50.63 v265.92,50.63
  Bottom 0.152: v286.24,7.2 287.77,5.68 291.07,5.68 291.32,5.93 292.47,5.93 292.85,6.31 294.37,6.31 296.28,8.22 298.82,8.22 304.4,13.81 304.4,14.95 B01.T2 | v293.23,71.34 295.01,73.11 295.01,74.26 304.4,83.65 304.4,84.8 A01.T2 | v296.78,67.27 296.78,63.08 289.8,56.1 289.8,55.33 v275.57,41.11 | v265.92,50.63 251.32,36.03 247.64,36.03 246.75,35.14 B06.L1
I_TS3  (via drill 0.61)
  Top 0.152: v292.09,6.69 284.21,14.57 272.65,14.57 265.42,21.81 265.42,22.44 v264.02,23.84 263,24.85 263,25.74 253.6,35.14 253.6,36.79 250.18,40.22 249.67,40.22 249.16,40.73 246.75,40.73 B06.J1 | v312.28,82.77 308.34,86.7 308.34,87.97 A01.S2
  Bottom 0.152: v292.09,6.69 294.24,6.69 304.4,16.85 305.55,16.85 307.2,18.5 B01.S2 | v312.28,82.77 311.64,82.77 306.56,77.69 306.56,77.05 301.36,71.84 301.36,67.14 300.09,65.88 300.09,65.11 300.98,64.22 300.47,63.72 300.47,60.29 296.28,56.1 296.28,55.84 289.93,49.49 289.93,49.11 270.88,30.06 270.24,30.06 v264.02,23.84
I_TT_INST  (via drill 0.61)
  Top 0.152: v158.99,7.96 152.39,14.57 147.18,14.57 145.02,16.73 144.51,16.73 135.24,26 135.24,27.65 B14.N2 | v205.6,51.02 206.61,51.02 224.39,33.24 225.79,33.24 v228.46,30.57 | v245.48,45.55 v250.05,40.98 274.94,16.09 278.62,16.09 B03.T2 | v278.37,83.91 278.37,81.75 v285.74,74.38
  Bottom 0.152: v158.99,7.96 158.99,8.47 174.1,23.58 174.61,23.58 199.63,48.6 203.19,48.6 v205.6,51.02 | v228.46,30.57 228.84,30.57 229.47,31.2 B07.M2 230.87,31.97 232.52,33.62 233.79,33.62 245.48,45.3 v245.48,45.55 | v278.37,83.91 279,84.54 279,84.8 A03.T2 | v285.74,74.38 285.74,74 279.89,68.16 278.12,68.16 274.94,64.99 274.69,64.99 272.02,62.32 271.38,62.32 v250.05,40.98
I_WCOV  (via drill 0.61)
  Top 0.152: v228.84,13.68 227.44,15.08 B07.T2 | v247.76,32.6 247.76,31.46 251.95,27.27 252.46,27.27 254.87,24.85 B05.P2 | v151.62,7.46 141.72,17.36 137.53,17.36 134.73,20.16 134.22,20.16 129.27,25.11 128.26,25.11 125.33,28.03 122.92,28.03 B15.N2 | v171.94,23.2 176.77,23.2 188.07,11.9 188.58,11.9 189.85,10.63 190.36,10.63 193.15,7.84 198.36,7.84 v198.74,7.46 | v211.82,7.58 212.33,7.58 v214.87,5.04 | v257.41,94.2 256.91,94.7 256.27,94.7 A05.P2 | v263.26,99.66 263.51,99.66 267.07,96.1 267.07,95.59 273.16,89.5 v273.29,89.5 | v264.02,75.65 264.02,74.64 v265.29,73.37 | v236.59,42 236.59,41.36 236.71,41.24 236.71,40.73 237.6,39.84 238.24,39.84 v246.62,31.46
  Bottom 0.152: v247.76,32.6 v246.62,31.46 v228.84,13.68 | v151.62,7.46 156.32,7.46 171.94,23.08 v171.94,23.2 | v198.74,7.46 211.69,7.46 v211.82,7.58 | v214.87,5.04 214.87,5.17 223.38,13.68 224.65,13.68 226.3,15.33 B07.T2 | v257.41,94.2 257.8,94.2 v263.26,99.66 | v273.29,89.5 273.29,87.34 265.54,79.59 265.54,77.18 v264.02,75.65 | v265.29,73.37 265.29,72.48 260.84,68.03 260.84,65.62 245.6,50.38 244.97,50.38 v236.59,42
N$1  (via drill 0.61)
  Top 0.152: v219.7,45.68 v222.24,43.14 | v243.57,61.56 244.33,61.56 245.35,60.54 B06.B1
  Bottom 0.152: v219.7,45.68 218.68,44.67 218.17,44.67 B08.H2 | v222.24,43.14 225.03,43.14 241.54,59.65 241.67,59.65 v243.57,61.56
N$2  (via drill 0.61)
  Top 0.152: v219.7,24.73 216.39,28.03 215,28.03 B08.N2
  Bottom 0.152: v219.7,24.73 220.97,24.73 243.7,47.46 243.95,47.46 246.37,49.87 248.14,49.87 248.52,50.25 B06.E1
N$3  (via drill 0.61)
  Top 0.152: v247.25,46.19 248.65,44.79 B06.H1
  Bottom 0.152: v247.25,46.19 215.76,14.69 217.16,13.3 B08.U2
N$4  (via drill 0.61)
  Top 0.152: v226.81,56.35 v246.62,36.54 | v210.17,39.71 209.28,39.71 206.74,42.25 205.6,42.25 203.95,43.9 B09.H2
  Bottom 0.152: v246.62,36.54 247.64,37.55 248.52,37.55 B06.K1 | v226.81,56.35 226.17,56.35 216.27,46.44 216.27,45.81 v210.17,39.71
N$5  (via drill 0.61)
  Top 0.152: v208.01,32.73 212.2,32.73 218.81,26.12 219.44,26.12 226.17,19.39 226.17,19.01 230.24,14.95 230.24,14.69 v230.62,14.31
  Bottom 0.152: v208.01,32.73 204.07,28.79 200.77,28.79 B09.N2 | v230.62,14.31 230.62,14.57 245.6,29.55 246.87,29.55 248.52,31.2 B06.M1
N$6  (via drill 0.61)
  Top 0.152: v206.61,13.93 213.35,13.93 v221.22,6.06 | v247.64,26.76 248.65,25.74 B06.P1
  Bottom 0.152: v206.61,13.93 205.6,12.92 203.95,12.92 B09.U2 | v221.22,6.06 225.28,6.06 227.19,7.96 228.84,7.96 v247.64,26.76
O_3CYCLE  (via drill 0.61)
  Top 0.152: v76.95,49.49 62.85,63.59 62.85,63.97 48.12,78.7 48.12,81.88 43.29,86.7 40.12,86.7 32.24,94.58 32.24,96.35 37.7,101.82 35.42,104.1 35.42,105.24 33.64,107.02 A22.K2
  Bottom 0.152: v76.95,49.49 76.06,48.6 75.8,48.6 73.39,46.19 73.39,45.05 B19.H2
O_AC00  (via drill 0.61)
  Top 0.152: v72.12,97.88 92.82,77.18 92.82,71.08 108.44,55.46 108.44,53.3 110.73,51.02 112,51.02 B16.E2
  Bottom 0.152: v72.12,97.88 72.12,98.51 74.53,100.93 74.53,101.43 93.2,120.1 93.2,121.25 94.85,122.9 A17.D2
O_AC01  (via drill 0.61)
  Top 0.152: v108.06,49.62 108.44,49.24 108.44,46.95 110.73,44.67 112,44.67 B16.H2 | v130.67,76.16 130.03,76.16 108.44,97.75 108.44,102.58 97.27,113.75 97.27,118.96 98.03,119.72 A17.E2
  Bottom 0.152: v108.06,49.62 108.06,50.76 120.13,62.83 120.13,65.62 v130.67,76.16
O_AC02  (via drill 0.61)
  Top 0.152: v80.5,78.07 96,62.57 96,61.18 103.62,53.56 103.62,50.25 112.38,41.49 112.38,38.7 B16.K2
  Bottom 0.152: v80.5,78.07 80.5,79.21 97.14,95.85 97.14,98.64 99.55,101.05 99.55,112.61 98.79,113.37 A17.H2
O_AC03  (via drill 0.61)
  Top 0.152: v115.05,37.55 115.05,39.84 108.06,46.83 108.06,48.48 107.3,49.24 107.3,50.38 96.38,61.3 96.38,63.34 v77.71,82
  Bottom 0.152: v115.05,37.55 113.02,35.52 113.02,32.35 B16.M2 | v77.71,82 77.71,85.31 82.03,89.62 82.03,89.88 96.38,104.23 96.38,105.37 98.03,107.02 A17.K2
O_AC04  (via drill 0.61)
  Top 0.152: v84.57,52.67 84.57,50.25 108.19,26.63 110.22,26.63 111.24,25.62 112,25.62 B16.P2 | v89.01,61.81 89.01,62.57 87.87,63.72 87.87,64.6 80.88,71.59 80.88,73.88 79.61,75.15 79.61,78.83 v78.72,79.72
  Bottom 0.152: v84.57,52.67 84.57,57.37 v89.01,61.81 | v78.72,79.72 79.23,79.72 91.3,91.78 91.3,92.8 96.38,97.88 96.38,99.02 98.03,100.67 A17.M2
O_AC05  (via drill 0.61)
  Top 0.152: v147.43,45.68 146.8,45.68 140.83,51.65 140.57,51.65 129.4,62.83 129.4,64.6 122.29,71.72 121.78,71.72 108.44,85.05 108.44,86.58 101.97,93.05 100.82,93.05 99.17,94.7 A17.P2
  Bottom 0.152: v147.43,45.68 125.33,23.58 121.65,23.58 117.33,19.27 113.4,19.27 B16.S2
O_AC06  (via drill 0.61)
  Top 0.152: v99.55,52.79 99.55,53.56 88.63,64.48 88.63,65.49 v82.03,72.1
  Bottom 0.152: v99.55,52.79 98.79,52.03 98.79,51.4 B17.E2 | v82.03,72.1 82.03,73.88 94.85,86.7 96,86.7 97.65,88.35 A17.S2
O_AC07  (via drill 0.61)
  Top 0.152: v116.19,61.81 116.19,63.08 97.27,82 97.27,83.15 95.62,84.8 A17.T2
  Bottom 0.152: v116.19,61.81 115.68,61.3 115.43,61.3 105.9,51.78 105.9,50.25 100.31,44.67 99.17,44.67 B17.H2
O_AC08  (via drill 0.61)
  Top 0.152: v103.49,41.49 103.49,42.25 v82.92,62.83
  Bottom 0.152: v103.49,41.49 100.31,38.32 99.17,38.32 B17.K2 | v82.92,62.83 82.92,66.51 94.85,78.45 A17.V2
O_AC09  (via drill 0.61)
  Top 0.152: v59.42,104.86 67.93,96.35 67.93,91.27 68.44,90.77 68.44,63.97 98.03,34.38 98.03,32.35 B17.M2
  Bottom 0.152: v59.42,104.86 59.42,107.15 59.04,107.53 59.04,108.55 69.33,118.83 76.19,118.83 78.98,121.63 80.12,121.63 81.77,123.28 A18.D2
O_AC10  (via drill 0.61)
  Top 0.152: v106.41,31.71 106.41,31.97 84.57,53.81 84.06,53.81 81.27,56.6 81.27,62.7 80.5,63.46 80.5,64.73 78.09,67.14 78.09,75.15 71.49,81.75 71.49,87.46 70.85,88.1 70.85,88.86 68.31,91.4 68.31,97.12 v67.17,98.26
  Bottom 0.152: v106.41,31.71 100.31,25.62 99.17,25.62 B17.P2 | v67.17,98.26 67.17,99.4 69.96,102.2 69.96,103.21 83.68,116.93 83.68,118.07 85.33,119.72 A18.E2
O_AC11  (via drill 0.61)
  Top 0.152: v50.78,68.92 98.03,21.68 98.03,19.65 B17.S2 | v85.96,109.44 85.96,113.37 A18.H2
  Bottom 0.152: v50.78,68.92 50.78,70.83 71.36,91.4 71.36,91.91 74.15,94.7 74.15,97.75 85.84,109.44 v85.96,109.44
O_ACCEPT  (via drill 0.61)
  Top 0.152: v71.61,99.15 73.77,99.15 94.85,78.07 97.39,78.07 101.97,73.49 101.97,73.24 102.22,72.99 102.22,72.61 102.35,72.48 102.35,72.22 102.47,72.1 102.47,70.95 105.52,67.91 106.03,67.91 109.71,64.22 110.22,64.22 118.6,55.84 119.87,55.84 121.52,54.19 B15.D2
  Bottom 0.152: v71.61,99.15 70.98,98.51 70.98,97.88 62.21,89.12 61.07,89.12 A20.S2
O_ACCLR  (via drill 0.61)
  Top 0.152: v111.49,64.99 111.49,67.27 96.89,81.88 96.89,82.38 87.74,91.53 87.74,92.67 86.09,94.32 A18.P2
  Bottom 0.152: v111.49,64.99 104.63,58.13 104.38,58.13 99.81,53.56 99.17,53.56 86.09,40.48 86.09,38.7 B18.K2
O_ADD00  (via drill 0.61)
  Top 0.152: v96.38,89.24 96.38,94.58 95.23,95.72 95.23,96.23 74.66,116.8 74.66,117.31 71.87,120.1 71.87,121.25 70.22,122.9 A19.D2
  Bottom 0.152: v96.38,89.24 60.69,53.56 60.69,51.4 B20.E2
O_ADD01  (via drill 0.61)
  Top 0.152: v99.55,85.43 99.55,91.91 95.62,95.85 95.62,96.35 75.04,116.93 75.04,118.07 73.39,119.72 A19.E2
  Bottom 0.152: v99.55,85.43 60.69,46.57 60.69,45.05 B20.H2
O_ADD02  (via drill 0.61)
  Top 0.152: v30.85,68.92 59.93,39.84 59.93,38.7 B20.K2
  Bottom 0.152: v30.85,68.92 30.85,70.07 57.52,96.74 57.64,96.74 61.83,100.93 61.83,101.43 70.98,110.58 70.98,111.72 72.63,113.37 A19.H2
O_ADD03  (via drill 0.61)
  Top 0.152: v31.61,67.02 55.99,42.63 55.99,40.73 59.93,36.79 59.93,32.35 B20.M2
  Bottom 0.152: v31.61,67.02 31.61,70.32 44.05,82.77 44.82,82.77 51.93,89.88 53.58,89.88 69.45,105.75 70.6,105.75 72.25,107.4 A19.K2
O_ADD04  (via drill 0.61)
  Top 0.152: v29.07,58.13 29.07,53.3 30.08,52.29 30.08,51.78 56.25,25.62 59.55,25.62 B20.P2
  Bottom 0.152: v29.07,58.13 29.07,60.67 51.93,83.53 53.58,83.53 69.45,99.4 70.6,99.4 72.25,101.05 A19.M2
O_ADD05  (via drill 0.61)
  Top 0.152: v32.24,48.48 59.93,20.79 59.93,19.65 B20.S2
  Bottom 0.152: v32.24,48.48 32.24,51.78 49.64,69.18 49.64,69.43 49.9,69.68 49.9,70.07 50.02,70.19 50.02,70.57 70.98,91.53 70.98,92.67 72.63,94.32 A19.P2
O_ADD06
  Bottom 0.152: B21.E2 45.32,51.02 43.93,51.02 40.62,54.32 68.18,81.88 68.18,82.38 70.98,85.18 70.98,86.32 72.63,87.97 A19.S2
O_ADD07
  Bottom 0.152: B21.H2 45.7,45.05 45.7,48.73 40.12,54.32 67.8,82 67.8,83.15 69.45,84.8 A19.T2
O_ADD08  (via drill 0.61)
  Top 0.152: v76.82,65.62 76.82,71.84 70.22,78.45 A19.V2
  Bottom 0.152: v76.82,65.62 49.52,38.32 46.72,38.32 B21.K2
O_ADD09  (via drill 0.61)
  Top 0.152: v16.37,81.75 16.37,59.65 30.59,45.43 33.77,45.43 45.7,33.49 45.7,32.35 B21.M2
  Bottom 0.152: v16.37,81.75 57.52,122.9 A20.D2
O_ADD10  (via drill 0.61)
  Top 0.152: v17,51.78 43.16,25.62 45.32,25.62 B21.P2
  Bottom 0.152: v17,51.78 18.53,53.3 18.53,63.97 58.66,104.1 58.66,110.96 61.45,113.75 61.45,118.96 60.69,119.72 A20.E2
O_ADD11  (via drill 0.61)
  Top 0.152: v16.24,50.76 45.7,21.3 45.7,19.65 B21.S2
  Bottom 0.152: v16.24,50.76 16.24,62.19 58.28,104.23 58.28,111.72 59.93,113.37 A20.H2
O_BAC00  (via drill 0.61)
  Top 0.152: v143.24,116.8 143.24,113.75 147.18,109.82 150.35,109.82 158.23,101.94 158.23,99.91 171.18,86.96 171.69,86.96 v195.18,63.46
  Bottom 0.152: v143.24,116.8 147.31,120.87 147.31,122.9 A13.D2 | v195.18,63.46 195.18,63.21 189.34,57.37 189.34,56.22 187.69,54.57 B10.D2
O_BAC01  (via drill 0.61)
  Top 0.152: v172.96,92.42 172.58,92.8 172.58,95.47 166.23,101.82 166.23,108.17 161.66,112.74 159.88,112.74 159.62,112.99 156.7,112.99 151.12,118.58 151.12,119.72 A13.E2 | v156.2,75.02 156.2,74.26 156.83,73.62 156.83,73.11 188.45,41.49 188.45,40.35 190.1,38.7 B10.K2
  Bottom 0.152: v172.96,92.42 172.58,92.42 171.31,91.15 171.31,90.13 v156.2,75.02
O_BAC02  (via drill 0.61)
  Top 0.152: v163.82,104.23 154.29,113.75 151.5,113.75 A13.H2 | v136.13,67.27 136.13,66.89 145.53,57.49 145.53,54.32 147.18,52.67 158.23,52.67 162.93,47.97 163.56,47.97 169.78,41.74 169.78,41.11 188.45,22.44 188.45,21.3 190.1,19.65 B10.S2
  Bottom 0.152: v163.82,104.23 163.82,103.21 163.31,102.7 163.31,102.45 162.67,101.82 162.29,101.82 143.37,82.89 143.37,74.51 v136.13,67.27
O_BAC03  (via drill 0.61)
  Top 0.152: v149.72,102.7 149.72,100.42 162.67,87.46 163.43,87.46 v183.37,67.53 | v173.47,55.33 174.23,54.57 B11.D2
  Bottom 0.152: v149.72,102.7 150.48,103.47 150.48,107.02 A13.K2 | v183.37,67.53 183.37,65.24 v173.47,55.33
O_BAC04  (via drill 0.61)
  Top 0.152: v188.45,51.14 179.82,59.78 179.82,62.95 179.69,63.08 179.69,64.99 v173.34,71.34 | v174.74,77.3 174.1,77.3 163.56,87.85 162.8,87.85 152.89,97.75 152.89,98.89 151.12,100.67 A13.M2
  Bottom 0.152: v188.45,51.14 182.1,44.79 182.1,40.73 179.69,38.32 178.55,38.32 B11.K2 | v173.34,71.34 173.34,75.91 v174.74,77.3
O_BAC05  (via drill 0.61)
  Top 0.152: v187.31,32.09 187.31,33.24 173.47,47.08 173.47,53.43 v157.85,69.05 | v165.47,77.81 165.47,78.32 155.69,88.1 155.69,88.61 152.89,91.4 152.89,92.54 151.12,94.32 A13.P2
  Bottom 0.152: v187.31,32.09 178.17,22.95 178.17,19.65 B11.S2 | v157.85,69.05 157.85,69.3 158.61,70.07 158.61,70.95 v165.47,77.81
O_BAC06  (via drill 0.61)
  Top 0.152: v144.64,78.32 145.02,77.94 145.02,70.7 150.86,64.86 151.37,64.86 152,64.22 152.77,64.22 161.53,55.46 161.53,54.57 B12.D2
  Bottom 0.152: v144.64,78.32 144.64,79.08 145.02,79.46 145.02,80.86 145.91,81.75 145.91,82.26 148.7,85.05 148.7,86.19 150.48,87.97 A13.S2
O_BAC07  (via drill 0.61)
  Top 0.152: v169.78,44.29 169.78,47.71 152.89,64.6 152.13,64.6 151.5,65.24 150.99,65.24 145.4,70.83 145.4,78.7 v144.26,79.84
  Bottom 0.152: v169.78,44.29 165.47,39.97 165.47,38.7 B12.K2 | v144.26,79.84 144.26,80.61 145.53,81.88 145.53,83.02 147.31,84.8 A13.T2
O_BAC08  (via drill 0.61)
  Top 0.152: v141.21,44.67 164.7,21.17 164.7,19.65 B12.S2 | v158.99,61.81 158.99,66.76 157.08,68.67 157.08,70.7 148.32,79.46 A13.V2
  Bottom 0.152: v141.21,44.67 141.84,44.67 v158.99,61.81
O_BAC09  (via drill 0.61)
  Top 0.152: v107.68,98.01 148.83,56.86 148.83,55.46 147.94,54.57 B13.D2
  Bottom 0.152: v107.68,98.01 132.95,123.28 134.22,123.28 A14.D2
O_BAC10  (via drill 0.61)
  Top 0.152: v148.83,106.13 138.42,116.55 138.42,119.72 A14.E2 | v121.91,70.95 121.91,68.67 128.26,62.32 128.89,62.32 140.32,50.89 140.57,50.89 150.73,40.73 150.73,38.7 B13.K2
  Bottom 0.152: v148.83,106.13 148.83,103.21 136.76,91.15 136.76,88.99 133.84,86.07 133.84,82.89 v121.91,70.95
O_BAC11  (via drill 0.61)
  Top 0.152: v160.51,26.51 160.51,31.46 140.7,51.27 140.45,51.27 v128.64,63.08 | v158.23,90.26 143.62,104.86 143.62,107.02 140.19,110.45 140.19,111.59 138.42,113.37 A14.H2
  Bottom 0.152: v160.51,26.51 153.27,19.27 151.5,19.27 B13.S2 | v128.64,63.08 128.89,63.08 129.78,63.97 130.8,63.97 131.3,64.48 135.24,64.48 136,65.24 136,66 158.23,88.23 v158.23,90.26
O_BREAK  (via drill 0.61)
  Top 0.152: v69.2,102.58 69.2,101.94 69.96,101.18 69.96,99.66 70.98,98.64 70.98,92.29 80.5,82.77 80.5,79.72 96.76,63.46 96.76,63.21 97.9,62.06 97.9,61.43 109.59,49.75 109.59,48.98 113.78,44.79 113.78,41.62 134.48,20.92 135.75,20.92 137.4,19.27 B14.S2
  Bottom 0.152: v69.2,102.58 69.2,102.45 62.21,95.47 61.07,95.47 A20.P2
O_BRKRQ  (via drill 0.61)
  Top 0.152: v75.04,38.57 85.33,28.28 85.33,26 B18.P2 | v85.58,61.68 87.49,63.59 87.49,64.35 80.12,71.72 80.12,73.62 71.87,81.88 71.87,87.59 71.23,88.23 71.23,88.99 68.69,91.53 68.69,97.88 62.34,104.23 62.34,105.37 60.69,107.02 A20.K2
  Bottom 0.152: v75.04,38.57 75.04,44.79 80.5,50.25 80.5,53.81 84.69,58 84.69,60.8 v85.58,61.68
O_CAINCR  (via drill 0.61)
  Top 0.152: v29.58,96.1 38.59,87.08 38.59,81.88 41.89,78.57 41.89,70.95 42.02,70.83 42.02,70.19 42.15,70.07 42.15,69.68 42.4,69.43 42.4,69.18 55.99,55.59 55.99,53.43 67.17,42.25 70.22,42.25 72.63,39.84 72.63,38.7 B19.K2
  Bottom 0.152: v29.58,96.1 31.23,97.75 31.23,98.89 33.01,100.67 A22.M2
O_DATA00  (via drill 0.61)
  Top 0.152: v16.37,90.64 17.89,89.12 17.89,87.08 19.54,85.43 19.54,81.88 26.15,75.27 26.15,67.91 36.05,58 33.64,55.59 33.64,51.4 B22.E2
  Bottom 0.152: v16.37,90.64 16.37,95.59 40.75,119.98 40.75,121.12 42.53,122.9 A21.D2
O_DATA01  (via drill 0.61)
  Top 0.152: v13.07,85.43 15.61,82.89 15.61,80.23 15.99,79.84 15.99,59.52 30.85,44.67 32.62,44.67 B22.H2
  Bottom 0.152: v13.07,85.43 13.07,85.94 43.93,116.8 43.93,117.94 45.7,119.72 A21.E2
O_DATA02  (via drill 0.61)
  Top 0.152: v15.22,79.46 15.61,79.08 15.61,59.4 33.01,42 33.01,38.7 B22.K2
  Bottom 0.152: v15.22,79.46 15.22,81.75 15.35,81.88 15.35,85.05 42.4,112.1 43.67,112.1 45.32,113.75 A21.H2
O_DATA03
  Bottom 0.152: B22.M2 32.62,31.97 28.18,31.97 22.21,37.94 21.07,36.79 18.02,36.79 6.84,47.97 9,50.13 9,62.83 24.88,78.7 24.88,85.05 43.93,104.1 43.93,105.24 45.7,107.02 A21.K2
O_DATA04  (via drill 0.61)
  Top 0.152: v12.81,60.54 13.19,60.16 13.19,50.13 16.37,46.95 16.37,40.6 17.38,39.59 17.38,39.08 30.85,25.62 32.62,25.62 B22.P2
  Bottom 0.152: v12.81,60.54 12.81,66.13 44.31,97.62 44.31,99.28 45.7,100.67 A21.M2
O_DATA05  (via drill 0.61)
  Top 0.152: v13.19,42.76 33.01,22.95 33.01,19.65 B22.S2
  Bottom 0.152: v13.19,42.76 13.19,59.78 41.39,87.97 41.39,88.86 43.93,91.4 43.93,92.54 45.7,94.32 A21.P2
O_DATA06  (via drill 0.61)
  Top 0.152: v19.54,53.81 20.3,53.05 20.3,51.4 B23.E2
  Bottom 0.152: v19.54,53.81 19.54,59.78 27.67,67.91 27.67,68.41 42.15,82.89 42.15,83.27 43.93,85.05 43.93,86.19 45.7,87.97 A21.S2
O_DATA07  (via drill 0.61)
  Top 0.152: v44.44,82 44.44,83.53 43.16,84.8 A21.T2
  Bottom 0.152: v44.44,82 42.78,80.35 42.4,80.35 32.37,70.32 32.37,66.64 23.1,57.37 23.1,56.1 14.84,47.84 18.02,44.67 19.92,44.67 B23.H2
O_DATA08
  Bottom 0.152: B23.K2 20.94,38.7 20.94,43.02 21.7,43.78 21.7,44.79 19.04,47.46 17.89,46.32 16.88,46.32 15.35,47.84 23.48,55.97 23.48,57.24 32.75,66.51 32.75,68.67 42.53,78.45 A21.V2
O_DATA09
  Top 0.152: B23.M2 20.3,32.35 20.3,34.51 12.43,42.38 12.43,57.24 10.02,59.65 10.02,63.34 5.32,68.03 5.32,78.07 6.33,79.08 6.21,79.21 6.21,114.01 19.04,126.83 20.18,125.69 27.8,125.69 29.45,124.04 A22.D2
O_DATA10
  Bottom 0.152: B23.P2 20.3,26 20.3,30.32 17.51,33.11 18.53,34.12 18.53,35.78 0.75,53.56 0.75,86.32 31.23,116.8 31.23,117.94 33.01,119.72 A22.E2
O_DATA11  (via drill 0.61)
  Top 0.152: v3.16,53.81 12.05,44.92 12.05,42.25 16.37,37.94 16.37,27.9 20.3,23.96 20.3,19.65 B23.S2
  Bottom 0.152: v3.16,53.81 3.16,85.56 29.7,112.1 30.97,112.1 32.62,113.75 A22.H2
O_DATAIN  (via drill 0.61)
  Top 0.152: v91.42,29.43 91.42,29.55 82.03,38.95 82.03,39.59 58.79,62.83 58.79,63.08 52.18,69.68 52.18,70.83 47.23,75.78 47.23,77.56 v41.39,83.4
  Bottom 0.152: v91.42,29.43 86.09,24.09 86.09,19.65 B18.S2 | v41.39,83.4 41.39,85.69 51.93,96.23 53.58,96.23 56.75,99.4 57.9,99.4 59.55,101.05 A20.M2
O_EXTA0  (via drill 0.61)
  Top 0.152: v17.89,106.26 25.89,98.26 25.89,94.58 28.05,92.42 28.05,90.39 31.86,86.58 31.86,81.75 34.15,79.46 34.15,78.57 37.83,74.89 37.83,68.54 55.61,50.76 55.61,46.95 68.69,33.87 68.69,28.03 69.83,26.89 69.83,26.38 72.63,23.58 72.63,19.65 B19.S2
  Bottom 0.152: v17.89,106.26 17.89,109.82 18.53,110.45 18.53,111.59 20.3,113.37 A23.H2
O_EXTA1  (via drill 0.61)
  Top 0.152: v82.79,39.33 82.79,39.71 84.19,41.11 43.67,81.62 43.67,82.64 31.86,94.45 31.86,94.96 29.07,97.75 29.07,110.45 22.72,116.8 22.72,117.94 20.94,119.72 A23.E2
  Bottom 0.152: v82.79,39.33 73.39,29.93 73.39,26 B19.P2
O_EXTA2
  Top 0.152: B19.M2 72.25,31.97 71.11,31.97 55.99,47.08 55.99,52.92 55.61,53.3 55.61,55.46 42.02,69.05 42.02,69.3 41.77,69.56 41.77,69.94 41.64,70.07 41.64,70.7 41.51,70.83 41.51,78.45 38.21,81.75 38.21,85.43 28.81,94.83 28.69,94.83 28.31,95.21 28.31,110.71 22.34,116.67 22.34,117.18 19.54,119.98 19.54,121.12 17.77,122.9 A23.D2
O_INIT  (via drill 0.61)
  Top 0.152: v132.7,76.42 132.7,73.49 147.18,59.02 152.64,59.02 153.27,58.38 154.16,58.38 156.7,55.84 157.34,55.84 164.07,49.11 164.07,48.86 190.1,22.82 190.61,22.82 v192.52,20.92 | v198.36,20.92 200.77,20.92 202.42,19.27 B09.S2
  Bottom 0.152: v132.7,76.42 134.61,78.32 134.61,78.45 A14.V2 | v192.52,20.92 v198.36,20.92
O_IOP1  (via drill 0.61)
  Top 0.152: v147.81,113.37 161.78,99.4 162.29,99.4 192.01,69.68 195.82,69.68 196.2,69.3 197.98,69.3 202.8,64.48 203.57,64.48 213.73,54.32 B08.D2
  Bottom 0.152: v147.81,113.37 145.27,113.37 141.72,109.82 140.45,109.82 138.8,108.17 A14.K2
O_IOP2
  Top 0.152: B08.K2 217.16,38.7 217.16,39.84 211.95,45.05 210.3,45.05 203.57,51.78 200.01,51.78 196.45,55.33 193.66,55.33 184.52,64.48 181.34,64.48 173.72,72.1 173.21,72.1 170.55,74.77 170.29,74.77 168.51,76.54 167.88,76.54 156.83,87.59 156.7,87.59 156.07,88.23 156.07,91.4 148.07,99.4 142.61,99.4 141.97,100.04 139.81,100.04 138.8,101.05 A14.M2
O_IOP4  (via drill 0.61)
  Top 0.152: v144.38,90.39 140.07,94.7 138.8,94.7 A14.P2 | v130.41,72.99 130.41,69.3 145.15,54.57 145.15,54.19 147.05,52.29 147.56,52.29 156.7,43.14 157.47,43.14 163.05,37.55 163.43,37.55 188.33,12.66 188.83,12.66 190.1,11.39 193.53,11.39 v193.79,11.14 | v211.69,22.19 212.58,22.19 213.85,20.92 215.12,20.92 216.77,19.27 B08.S2
  Bottom 0.152: v144.38,90.39 144.38,90.26 143.37,89.24 143.37,85.94 v130.41,72.99 | v193.79,11.14 199.76,11.14 209.03,20.41 209.92,20.41 v211.69,22.19
O_IRQ  (via drill 0.61)
  Top 0.152: v107.94,67.91 107.94,69.81 101.71,76.03 101.71,76.54 96.5,81.75 96.5,82.26 87.36,91.4 87.36,91.91 84.57,94.7 84.57,99.91 85.33,100.67 A18.M2
  Bottom 0.152: v107.94,67.91 107.81,67.91 86.09,46.19 86.09,45.05 B18.H2
O_LINE  (via drill 0.61)
  Top 0.152: v99.17,47.71 99.17,48.35 94.09,53.43 94.09,58 88.25,63.84 88.25,64.73 81.27,71.72 81.27,74.64 v80.38,75.53
  Bottom 0.152: v99.17,47.71 86.09,34.63 86.09,32.35 B18.M2 | v80.38,75.53 80.38,76.67 82.15,78.45 A18.V2
O_MB00  (via drill 0.61)
  Top 0.152: v158.99,122.9 153.02,128.87 134.48,128.87 133.34,130.01 127.37,124.04 122.92,124.04 A15.D2 | v172.58,124.8 182.23,124.8 v190.87,116.17 | v214.36,135.47 218.68,135.47 225.54,128.61 225.54,125.56 226.68,124.42 A07.D2
  Bottom 0.152: v158.99,122.9 159.62,122.9 161.53,124.8 v172.58,124.8 | v190.87,116.17 190.87,116.8 199.88,125.82 200.65,125.82 209.15,134.33 213.22,134.33 v214.36,135.47
O_MB01  (via drill 0.61)
  Top 0.152: v202.17,137.76 209.54,130.39 209.54,129.88 211.44,127.98 211.95,127.98 229.86,110.07 229.86,108.55 A07.K2 | v155.69,103.21 150.61,103.21 135.37,118.45 127.75,118.45 126.1,120.1 A15.E2
  Bottom 0.152: v202.17,137.76 196.58,137.76 187.69,128.87 183.75,128.87 169.02,114.13 166.61,114.13 v155.69,103.21
O_MB02  (via drill 0.61)
  Top 0.152: v227.82,89.62 228.33,89.12 229.47,89.12 A07.S2 | v222.24,84.42 222.24,85.56 214.74,93.05 213.09,93.05 206.74,99.4 202.55,99.4 183.63,118.33 181.47,118.33 178.17,121.63 174.48,121.63 160.89,135.22 148.83,135.22 v148.45,135.6
  Bottom 0.152: v227.82,89.62 227.44,89.62 v222.24,84.42 | v148.45,135.6 129.02,116.17 127.75,116.17 126.1,114.52 A15.H2
O_MB03  (via drill 0.61)
  Top 0.152: v178.55,135.22 185.53,135.22 187.18,133.57 187.95,133.57 200.77,120.74 201.41,120.74 209.15,112.99 210.68,112.99 213.85,109.82 215.12,109.82 216.77,108.17 A08.K2
  Bottom 0.152: v178.55,135.22 177.66,134.33 177.4,134.33 171.69,128.61 170.93,128.61 170.29,127.98 168.77,127.98 163.94,132.8 163.94,133.57 164.7,134.33 163.69,135.34 162.93,135.34 134.61,107.02 134.22,107.02 132.57,105.37 132.19,105.37 128.64,101.82 126.1,101.82 A15.M2
O_MB03\  (via drill 0.61)
  Top 0.152: v191.5,139.66 197.98,139.66 199.12,138.52 199.38,138.52 210.68,127.22 210.68,126.96 213.6,124.04 A08.D2
  Bottom 0.152: v191.5,139.66 189.34,137.5 170.67,137.5 169.53,136.36 161.02,136.36 160.64,135.98 157.08,135.98 155.05,133.95 154.42,133.95 134.35,113.88 133.72,113.88 128,108.17 126.1,108.17 A15.K2
O_MB04  (via drill 0.61)
  Top 0.152: v196.07,128.74 196.45,128.74 197.98,127.22 197.98,126.07 199.63,124.42 A09.D2
  Bottom 0.152: v196.07,128.74 196.58,129.25 196.58,130.39 204.2,138.01 204.71,138.01 205.47,138.77 204.71,139.53 203.95,139.53 202.93,138.52 201.79,138.52 201.41,138.14 196.45,138.14 195.18,136.87 190.1,136.87 188.33,135.09 187.18,135.09 186.42,134.33 183.75,134.33 180.96,131.53 180.45,131.53 172.2,123.28 171.69,123.28 158.1,109.69 150.1,109.69 134.73,94.32 132.95,94.32 127.75,89.12 126.1,89.12 A15.S2
O_MB04\  (via drill 0.61)
  Top 0.152: v212.33,85.81 210.93,85.81 202.04,94.7 202.04,95.97 201.03,96.99 199.76,96.99 179.82,116.93 179.82,117.18 v178.67,118.33 | v137.53,90.77 131.3,90.77 129.02,93.05 127.75,93.05 126.1,94.7 A15.P2
  Bottom 0.152: v212.33,85.81 214.87,88.35 216.77,88.35 A08.S2 | v178.67,118.33 177.15,118.33 171.82,112.99 167.12,112.99 156.32,102.2 153.15,102.2 151.24,100.29 147.05,100.29 v137.53,90.77
O_MB05  (via drill 0.61)
  Top 0.152: v148.07,56.48 125.72,78.83 122.92,78.83 A15.V2 | v167.62,65.88 171.44,65.88 v174.99,62.32
  Bottom 0.152: v148.07,56.48 148.7,56.48 150.35,58.13 154.16,58.13 158.61,62.57 162.29,62.57 164.58,64.86 166.61,64.86 v167.62,65.88 | v174.99,62.32 175.25,62.32 177.4,64.48 177.91,64.48 182.99,69.56 185.53,69.56 201.15,85.18 201.15,86.32 202.8,87.97 A09.S2
O_MB05\  (via drill 0.61)
  Top 0.152: v136.76,97.5 140.45,97.5 147.18,90.77 152.39,90.77 v154.67,88.48 | v188.07,121.25 188.2,121.25 199.63,109.82 200.77,109.82 202.42,108.17 A09.K2
  Bottom 0.152: v136.76,97.5 135.49,96.23 131.3,96.23 122.54,87.46 122.54,86.32 A15.T2 | v154.67,88.48 155.31,88.48 v188.07,121.25
O_MB06  (via drill 0.61)
  Top 0.152: v172.07,90.77 171.56,90.77 148.19,114.13 147.18,114.13 143.5,117.82 142.35,117.82 138.54,121.63 119.49,121.63 113.14,127.98 112.25,127.98 107.94,123.66 109.08,122.52 110.35,122.52 112,120.87 A16.E2
  Bottom 0.152: v172.07,90.77 174.99,90.77 190.1,105.88 190.1,107.02 A10.K2
O_MB06\  (via drill 0.61)
  Top 0.152: v121.02,136.74 v171.05,136.74 | v173.34,136.74 173.34,136.11 183.75,125.69 184.9,125.69 186.55,124.04 A10.D2
  Bottom 0.152: v121.02,136.74 109.84,125.56 109.84,124.42 A16.D2 | v171.05,136.74 v173.34,136.74
O_MB07  (via drill 0.61)