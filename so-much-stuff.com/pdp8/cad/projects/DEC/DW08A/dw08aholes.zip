# EAGLE board dw08aholes (EAGLE 4.11), part 2 of 4
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
I_AC11  (via drill 0.61) (continued)
  Top 0.152: v117.46,39.08 126.6,39.08 144.38,21.3 145.15,21.3 150.35,16.09 152,16.09 156.7,11.39 158.35,11.39 161.53,8.22 171.44,8.22 172.58,7.07 179.06,7.07 v184.52,1.61 | v244.84,7.84 246.11,7.84 v250.68,3.26 | v271.51,23.46 v271.51,32.35 | v257.29,137.63 261.22,137.63 261.61,137.25 261.86,137.25 282.18,116.93 282.18,114.9 A03.H2 | v234.94,116.17 232.78,116.17 224.14,124.8 223.12,124.8 220.08,127.85 218.04,127.85 217.92,127.98 215.25,127.98 214.36,128.87 213.85,128.87 v210.81,131.92 | v155.43,78.32 v158.23,81.11
  Bottom 0.152: v184.52,1.61 204.07,1.61 205.22,2.76 210.17,2.76 210.55,2.38 230.36,2.38 233.28,5.3 236.33,5.3 238.87,7.84 v244.84,7.84 | v250.68,3.26 252.08,4.66 252.46,4.66 261.48,13.68 261.73,13.68 v271.51,23.46 | v271.51,32.35 272.15,32.35 280.53,40.73 280.53,41.87 282.18,43.52 B03.H2 | B17.R2 96,22.44 98.79,22.44 114.67,38.32 116.7,38.32 v117.46,39.08 117.84,38.82 145.4,66.38 145.4,71.59 151.88,78.07 154.42,78.07 154.67,78.32 v155.43,78.32 | v257.29,137.63 257.29,137.38 239.63,119.72 238.49,119.72 v234.94,116.17 | v210.81,131.92 209.79,131.92 203.57,125.69 202.93,125.69 201.15,123.91 201.15,123.28 190.87,112.99 187.82,112.99 179.82,104.99 179.82,101.94 159.5,81.62 158.74,81.62 v158.23,81.11
I_ACCEPT  (via drill 0.61)
  Top 0.152: v234.94,21.81 236.84,21.81 v255.51,3.14 | v151.24,66.13 152,66.13 v213.35,4.79 | v271,87.21 270.24,87.97 A04.S2 | v259.45,75.02 259.45,74.38 v265.92,67.91 | v254.49,51.91 254.49,49.87 263.76,40.6 264.4,40.6 v278.88,26.12
  Bottom 0.152: v234.94,21.81 232.4,19.27 230.87,19.27 B07.S2 229.47,18.5 227.82,16.85 226.55,16.85 223.76,14.06 223.25,14.06 215,5.8 214.49,5.8 213.47,4.79 v213.35,4.79 | v255.51,3.14 255.64,3.14 267.83,15.33 267.83,16.47 269.48,18.12 B04.S2 270.62,19.27 272.27,20.92 273.42,20.92 274.31,21.81 275.07,21.81 278.88,25.62 v278.88,26.12 | v151.24,66.13 129.78,44.67 126.1,44.67 B15.H2 | v271,87.21 271,86.58 v259.45,75.02 | v265.92,67.91 265.92,63.34 v254.49,51.91
I_ACCLR  (via drill 0.61)
  Top 0.152: v260.46,4.66 255.51,4.66 251.83,8.34 251.32,8.34 235.06,24.6 235.06,25.23 v233.67,26.63 | v230.49,23.33 225.92,27.9 225.92,31.08 221.09,35.9 216.39,35.9 200.9,51.4 199.25,51.4 v196.07,54.57 | v146.29,5.93 141.84,5.93 133.72,14.06 133.46,14.06 100.44,47.08 100.44,48.6 v99.55,49.49 | v281.04,93.94 280.4,93.94 278.88,95.47 277.86,95.47 276.72,96.61 276.21,96.61 267.07,105.75 266.18,105.75 v261.35,110.58 | v253.35,106.64 253.22,106.64 v245.73,114.13 | v230.62,99.53 230.62,99.15 v233.16,96.61
  Bottom 0.152: v260.46,4.66 280.66,24.85 281.8,24.85 B03.P2 | v233.67,26.63 233.67,26.51 v230.49,23.33 | v196.07,54.57 195.95,54.57 195.57,54.19 | 195.57,54.19 194.04,52.67 193.66,52.67 192.77,51.78 192.77,50.89 179.82,37.94 179.31,37.94 162.29,20.92 161.28,20.92 v146.29,5.93 | v99.55,49.49 95.74,49.49 87.74,41.49 87.74,38.44 86.09,36.79 85.2,36.79 83.3,38.7 83.55,38.95 83.55,39.71 82.92,40.35 B18.J2 | v281.04,93.94 281.8,94.7 A03.P2 | v261.35,110.58 259.95,110.58 256.02,106.64 v253.35,106.64 | v245.73,114.13 244.46,114.13 243.32,112.99 243.06,112.99 241.92,111.85 241.92,111.09 233.92,103.09 233.54,103.09 232.65,102.2 232.65,101.56 v230.62,99.53 | v233.16,96.61 233.16,96.48 208.9,72.22 208.77,72.22 208.39,71.84 208.39,70.7 205.47,67.78 205.22,67.78 204.96,67.53 204.71,67.53 194.3,57.11 194.17,57.11 193.79,56.73 193.79,55.97 195.57,54.19
I_ADD00  (via drill 0.61)
  Top 0.152: v81.27,36.41 80.88,36.79 78.98,36.79 62.34,53.43 57.9,53.43 B20.D2 | v110.22,58.13 114.03,58.13 115.55,56.6 117.33,56.6 118.48,55.46 118.98,55.46 121.78,52.67 137.65,52.67 v149.97,40.35 | v209.15,99.53 209.28,99.53 v225.92,82.89 259.45,49.37 v259.57,49.37
  Bottom 0.152: v81.27,36.41 86.73,36.41 99.05,48.73 100.82,48.73 v110.22,58.13 | v149.97,40.35 149.97,40.73 152.26,43.02 152.64,43.02 v209.15,99.53 | v259.57,49.37 259.57,50 266.81,57.24 267.07,57.24 269.23,59.4 271.89,59.4 272.27,59.78 B04.B1 | v225.92,82.89 243.95,100.93 243.95,101.18 246.24,103.47 246.49,103.47 250.18,107.15 251.19,107.15 265.54,121.5 265.54,124.04 271.13,129.63 272.27,129.63 A04.B1
I_ADD01  (via drill 0.61)
  Top 0.152: v69.45,39.46 61.83,47.08 57.9,47.08 B20.F2 | v133.46,93.18 137.02,93.18 v139.3,90.89 | v155.56,98.13 158.86,98.13 165.72,91.27 166.23,91.27 v185.02,72.48 | v212.71,97.75 212.71,97.62 223.12,87.21 223.76,87.21 v234.94,76.03 | v238.11,79.21 239.25,78.07 239.63,78.07 243.06,74.64 243.06,74 253.1,63.97 253.1,63.34 263.76,52.67 266.18,52.67 v268.21,50.63 | v255.89,104.48 255.89,103.59 v259.83,99.66
  Bottom 0.152: v69.45,39.46 73.64,35.27 113.65,75.27 113.9,75.27 114.16,75.53 114.54,75.53 114.67,75.65 115.17,75.65 115.3,75.78 116.06,75.78 v133.46,93.18 | v139.3,90.89 139.3,91.53 140.83,93.05 150.48,93.05 v155.56,98.13 | v185.02,72.48 185.41,72.48 209.15,96.23 211.19,96.23 v212.71,97.75 | v234.94,76.03 v238.11,79.21 238.36,79.59 239.25,80.48 240.65,80.48 241.41,81.24 243.32,81.24 254.37,92.29 254.37,93.05 255.26,93.94 256.02,93.94 259.83,97.75 v259.83,99.66 | v268.21,50.63 268.34,50.63 269.48,51.78 270.62,51.78 272.27,53.43 B04.D1 | v255.89,104.48 258.05,106.64 258.68,106.64 273.29,121.25 273.29,122.9 A04.D1
I_ADD02  (via drill 0.61)
  Top 0.152: v102.22,81.37 104.25,81.37 v107.81,77.81 | v187.56,134.33 187.82,134.33 190.1,132.04 195.69,132.04 196.33,131.41 197.09,131.41 202.8,125.69 205.22,125.69 v205.47,125.44 | v210.3,130.26 211.95,130.26 213.73,128.49 214.23,128.49 220.2,122.52 223,122.52 v223.12,122.39 | v238.87,138.14 239.13,138.14 241.03,136.23 241.92,136.23 v251.06,127.09 | v260.59,136.49 262.11,136.49 266.69,131.92 266.69,131.53 274.18,124.04 274.18,122.9 275.83,121.25 A04.E1 | v268.21,44.29 266.69,44.29 260.84,50.13 260.84,52.41 v260.34,52.92 | v263,55.72 263,57.49 v257.29,63.21 | v243.83,52.67 243.83,53.05 241.67,55.21 241.29,55.21 226.93,69.56 226.68,69.56 v225.79,70.45 | v225.79,74.89 225.79,77.3 212.58,90.51 v212.46,90.51 | v222.24,107.91 222.11,107.91 v215.25,114.77
  Bottom 0.152: v102.22,81.37 84.31,63.46 84.31,58.13 70.09,43.9 69.83,43.9 68.18,42.25 63.1,42.25 62.34,41.49 57.9,41.49 B20.J2 | v107.81,77.81 116.95,77.81 133.08,93.94 134.86,93.94 150.23,109.31 158.23,109.31 171.82,122.9 172.32,122.9 180.58,131.15 184.39,131.15 v187.56,134.33 | v205.47,125.44 v210.3,130.26 | v238.87,138.14 235.95,135.22 235.95,135.09 223.25,122.39 v223.12,122.39 222.74,122.26 218.3,117.82 217.66,117.82 215.25,115.4 v215.25,114.77 | v251.06,127.09 251.19,127.09 v260.59,136.49 | v268.21,44.29 272.53,48.6 273.8,48.6 275.45,50.25 B04.E1 | v260.34,52.92 260.34,53.05 v263,55.72 | v257.29,63.21 257.03,63.21 246.49,52.67 v243.83,52.67 | v225.79,74.89 v225.79,70.45 | v212.46,90.51 212.46,93.69 215.76,96.99 216.39,96.99 227.06,107.66 227.06,109.44 228.08,110.45 228.08,111.47 226.93,112.61 v222.24,107.91
I_ADD03  (via drill 0.61)
  Top 0.152: v70.22,43.02 71.74,43.02 97.78,16.98 104.25,16.98 v112.13,9.11 | v200.65,96.23 200.65,95.59 210.81,85.43 211.57,85.43 v219.95,77.05 | v265.29,118.45 270.37,118.45 272.65,116.17 273.8,116.17 275.45,114.52 A04.H1 | v242.3,74.26 252.72,63.84 252.72,63.21 264.53,51.4 266.3,51.4 272.53,45.17 273.92,45.17 274.43,44.67 275.45,44.67 B04.H1 | v233.41,89.24 v245.35,77.3
  Bottom 0.152: v70.22,43.02 62.34,35.14 57.9,35.14 B20.L2 | v112.13,9.11 113.14,9.11 113.4,9.36 113.65,9.36 166.61,62.32 166.86,62.32 171.82,67.27 171.82,67.4 v200.65,96.23 | v219.95,77.05 221.22,77.05 226.68,82.51 226.68,82.89 233.03,89.24 | 233.03,89.24 237.98,94.2 238.49,94.2 241.16,96.86 241.92,96.86 261.35,116.29 263.13,116.29 v265.29,118.45 | v245.35,77.3 v242.3,74.26 | 233.03,89.24 v233.41,89.24
I_ADD04  (via drill 0.61)
  Top 0.152: v162.29,102.58 162.29,101.94 v179.82,84.42 | v203.44,105.37 204.07,105.37 209.15,100.29 209.54,100.29 209.92,99.91 209.92,99.4 212.33,96.99 212.84,96.99 226.17,83.65 226.3,83.65 234.17,75.78 234.17,75.65 234.55,75.27 236.97,75.27 237.09,75.15 | 237.09,75.15 238.49,73.75 239.13,73.75 240.27,72.61 241.41,72.61 241.79,72.22 242.05,72.22 251.57,62.7 252.21,62.7 265.42,49.49 266.18,49.49 271,44.67 271,43.52 272.65,41.87 B04.J1 | v255.13,92.67 v253.99,93.81 | 237.09,75.15 v237.22,75.15
  Bottom 0.152: v162.29,102.58 105.14,45.43 104.38,45.43 90.54,31.59 89.65,31.59 82.03,23.96 74.66,23.96 73.64,22.95 67.04,29.55 63.1,29.55 62.34,28.79 57.9,28.79 B20.N2 | v179.82,84.42 182.61,84.42 203.44,105.24 v203.44,105.37 | v253.99,93.81 254.49,94.32 254.49,95.59 263.51,104.61 264.65,103.47 267.07,103.47 268.72,105.12 268.72,108.17 271.13,110.58 272.27,110.58 A04.J1 | v255.13,92.67 255.13,92.54 243.44,80.86 242.94,80.86 v237.22,75.15
I_ADD05  (via drill 0.61)
  Top 0.152: v72.76,16.6 73.77,16.6 75.8,14.57 80.63,14.57 84.95,10.25 85.46,10.25 88.25,7.46 90.03,7.46 90.41,7.07 92.69,7.07 94.09,5.68 95.23,5.68 95.36,5.55 100.06,5.55 102.98,2.63 123.68,2.63 124.44,1.87 130.67,1.87 v131.05,1.49 | v207.88,63.72 207.88,63.08 224.9,46.06 225.54,46.06 v225.92,45.68 | v268.72,33.36 267.83,34.25 267.83,35.14 262.49,40.48 262.49,40.86 248.52,54.83 247.89,54.83 246.37,56.35 245.86,56.35 241.79,60.41 v241.29,60.41 241.03,60.8 239,62.83 v239,63.34
  Bottom 0.152: v72.76,16.6 70.09,13.93 62.34,21.68 57.9,21.68 B20.R2 | v131.05,1.49 131.56,1.49 132.07,1.99 141.08,1.99 141.97,2.88 145.91,2.88 156.7,13.68 157.34,13.68 168.13,24.47 169.02,24.47 199.5,54.95 199.88,54.95 200.26,55.33 200.26,56.1 v207.88,63.72 | v225.92,45.68 227.06,45.68 236.21,54.83 236.21,55.08 240.78,59.65 240.78,59.91 v241.29,60.41 | v268.72,33.36 271.26,33.36 272.27,34.38 B04.L1 | v239,63.34 253.48,77.81 253.48,78.83 254.75,80.1 255.38,80.1 263.13,87.85 263.13,91.53 263.38,91.78 263.38,93.31 265.54,95.47 265.54,96.1 266.56,97.12 267.07,97.12 272.65,102.7 272.65,103.85 A04.L1
I_ADD06  (via drill 0.61)
  Top 0.152: v96.38,96.23 108.32,96.23 v110.86,93.69 | v199.5,139.28 v211.57,127.22 | v212.71,128.36 212.71,127.72 234.05,106.39 234.05,106.26 v245.86,94.45 | v264.53,110.71 265.42,110.71 269.48,106.64 269.86,106.64 270.24,106.26 270.24,105.88 272.65,103.47 273.8,103.47 275.45,101.82 A04.M1 276.59,100.67 277.35,99.91 v277.35,99.15 | v253.6,56.6 273.04,37.17 273.54,37.17 275.83,34.89 275.83,32.35 B04.M1 | v268.59,71.72 268.59,75.02 v263.13,80.48
  Bottom 0.152: v96.38,96.23 66.15,66 64.5,66 62.98,64.48 59.93,64.48 53.58,58.13 51.93,58.13 47.99,54.19 43.55,54.19 B21.D2 | v110.86,93.69 114.03,93.69 133.84,113.5 134.48,113.5 154.54,133.57 155.18,133.57 157.21,135.6 160.77,135.6 161.15,135.98 177.4,135.98 178.04,136.61 189.34,136.61 191.63,138.9 199.12,138.9 v199.5,139.28 | v211.57,127.22 v212.71,128.36 | v245.86,94.45 246.49,94.45 252.72,100.67 253.22,100.67 261.48,108.93 262.75,108.93 v264.53,110.71 | v253.6,56.6 253.6,56.73 v268.59,71.72 | v263.13,80.48 267.83,85.18 267.83,89.62 v277.35,99.15
I_ADD07  (via drill 0.61)
  Top 0.152: v91.42,8.22 88.5,8.22 78.98,17.74 72.63,17.74 53.45,36.92 53.45,38.44 44.82,47.08 43.55,47.08 B21.F2 | v152.39,50.13 152.89,50.13 158.23,44.79 158.23,43.27 161.53,39.97 167.37,39.97 174.1,33.24 174.61,33.24 190.1,17.74 195.69,17.74 v198.87,14.57 | v219.95,31.84 220.46,31.84 229.35,22.95 229.35,22.82 229.98,22.19 230.49,22.19 242.56,10.12 242.56,8.98 244.46,7.07 245.73,7.07 v248.02,4.79 | v265.29,20.16 265.92,20.16 v269.35,16.73 | v272.78,20.16 275.32,22.7 v274.69,23.33 | v289.67,78.45 276.59,91.53 276.59,94.32 A04.P1 | v289.29,76.54 289.29,74.77 v290.05,74 | v282.81,65.11 282.81,64.6 296.4,51.02 v296.4,49.11
  Bottom 0.152: v91.42,8.22 106.79,8.22 121.78,23.2 126.1,23.2 148.19,45.3 148.19,45.94 v152.39,50.13 | v198.87,14.57 202.68,14.57 v219.95,31.84 | v248.02,4.79 249.92,4.79 v265.29,20.16 | v269.35,16.73 v272.78,20.16 | v274.69,23.33 275.83,24.47 B04.P1 276.59,26 278.24,27.65 278.24,28.79 287.39,37.94 287.39,38.44 296.4,47.46 v296.4,49.11 | v289.67,78.45 289.67,76.92 v289.29,76.54 | v290.05,74 290.05,72.35 v282.81,65.11
I_ADD08  (via drill 0.61)
  Top 0.152: v69.2,64.35 69.45,64.35 107.94,25.87 109.97,25.87 128,7.84 130.8,7.84 134.35,4.28 140.7,4.28 141.08,3.9 145.65,3.9 v147.56,1.99 | v199.88,50 201.15,50 216.39,34.76 216.39,34.25 219.57,31.08 220.08,31.08 v228.59,22.57 | v232.4,26.51 232.65,26.51 251.19,7.96 251.7,7.96 255.38,4.28 258.18,4.28 v258.56,3.9 | v273.42,18.76 275.45,18.76 B04.S1 | v301.61,54.32 300.09,55.84 300.09,56.86 299.58,57.37 299.58,60.54 293.74,66.38 293.48,66.38 286.88,72.99 286.88,75.27 283.45,78.7 283.07,78.7 279.13,82.64 279.13,84.29 276.59,86.83 276.59,87.97 A04.S1
  Bottom 0.152: v69.2,64.35 46.34,41.49 43.55,41.49 B21.J2 | v147.56,1.99 151.88,1.99 v199.88,50 | v228.59,22.57 230.11,24.09 230.62,24.09 231.25,24.73 231.25,25.36 v232.4,26.51 | v258.56,3.9 v273.42,18.76 273.67,19.14 287,32.47 287,33.49 287.77,34.25 287.77,38.32 299.58,50.13 299.58,52.29 v301.61,54.32
I_ADD09  (via drill 0.61)
  Top 0.152: v49.13,30.44 45.58,30.44 43.16,32.86 43.16,34 B21.L2 | v140.07,87.97 142.48,87.97 v154.67,75.78 | v201.15,121.5 202.55,122.9 203.44,122.01 204.2,122.01 v210.42,115.79 | v234.68,139.28 234.68,138.65 248.91,124.42 250.05,124.42 v252.97,121.5 252.97,121.12 265.42,108.67 v265.42,107.78 | v264.53,125.44 265.92,124.04 A04.D2 | v267.19,56.48 256.91,66.76 v255.51,66.76 | v245.48,73.37 v252.08,66.76 | v246.49,74.77 246.49,75.02 v240.27,81.24
  Bottom 0.152: v49.13,30.44 70.34,30.44 82.15,42.25 87.36,42.25 99.05,53.94 99.3,53.94 111.49,66.13 117.08,66.13 119.36,68.41 120.51,68.41 v140.07,87.97 | v154.67,75.78 172.45,93.56 173.21,93.56 v201.15,121.5 | v210.42,115.79 210.42,116.04 216.77,122.39 217.28,122.39 226.43,131.53 226.93,131.53 v234.68,139.28 | v252.97,121.5 255,121.5 258.3,124.8 263.89,124.8 v264.53,125.44 | v267.19,56.48 267.07,56.35 267.07,54.57 B04.D2 | v252.08,66.76 v255.51,66.76 | v245.48,73.37 245.48,73.75 v246.49,74.77 | v240.27,81.24 240.27,81.37 244.71,85.81 244.71,86.07 251.06,92.42 251.06,92.93 263.13,104.99 263.13,105.5 v265.42,107.78
I_ADD10  (via drill 0.61)
  Top 0.152: v218.3,138.27 221.6,138.27 228.84,131.03 230.49,131.03 v234.94,126.58 | v248.02,137.88 249.29,137.88 261.48,125.69 263.13,125.69 266.3,122.52 267.45,122.52 269.1,120.87 A04.E2 | v267.57,52.41 268.97,51.02 269.1,51.02 B04.E2 | v250.81,36.79 248.78,36.79 247,38.57 245.73,38.57 v244.84,39.46 | v234.94,31.59 229.09,37.43 229.09,39.46 v228.59,39.97 | v228.59,44.03 228.59,44.16 226.3,46.44 225.03,46.44 223.25,48.22 223.25,48.73 218.93,53.05 218.93,53.94 v212.08,60.8 | v217.54,67.53 217.54,67.65 207.63,77.56 206.49,77.56 186.17,97.88 186.17,101.31 v182.61,104.86
  Bottom 0.152: 182.61,104.23 200.65,122.26 201.15,122.26 209.92,131.03 211.06,131.03 v218.3,138.27 | 182.61,104.23 158.23,79.84 157.34,80.73 153.4,80.73 117.33,44.67 114.16,44.67 113.78,44.29 113.78,43.78 86.85,16.85 75.8,16.85 71.23,12.28 65.9,17.62 45.7,17.62 41.77,21.55 41.77,22.57 42.53,23.33 42.53,27.65 B21.N2 | v234.94,126.58 234.94,126.83 239.25,131.15 239.51,131.15 240.02,131.66 240.02,131.92 242.43,134.33 244.46,134.33 v248.02,137.88 | v267.57,52.41 266.56,52.41 265.16,51.02 265.16,50.38 263.51,48.73 262.75,48.73 v250.81,36.79 | v244.84,39.46 242.81,39.46 v234.94,31.59 | v228.59,39.97 v228.59,44.03 | v212.08,60.8 212.08,62.06 v217.54,67.53 | v182.61,104.86 182.61,104.23
I_ADD11  (via drill 0.61)
  Top 0.152: v155.18,139.66 172.83,139.66 186.93,125.56 187.44,125.56 195.18,117.82 195.82,117.82 203.57,110.07 203.57,109.44 v209.54,103.47 | v242.94,136.87 243.44,136.87 259.83,120.48 260.34,120.48 261.48,119.34 263.13,119.34 266.3,116.17 267.45,116.17 269.1,114.52 A04.H2 | v263.13,49.49 267.57,45.05 268.59,45.05 268.97,44.67 269.1,44.67 B04.H2 | v264.15,53.43 263.89,53.43 254.49,62.83 254.49,63.21 244.71,72.99 244.71,74 v244.08,74.64 | v246.62,77.18 245.73,78.07 245.1,78.07 234.3,88.86 234.3,89.5 233.03,90.77 232.9,90.77 v215.25,108.42
  Bottom 0.152: v155.18,139.66 110.35,94.83 109.46,94.83 104.89,90.26 104.25,90.26 100.7,86.7 99.17,86.7 43.93,31.46 43.93,27.9 43.16,27.14 43.16,22.82 B21.R2 | v209.54,103.47 210.17,103.47 215.12,108.42 | 215.12,108.42 228.97,122.26 228.97,122.9 v242.94,136.87 | v263.13,49.49 263.13,52.41 v264.15,53.43 | v246.62,77.18 v244.08,74.64 | 215.12,108.42 v215.25,108.42
I_BAC00  (via drill 0.61)
  Top 0.152: v205.6,36.28 205.09,36.79 202.8,36.79 200.01,39.59 199.5,39.59 195.18,43.9 191.25,43.9 B10.H2 | v231.25,61.94 232.65,60.54 B07.B1 | v209.28,35.01 v206.87,37.43 | v205.85,31.71 206.49,31.71 231.12,7.07 232.9,7.07 237.22,2.76 237.6,2.76 238.62,1.74 240.52,1.74 v241.03,1.23 | v264.78,5.93 269.99,5.93 v273.42,2.5 | v317.49,23.08 317.49,38.95 315.83,40.6 315.83,44.79 312.15,48.48 312.15,48.86 308.21,52.79 308.21,55.21 v308.09,55.33
  Bottom 0.152: 206.74,37.43 v231.25,61.94 | 206.74,37.43 v205.6,36.28 | A01.B1 310.88,129.25 310.63,128.99 318.25,121.37 318.25,74.26 317.61,73.62 317.61,72.48 317.23,72.1 317.23,69.56 316.6,68.92 316.6,68.29 311.52,63.21 311.52,60.92 B01.B1 310.37,59.78 308.72,58.13 307.58,58.13 306.44,56.98 v308.09,55.33 | v206.87,37.43 206.74,37.43 | v209.28,35.01 209.15,35.01 v205.85,31.71 | v241.03,1.23 242.68,1.23 243.19,0.72 253.6,0.72 254.87,1.99 260.84,1.99 v264.78,5.93 | v273.42,2.5 299.45,2.5 315.45,18.5 315.45,21.04 v317.49,23.08
I_BAC01  (via drill 0.61)
  Top 0.152: v314.31,60.8 314.31,61.81 v310.5,65.62 | v190.61,23.58 187.69,26.51 187.69,27.65 B10.N2 | v225.66,57.49 226.93,57.49 v229.6,54.83 v232.01,52.41 | v293.61,126.96 295.77,124.8 305.17,124.8 305.93,124.04 310.37,124.04 A01.D1 | v226.55,68.8 226.55,68.54 v234.94,60.16
  Bottom 0.152: v314.31,60.8 312.91,59.4 312.91,57.87 311.52,56.48 311.52,54.57 B01.D1 | v310.5,65.62 310.5,68.03 313.42,70.95 313.42,71.59 315.2,73.37 315.2,79.46 315.58,79.84 315.58,81.62 315.83,81.88 315.83,84.54 317.61,86.32 317.61,115.66 310.63,122.64 310.88,122.9 A01.D1 | v190.61,23.58 191.37,23.58 202.68,34.89 203.06,34.89 206.36,38.19 206.61,38.19 224.9,56.48 224.9,56.73 v225.66,57.49 | v232.01,52.41 232.01,52.54 232.78,53.3 B07.D1 | v293.61,126.96 290.56,126.96 289.29,125.69 283.7,125.69 270.37,112.36 269.61,112.36 267.07,109.82 266.3,109.82 264.65,108.17 264.65,107.53 262.75,105.63 262.75,105.12 251.45,93.81 250.05,93.81 244.46,88.23 244.46,87.85 243.19,86.58 243.19,85.94 231.51,74.26 231.51,73.75 v226.55,68.8 | v229.6,54.83 v234.94,60.16
I_BAC02  (via drill 0.61)
  Top 0.152: v194.68,12.03 194.55,12.15 191.25,12.15 B10.U2 | 311.52,55.72 305.29,61.94 304.66,61.94 v303.77,62.83 | 311.52,55.72 313.29,53.94 313.29,53.3 313.93,52.67 313.93,51.4 B01.E1 | v303.51,71.84 303.51,77.81 v298.44,82.89 | v314.82,112.1 317.87,115.15 317.87,116.55 314.69,119.72 A01.E1 | v251.95,63.46 265.54,49.87 266.3,49.87 271.38,44.79 271.38,44.29 274.81,40.86 274.81,40.73 275.19,40.35 276.08,40.35 v286.12,30.32 | v308.98,53.18 311.52,55.72
  Bottom 0.152: v194.68,12.03 210.04,27.39 210.55,27.39 217.66,34.51 217.92,34.51 228.2,44.79 229.09,44.79 232.9,48.6 234.17,48.6 235.82,50.25 B07.E1 237.22,51.02 239,51.02 245.86,57.87 246.37,57.87 v251.95,63.46 | v303.77,62.83 303.77,71.59 v303.51,71.84 | v298.44,82.89 299.07,82.89 305.55,89.37 305.55,91.15 305.93,91.53 305.93,103.21 v314.82,112.1 | v286.12,30.32 v308.98,53.18
I_BAC03  (via drill 0.61)
  Top 0.152: v184.77,41.62 182.48,43.9 178.55,43.9 B11.H2 | v199.5,55.72 v204.58,55.72 | v215.38,66.51 215.89,66.51 224.9,57.49 224.9,57.11 226.43,55.59 227.06,55.59 233.03,49.62 233.03,49.37 234.43,47.97 234.43,46.83 236.21,45.05 B07.H1 237.22,43.9 238.49,43.9 243.95,38.44 243.95,38.06 v244.84,37.17 | v285.74,66.13 287.39,64.48 287.39,62.7 296.91,53.18 297.42,53.18 305.17,45.43 308.34,45.43 309.48,44.29 B01.H1 | v253.6,45.68 256.53,45.68 v261.73,40.48 | v264.15,41.36 264.4,41.36 266.18,39.59 266.69,39.59 275.83,30.44 279.77,30.44 v293.23,16.98
  Bottom 0.152: v184.77,41.62 185.41,41.62 v199.5,55.72 | v204.58,55.72 v215.38,66.51 | v285.74,66.13 285.74,67.53 290.43,72.22 290.43,73.24 290.81,73.62 290.81,74.13 305.93,89.24 305.93,91.02 306.31,91.4 306.31,102.45 315.58,111.72 315.58,112.48 314.69,113.37 A01.H1 | v244.84,37.17 246.24,38.57 246.49,38.57 249.67,41.74 250.18,41.74 250.94,42.51 250.94,43.02 v253.6,45.68 | v261.73,40.48 263.26,40.48 v264.15,41.36 | v293.23,16.98 293.23,19.9 305.8,32.47 305.8,33.24 310.37,37.81 310.37,38.82 312.28,40.73 312.28,41.87 313.93,43.52 B01.H1
I_BAC04  (via drill 0.61)
  Top 0.152: v315.71,46.57 315.71,51.4 313.68,53.43 313.68,54.06 304.15,63.59 303.51,63.59 v302.12,64.99 | v307.71,77.18 307.71,79.21 v297.29,89.62 | v170.29,33.49 170.29,31.2 172.71,28.79 173.85,28.79 B11.N2 | v189.85,53.68 190.36,53.68 195.44,48.6 201.41,48.6 v203.44,46.57 | v207.88,50.89 207.88,50.76 217.16,41.49 217.41,41.49 v220.08,38.82 v224.9,34 | v281.16,3.26 275.32,3.26 272.78,0.72 263.64,0.72 261.99,2.38 255.13,2.38 v245.22,12.28 | v234.94,9.74 234.55,9.74 233.79,10.5 231.12,10.5 230.62,11.01 230.11,11.01 216.39,24.73 216.39,25.11 215.89,25.62 215.5,25.62 213.22,27.9 213.22,30.44 v211.69,31.97
  Bottom 0.152: 314.69,45.55 v315.71,46.57 | 314.69,45.55 314.56,45.43 313.93,45.43 311.52,43.02 311.52,41.87 B01.J1 | v302.12,64.99 302.12,71.59 v307.71,77.18 | v297.29,89.62 297.29,92.8 300.85,96.35 300.85,98.64 303.13,100.93 303.13,101.43 309.1,107.4 309.1,108.55 310.75,110.2 A01.J1 | v170.29,33.49 170.29,34.12 v189.85,53.68 | v203.44,46.57 203.57,46.57 v207.88,50.89 | v224.9,34 224.9,34.51 227.44,37.05 227.7,37.05 229.73,39.08 231,39.08 232.65,40.73 B07.J1 | 314.69,45.55 316.34,43.9 311.77,39.33 311.77,37.43 309.61,35.27 309.61,31.71 v281.16,3.26 | v245.22,12.28 244.21,12.28 243.32,11.39 239.63,11.39 238.24,10 235.19,10 v234.94,9.74 | v211.69,31.97 213.09,33.36 214.49,33.36 215.38,34.25 215.38,34.51 216.77,35.9 217.16,35.9 v220.08,38.82
I_BAC05  (via drill 0.61)
  Top 0.152: v180.58,12.66 178.55,12.66 B11.U2 | v199.88,30.32 201.66,30.32 204.2,27.78 | v213.47,18.5 204.2,27.78 | v316.98,42.89 316.98,50.63 314.06,53.56 314.06,54.19 v293.61,74.64 | 204.2,27.78 v203.95,27.52 | v292.34,115.28 298.94,115.28 305.55,108.67 307.32,108.67 307.96,109.31 309.1,108.17 309.1,107.02 310.75,105.37 A01.L1
  Bottom 0.152: v180.58,12.66 182.23,12.66 v199.88,30.32 | v213.47,18.5 215.25,18.5 228.08,31.33 228.33,31.33 229.73,32.73 231,32.73 232.65,34.38 B07.L1 | v316.98,42.89 312.53,38.44 312.53,37.17 311.52,36.16 311.52,35.52 B01.L1 | v293.61,74.64 293.61,76.42 306.31,89.12 306.31,90.89 306.69,91.27 306.69,98.64 309.1,101.05 309.1,102.2 310.75,103.85 A01.L1 | v203.95,27.52 209.15,32.73 210.04,32.73 227.57,50.25 227.57,50.51 235.32,58.26 235.32,58.51 250.81,74 251.06,74 v292.34,115.28
I_BAC06  (via drill 0.61)
  Top 0.152: v167.12,42.76 165.97,43.9 165.85,43.9 B12.H2 | v185.28,55.59 187.06,55.59 188.45,54.19 188.45,53.94 189.47,52.92 190.23,52.92 v209.41,33.74 | v221.35,45.17 224.52,42 224.52,41.24 234.17,31.59 234.17,31.2 234.55,30.82 236.21,30.82 B07.M1 | v301.48,17.23 294.12,17.23 v269.61,41.74 | v257.29,30.19 253.86,30.19 v248.91,35.14 | v316.47,88.1 316.47,77.18 v316.72,76.92 | v306.31,55.72 v306.31,59.02 | v304.53,52.16 304.53,51.27 307.58,48.22 307.83,48.22 v309.61,46.44 | v308.47,42.63 311.13,42.63 315.45,38.32 315.45,33.11 314.69,32.35 B01.M1
  Bottom 0.152: v167.12,42.76 169.4,45.05 170.67,45.05 174.23,48.6 178.29,48.6 v185.28,55.59 | v209.41,33.74 210.04,33.74 221.35,45.05 v221.35,45.17 | v301.48,17.23 313.93,29.68 313.93,30.82 B01.M1 | v269.61,41.74 268.84,41.74 v257.29,30.19 | v248.91,35.14 248.02,35.14 246.49,33.62 242.43,33.62 237.48,28.66 236.71,28.66 235.44,29.93 236.33,30.82 B07.M1 | v316.47,88.1 316.85,88.48 316.85,98.51 314.69,100.67 A01.M1 | v316.72,76.92 316.72,72.61 316.47,72.35 316.47,69.81 315.83,69.18 315.83,68.54 v306.31,59.02 | v306.31,55.72 306.31,53.81 304.66,52.16 v304.53,52.16 | v309.61,46.44 309.61,45.94 309.1,45.43 309.1,43.27 v308.47,42.63
I_BAC07  (via drill 0.61)
  Top 0.152: v264.78,1.99 259.32,7.46 258.05,7.46 252.97,12.54 252.72,12.54 251.45,13.81 250.81,13.81 245.98,18.63 245.98,18.89 241.54,23.33 240.9,23.33 239.38,24.85 237.22,24.85 B07.P1 | v274.94,6.44 v290.69,6.44 | v169.15,23.71 164.83,28.03 162.67,28.03 B12.N2 | v187.69,38.95 187.95,38.95 199.63,27.27 203.06,27.27 203.57,26.76 204.07,26.76 213.09,17.74 214.23,17.74 v217.16,14.82 | v231.12,26.63 232.01,25.74 232.27,25.74 v234.43,23.58 | v295.9,74 295.9,72.86 v314.82,53.94 | v306.31,37.81 306.31,36.16 313.55,28.92 313.55,26.38 313.93,26 B01.P1
  Bottom 0.152: v264.78,1.99 270.5,1.99 v274.94,6.44 | v290.69,6.44 291.7,7.46 294.5,7.46 304.28,17.23 304.79,17.23 310.75,23.2 311.9,23.2 313.55,24.85 B01.P1 | v169.15,23.71 171.31,23.71 171.56,23.96 172.71,23.96 v187.69,38.95 | v217.16,14.82 218.17,14.82 229.73,26.38 230.87,26.38 v231.12,26.63 | v234.43,23.58 234.55,23.58 235.82,24.85 B07.P1 | v295.9,74 313.93,92.04 313.93,94.32 A01.P1 | v314.82,53.94 314.82,53.3 307.96,46.44 307.96,45.81 306.82,44.67 306.82,38.32 v306.31,37.81
I_BAC08  (via drill 0.61)
  Top 0.152: v169.91,13.68 175.12,13.68 177.4,11.39 181.85,11.39 v185.02,8.22 | v217.16,35.14 218.68,35.14 220.2,33.62 v222.24,33.62 | v245.22,51.14 245.73,51.14 259.45,37.43 260.84,37.43 v263.26,35.01 | v262.62,33.49 263.13,33.49 v268.97,27.65 | v261.61,1.61 261.22,1.99 255,1.99 253.86,3.14 252.08,3.14 247,8.22 245.6,8.22 236.84,16.98 236.84,18.12 B07.S1 | v280.53,20.54 285.74,20.54 291.7,14.57 303.64,14.57 304.28,13.93 305.04,13.93 307.58,11.39 308.34,11.39 314.56,17.62 314.06,18.12 B01.S1 313.93,19.65 312.28,21.3 312.28,22.44 306.82,27.9 306.82,30.19 304.91,32.09 304.66,32.09 v289.67,47.08 289.29,47.33 288.15,48.48 287.51,48.48 287.13,48.86 v287.13,50.38 | v299.71,64.35 v300.85,65.49
  Bottom 0.152: v169.91,13.68 169.15,12.92 165.85,12.92 B12.U2 | v185.02,8.22 188.58,8.22 200.65,20.28 202.3,20.28 v217.16,35.14 | v222.24,33.62 223.38,33.62 227.19,37.43 227.57,37.43 229.6,39.46 230.11,39.46 236.08,45.43 239.51,45.43 v245.22,51.14 | v263.26,35.01 263.26,34.12 v262.62,33.49 | v268.97,27.65 280.27,38.95 281.54,38.95 v289.67,47.08 | v261.61,1.61 v280.53,20.54 | v300.85,65.49 301.74,66.38 301.74,71.72 306.94,76.92 306.94,77.56 311.39,82 312.66,82 313.17,82.51 313.17,82.89 316.47,86.19 314.69,87.97 A01.S1 | v299.71,64.35 299.71,64.1 296.02,60.41 296.02,59.78 292.09,55.84 292.09,55.33 v287.13,50.38
I_BAC09  (via drill 0.61)
  Top 0.152: v317.49,84.54 317.49,103.09 313.17,107.4 313.17,112.99 312.53,113.63 312.53,114.39 309.99,116.93 309.99,119.98 308.34,121.63 307.2,121.63 305.55,123.28 A01.D2 | v152.77,42.25 151.37,43.65 151.24,43.65 B13.H2 | v195.44,84.67 196.07,84.67 201.15,79.59 201.15,79.08 206.74,73.49 206.74,73.24 207,72.99 207,72.61 207.12,72.48 207.12,72.22 216.39,62.95 216.39,62.83 v222.24,56.98 223.38,55.84 224.65,55.84 226.3,54.19 B07.D2 | v278.5,94.7 278.12,94.7 276.59,96.23 271.89,96.23 v268.46,99.66
  Bottom 0.152: v317.49,84.54 317.87,84.16 317.87,74.38 317.23,73.75 317.23,72.61 316.85,72.22 316.85,69.68 316.22,69.05 316.22,68.41 310.25,62.45 310.25,61.81 305.17,56.73 305.17,54.57 B01.D2 | v152.77,42.25 165.09,54.57 165.34,54.57 v195.44,84.67 | v278.5,94.7 304.4,120.61 304.4,122.9 A01.D2 | v268.46,99.66 264.91,99.66 251.32,86.07 251.32,85.81 250.81,85.31 250.56,85.31 244.97,79.72 244.97,79.46 239.25,73.75 239,73.75 v222.24,56.98
I_BAC10  (via drill 0.61)
  Top 0.152: v315.83,65.11 315.83,69.3 310.63,74.51 310.37,74.51 309.99,74.89 309.74,74.89 308.98,75.65 v308.85,75.65 | v182.99,11.39 179.82,14.57 174.23,14.57 171.82,16.98 169.53,16.98 169.15,17.36 164.58,17.36 158.23,23.71 156.58,23.71 152.26,28.03 148.32,28.03 B13.N2 | v294.12,125.31 297.8,121.63 301.99,121.63 302.75,120.87 307.2,120.87 A01.E2 | v241.79,78.57 241.79,78.19 v250.18,69.81 | v235.44,55.21 v237.48,53.18
  Bottom 0.152: v315.83,65.11 315.2,64.48 313.93,64.48 312.66,63.21 312.66,59.65 312.53,59.52 312.53,58 309.74,55.21 309.74,52.79 308.34,51.4 B01.E2 | v308.85,75.65 309.1,75.65 315.45,82 315.45,84.67 317.23,86.45 317.23,112.74 308.98,120.99 308.72,120.74 A01.E2 | v182.99,11.39 184.52,11.39 188.45,15.33 188.45,18.38 193.28,23.2 195.95,23.2 196.84,24.09 203.57,24.09 210.68,31.2 210.68,32.73 226.55,48.6 227.82,48.6 229.47,50.25 B07.E2 229.86,51.4 232.27,53.81 232.27,54.32 233.16,55.21 v235.44,55.21 | v294.12,125.31 290.05,125.31 263.64,98.89 263.26,98.89 257.8,93.43 257.03,93.43 255.51,91.91 255.13,91.91 v241.79,78.57 | v250.18,69.81 250.18,65.88 v237.48,53.18
I_BAC11  (via drill 0.61)
  Top 0.152: v316.09,54.06 316.09,56.73 308.34,64.48 308.09,64.48 298.94,73.62 298.94,77.18 297.29,78.83 297.29,84.04 v290.94,90.39 | v202.68,66.64 203.19,66.64 205.98,63.84 206.61,63.84 225.54,44.92 226.55,44.92 228.2,43.27 | 228.2,43.27 229.09,43.27 229.6,43.78 B07.H2 | v303.26,43.9 307.2,43.9 B01.H2 | v266.56,7.71 263.76,7.71 228.2,43.27
  Bottom 0.152: v316.09,54.06 308.34,46.32 308.34,45.05 B01.H2 | v290.94,90.39 290.94,94.32 293.23,96.61 293.23,96.86 293.36,96.99 293.36,97.5 297.29,101.43 297.29,101.94 305.93,110.58 305.93,111.72 307.58,113.37 A01.H2 | v202.68,66.64 190.49,54.45 189.47,54.45 172.96,37.94 172.96,37.43 151.12,15.58 151.12,13.3 B13.U2 | v303.26,43.9 302.75,43.9 v266.56,7.71
I_BREAK  (via drill 0.61)
  Top 0.152: B23.V2 18.15,8.98 22.59,8.98 23.35,8.22 28.69,8.22 29.45,8.98 B22.V2 30.85,8.98 37.96,1.87 v102.47,1.87 | v135.88,13.04 136,12.92 137.4,12.92 B14.U2 138.8,12.15 143.24,12.15 147.18,8.22 149.72,8.22 151.24,6.69 151.75,6.69 v154.8,3.65 | 231.76,28.41 v233.41,30.06 | 231.76,28.41 230.36,27.01 230.36,26 B07.P2 | v228.59,18.89 v244.21,3.26 | v267.07,25.62 269.1,25.62 B04.P2 | v264.53,91.27 263.64,91.27 246.37,108.55 246.37,109.05 244.46,110.96 244.46,111.09 244.08,111.47 243.83,111.47 v241.29,114.01 | v221.09,95.08 221.09,93.05 229.47,84.67 v229.47,84.54 | v213.85,70.19 213.85,69.94 v223.51,60.29 | v212.58,49.62 212.58,46.7 217.41,41.87 218.3,41.87 231.76,28.41
  Bottom 0.152: v135.88,13.04 135.24,13.04 125.97,3.77 104.38,3.77 v102.47,1.87 | v233.41,30.06 236.59,26.89 v228.59,18.89 | v244.21,3.26 258.18,17.23 258.68,17.23 v267.07,25.62 | v264.53,91.27 267.96,94.7 269.1,94.7 A04.P2 | v241.29,114.01 240.4,114.01 235.57,109.18 235.19,109.18 v221.09,95.08 | v229.47,84.54 228.84,84.54 228.08,83.78 228.08,83.4 221.35,76.67 220.71,76.67 220.33,76.29 219.95,76.29 v213.85,70.19 | v223.51,60.29 223.51,59.91 214.36,50.76 213.73,50.76 v212.58,49.62 212.2,49.75 197.6,35.14 197.6,34.89 197.22,34.51 197.22,33.11 196.84,32.73 196.45,32.73 167.37,3.65 v154.8,3.65
I_BRKRQ  (via drill 0.61)
  Top 0.152: v142.35,2.12 132.07,2.12 131.56,2.63 124.7,2.63 120,7.33 111.75,7.33 110.86,8.22 101.2,8.22 82.92,26.51 82.92,27.65 B18.N2 | v148.7,3.14 149.97,3.14 150.23,2.88 160.01,2.88 160.39,2.5 161.53,2.5 163.18,0.85 191.12,0.85 192.64,2.38 v190.23,4.79 | v227.95,20.03 230.62,20.03 237.6,13.04 237.6,12.79 v238.11,12.28 | v278.75,100.42 271.76,107.4 270.62,107.4 A04.K2 | v272.91,93.56 274.18,92.29 274.18,87.34 274.81,86.7 274.81,85.05 v275.83,84.04 | v269.35,77.3 268.08,76.03 v269.61,74.51 | v235.95,40.86 236.08,40.86 246.24,30.7 246.62,30.7 v255.13,22.19
  Bottom 0.152: v142.35,2.12 144.89,2.12 145.15,2.38 145.91,2.38 146.29,2.76 148.32,2.76 v148.7,3.14 | v190.23,4.79 185.53,4.79 185.15,4.41 185.15,3.65 185.53,3.26 190.74,3.26 190.99,3.52 207.25,3.52 208.65,4.92 211.44,4.92 218.55,12.03 218.55,12.28 220.2,13.93 221.85,13.93 v227.95,20.03 | v238.11,12.28 241.03,12.28 242.43,13.68 246.62,13.68 v255.13,22.19 265.92,32.98 266.43,32.98 267.83,34.38 267.83,35.52 269.48,37.17 B04.K2 | v278.75,100.42 278.75,99.4 v272.91,93.56 | v275.83,84.04 275.83,83.78 v269.35,77.3 | v269.61,74.51 269.61,73.88 236.97,41.24 236.33,41.24 v235.95,40.86
I_CAINCR  (via drill 0.61)
  Top 0.152: v112,6.57 110.73,7.84 101.08,7.84 71.23,37.68 71.23,38.19 70.22,39.2 70.22,40.35 B19.J2 | v130.16,13.17 130.16,12.54 134.48,8.22 139.05,8.22 142.61,4.66 145.27,4.66 145.65,4.28 146.42,4.28 148.32,2.38 160.01,2.38 v161.15,1.23 | v201.03,19.52 202.8,17.74 205.85,17.74 | 205.85,17.74 210.68,17.74 v223.12,5.3 | v253.73,102.96 254.87,101.82 A05.M2 | v227.19,76.29 227.19,72.99 v227.57,72.61 | v192.14,32.09 192.14,31.46 205.85,17.74
  Bottom 0.152: v112,6.57 123.56,6.57 v130.16,13.17 | v161.15,1.23 162.8,1.23 163.31,0.72 180.96,0.72 185.41,5.17 186.68,5.17 v201.03,19.52 | v223.12,5.3 227.19,5.3 234.3,12.41 234.81,12.41 236.08,13.68 238.36,13.68 238.87,14.19 239.76,14.19 253.48,27.9 253.48,29.05 255.26,30.82 B05.M2 | v253.73,102.96 253.73,102.7 251.19,100.16 249.54,100.16 236.84,87.46 236.84,85.94 v227.19,76.29 | v227.57,72.61 227.57,70.95 218.43,61.81 218.43,60.03 211.69,53.3 211.69,51.27 197.22,36.79 196.71,36.79 195.69,35.78 195.69,35.27 194.04,33.62 193.66,33.62 v192.14,32.09
I_DATA00  (via drill 0.61)
  Top 0.152: v54.34,40.73 45.58,49.49 32.88,49.49 30.46,51.91 30.46,53.05 B22.D2 | v143.37,125.56 155.18,125.56 158.61,122.14 160.77,122.14 v166.48,116.42 | v175.63,122.39 180.2,122.39 183.5,119.09 183.63,119.09 188.96,113.75 188.96,113.63 199.5,103.09 200.01,103.09 202.8,100.29 v205.22,100.29 | v246.62,137.63 247.13,137.63 v255,129.76 | v244.08,46.7 243.95,46.7 v241.79,48.86 | v234.3,44.79 231.76,44.79 227.57,48.98 227.06,48.98 223.76,52.29 v223.63,52.29 | v228.59,58.13 228.59,60.16 227.44,61.3 226.55,61.3 v225.66,62.19 | v233.92,71.97 233.28,71.97 227.82,77.43 227.19,77.43 213.22,91.4 213.22,91.91 210.93,94.2 210.17,94.2 209.54,93.56 v204.71,98.39
  Bottom 0.152: v54.34,40.73 54.34,41.36 99.3,86.32 100.82,86.32 104.38,89.88 105.01,89.88 109.59,94.45 110.47,94.45 140.83,124.8 142.61,124.8 v143.37,125.56 | v166.48,116.42 166.48,117.06 167.88,118.45 170.55,118.45 171.31,119.21 172.45,119.21 v175.63,122.39 | v246.62,137.63 242.56,137.63 242.17,137.25 242.17,136.61 228.59,123.02 228.59,122.39 215.76,109.56 214.49,109.56 v205.22,100.29 204.96,99.91 204.71,99.66 v204.71,98.39 | v255,129.76 258.05,129.76 A05.B1 | v244.08,46.7 244.97,47.59 244.97,47.97 246.49,49.49 249.67,49.49 258.43,58.26 258.43,59.4 B05.B1 | v241.79,48.86 238.36,48.86 v234.3,44.79 | v223.63,52.29 223.89,52.29 227.57,55.97 227.57,57.11 v228.59,58.13 | v225.66,62.19 225.66,63.72 v233.92,71.97
I_DATA01  (via drill 0.61)
  Top 0.152: v22.34,56.48 23.86,54.95 24.24,54.95 29.83,49.37 29.83,48.22 B22.F2 | v104.89,134.84 160.77,134.84 175.75,119.85 176.01,119.85 186.55,109.31 186.55,109.05 v198.23,97.37 211.69,83.91 211.95,83.91 219.57,76.29 221.35,76.29 224.27,73.37 224.27,73.11 233.03,64.35 233.28,64.35 244.59,53.05 244.59,51.65 244.08,51.14 244.84,50.38 245.35,50.38 v251.06,44.67 | v256.91,122.26 256.91,122.39 251.45,127.85 250.81,127.85 242.05,136.61 241.79,136.61 v241.41,137
  Bottom 0.152: v22.34,56.48 22.34,62.06 57.39,97.12 57.52,97.12 61.45,101.05 61.45,110.45 69.45,118.45 82.15,118.45 85.33,121.63 91.68,121.63 v104.89,134.84 | v251.06,44.67 251.19,44.67 256.65,50.13 256.65,51.27 258.43,53.05 B05.D1 | v256.91,122.26 257.92,123.28 258.05,123.28 A05.D1 | v241.41,137 241.41,136.36 228.2,123.15 228.2,122.52 226.55,120.87 225.79,120.87 221.09,116.17 217.92,116.17 213.85,112.1 213.22,112.1 210.17,109.05 209.28,109.05 198.87,98.64 198.87,98.01 v198.23,97.37
I_DATA02  (via drill 0.61)
  Top 0.152: v45.96,42.25 46.47,42.25 v55.1,33.62 | v171.69,118.45 176.9,118.45 186.17,109.18 186.17,108.29 v193.15,101.31 v213.6,80.86 | v215.63,82.51 224.65,73.49 224.65,73.24 233.16,64.73 233.54,64.73 239.25,59.02 242.43,59.02 250.3,51.14 250.3,47.84 v255.51,42.63 | v241.41,139.53 243.7,137.25 243.7,137.12 259.95,120.87 261.22,120.87 A05.E1 | v236.71,134.84 234.3,134.84 v231.12,138.01
  Bottom 0.152: v45.96,42.25 36.05,42.25 35.29,41.49 30.85,41.49 B22.J2 | v55.1,33.62 72.5,33.62 113.78,74.89 114.03,74.89 114.28,75.15 114.67,75.15 114.79,75.27 115.3,75.27 115.43,75.4 116.83,75.4 150.35,108.93 158.35,108.93 164.7,115.28 168.51,115.28 v171.69,118.45 | v213.6,80.86 213.98,80.86 v215.63,82.51 | v255.51,42.63 259.83,46.95 259.83,48.09 261.61,49.87 B05.E1 | v236.71,134.84 v241.41,139.53 | v231.12,138.01 231.12,137.38 230.36,136.61 229.73,136.61 228.46,135.34 227.57,135.34 221.09,128.87 220.84,128.87 218.81,126.83 218.81,126.58 209.66,117.44 209.28,117.44 v193.15,101.31
I_DATA03  (via drill 0.61)
  Top 0.152: v86.85,106.39 94.35,113.88 94.35,116.67 94.09,116.93 94.09,120.99 104.76,131.66 103.62,132.8 103.62,135.6 108.19,140.17 153.53,140.17 154.8,138.9 170.04,138.9 183.63,125.31 184.14,125.31 186.93,122.52 189.34,122.52 189.98,121.88 190.61,121.88 v202.8,109.69 | v232.65,138.39 234.43,138.39 v260.34,112.48 | v252.84,36.41 252.33,36.41 249.67,39.08 246.37,39.08 244.21,41.24 242.94,41.24 236.08,48.09 236.08,48.98 235.06,50 235.06,50.51 220.33,65.24 220.33,65.88 212.96,73.24 212.96,75.02 v192.26,95.72
  Bottom 0.152: v86.85,106.39 54.09,73.62 54.09,69.81 33.01,48.73 33.01,48.09 27.29,42.38 29.83,39.84 29.83,35.52 B22.L2 | v232.65,138.39 217.03,122.77 216.65,122.77 210.42,116.55 210.04,116.55 206.87,113.37 206.87,112.74 206.23,112.1 205.98,112.1 203.57,109.69 v202.8,109.69 202.55,109.31 192.26,99.02 v192.26,95.72 | v260.34,112.48 260.34,112.61 261.35,113.63 A05.H1 | v252.84,36.41 254.49,38.06 254.49,38.44 259.95,43.9 261.22,43.9 B05.H1
I_DATA04  (via drill 0.61)
  Top 0.152: v75.17,13.04 71.11,17.11 57.77,17.11 57.13,17.74 45.58,17.74 35.29,28.03 30.85,28.03 B22.N2 | v114.54,43.9 117.08,43.9 v121.02,39.97 | v226.05,138.39 227.32,138.39 v256.27,109.44 | v263,42.63 264.02,42.63 264.91,41.74 264.91,41.36 266.3,39.97 269.61,39.97 v273.16,36.41 | v287.89,49.24 289.04,49.24 290.81,47.46 290.81,47.21 298.05,39.97 298.69,39.97 300.09,38.57 300.09,37.94 v302.88,35.14 | v317.74,63.08 317.74,67.27 317.1,67.91 317.1,68.54 309.23,76.42 306.06,76.42 298.82,83.65 298.31,83.65 295.51,86.45 295.51,86.96 288.15,94.32 285.99,94.32 279.13,101.18 278.5,101.18 271.89,107.78 271.51,107.78 268.59,110.71 268.59,111.34 v265.42,114.52
  Bottom 0.152: v75.17,13.04 78.34,13.04 78.98,13.68 84.31,13.68 v114.54,43.9 | v121.02,39.97 125.84,39.97 150.35,64.48 150.73,64.48 157.47,71.21 157.72,71.21 209.92,123.41 210.81,123.41 211.19,123.79 211.44,123.79 v226.05,138.39 | v256.27,109.44 256.91,109.44 258.05,110.58 A05.J1 259.45,111.34 259.83,111.72 260.72,111.72 261.99,112.99 262.37,112.99 263.89,114.52 v265.42,114.52 | v263,42.63 262.62,42.25 261.86,42.25 261.1,41.49 259.45,41.49 B05.J1 | v273.16,36.41 275.83,39.08 276.34,39.08 277.86,40.6 277.86,41.87 282.05,46.06 282.81,46.06 285.35,48.6 287.26,48.6 v287.89,49.24 | v302.88,35.14 303.64,35.14 304.4,35.9 306.94,35.9 307.07,36.03 307.58,36.03 309.1,37.55 309.1,41.62 311.39,43.9 311.39,46.19 315.45,50.25 315.45,52.29 316.85,53.68 316.85,57.49 317.23,57.87 317.23,61.3 316.6,61.94 v317.74,63.08
I_DATA05  (via drill 0.61)
  Top 0.152: v130.16,41.74 132.19,41.74 154.16,19.77 | 154.16,19.77 156.58,17.36 158.23,17.36 161.4,14.19 165.47,14.19 167.24,12.41 167.75,12.41 172.71,7.46 180.2,7.46 v184.77,2.88 | v220.58,13.17 221.6,13.17 v227.57,7.2 | v258.3,107.4 258.43,107.28 258.43,105.37 A05.L1 | v260.34,109.82 260.34,111.34 259.57,112.1 259.57,112.74 242.94,129.38 241.92,129.38 v239.25,132.04 | v225.92,115.66 225.92,115.53 v234.81,106.64 | v215.89,86.07 215.38,86.07 v212.2,89.24 | v147.05,24.35 151.62,19.77 154.16,19.77
  Bottom 0.152: v130.16,41.74 129.65,41.24 129.65,40.6 129.02,39.97 127.24,39.97 126.73,39.46 124.83,39.46 122.03,36.66 121.52,36.66 114.41,29.55 109.08,29.55 105.9,26.38 104.38,26.38 94.85,16.85 88.5,16.85 81.39,9.74 81.39,9.61 74.66,2.88 66.66,10.88 63.48,10.88 57.13,17.23 39.74,17.23 35.29,21.68 30.85,21.68 B22.R2 | v184.77,2.88 204.84,2.88 205.09,3.14 209.79,3.14 210.55,3.9 211.31,3.9 v220.58,13.17 | v227.57,7.2 228.59,7.2 234.17,12.79 234.68,12.79 235.95,14.06 236.46,14.06 255.13,32.73 256.4,32.73 258.05,34.38 B05.L1 | v258.3,107.4 258.3,107.78 v260.34,109.82 | v239.25,132.04 233.92,126.71 233.92,125.82 232.27,124.17 232.27,123.91 231.12,122.77 230.87,122.77 225.92,117.82 v225.92,115.66 | v234.81,106.64 234.81,104.48 233.79,103.47 233.41,103.47 232.27,102.32 232.27,101.94 230.62,100.29 230.24,100.29 229.86,99.91 229.86,99.53 227.44,97.12 227.06,97.12 225.41,95.47 225.41,95.08 217.92,87.59 217.41,87.59 v215.89,86.07 | v212.2,89.24 179.94,56.98 179.94,56.73 160.89,37.68 160.39,37.68 v147.05,24.35
I_DATA06  (via drill 0.61)
  Top 0.152: v277.61,47.33 277.61,46.95 285.23,39.33 285.74,39.33 v288.78,36.28 | v304.79,57.49 304.79,58.13 298.82,64.1 298.82,64.22 296.53,66.51 296.4,66.51 289.29,73.62 289.29,74.13 284.59,78.83 284.59,81.88 282.94,83.53 281.67,83.53 281.16,84.04 281.16,86.45 270.11,97.5 269.48,97.5 v263.76,103.21 | v132.45,1.23 131.43,2.25 124.57,2.25 123.81,3.01 103.11,3.01 100.19,5.93 95.49,5.93 95.36,6.06 94.22,6.06 92.82,7.46 90.54,7.46 90.16,7.84 88.38,7.84 85.58,10.63 85.08,10.63 78.34,17.36 72.5,17.36 72.12,17.74 59.93,17.74 53.58,24.09 51.93,24.09 45.96,30.06 45.45,30.06 38.72,36.79 32.88,36.79 17.77,51.91 17.77,53.05 B23.D2 | v185.66,5.93 192.52,5.93 193.66,4.79 203.57,4.79 v203.95,4.41 | v213.22,7.84 217.28,7.84 218.43,6.69 218.93,6.69 220.71,4.92 221.85,4.92 222.62,4.15 230.62,4.15 231,3.77 231.76,3.77 232.52,4.53 231.76,5.3 227.19,5.3 v225.28,7.2 | v241.29,22.06 241.67,22.06 v245.22,18.5
  Bottom 0.152: v277.61,47.33 262.49,32.22 262.49,32.09 B05.M1 261.22,31.2 259.57,29.55 258.3,29.55 247.25,18.5 v245.22,18.5 | v288.78,36.28 302.75,50.25 302.75,55.46 v304.79,57.49 | v263.76,103.21 262.49,101.94 A05.M1 | v132.45,1.23 148.19,1.23 148.7,0.72 159.5,0.72 160.77,1.99 181.72,1.99 v185.66,5.93 | v203.95,4.41 207.63,4.41 208.52,5.3 210.68,5.3 v213.22,7.84 | v225.28,7.2 225.28,9.23 226.55,10.5 229.73,10.5 v241.29,22.06
I_DATA07  (via drill 0.61)
  Top 0.152: v268.08,32.22 267.45,32.22 266.69,32.98 264.27,32.98 263,34.25 260.84,34.25 259.19,35.9 256.02,35.9 251.32,40.6 251.32,40.86 250.43,41.74 250.18,41.74 248.14,43.78 248.14,44.03 245.86,46.32 245.6,46.32 229.09,62.83 229.09,63.08 224.78,67.4 v224.78,69.68 | v237.48,92.54 235.44,94.58 235.44,96.74 v235.19,96.99 | v247.13,108.93 247.13,108.29 258.3,97.12 259.57,97.12 261.22,95.47 A05.P1 | v98.54,115.79 110.73,115.79 110.86,115.66 114.92,115.66 118.73,111.85 119.49,111.85 140.07,91.27 140.07,91.02 153.4,77.69 154.42,77.69 154.93,77.18 155.18,77.18 167.24,65.11 168.13,65.11 177.4,55.84 182.1,55.84 v191.88,46.06
  Bottom 0.152: v268.08,32.22 262.24,26.38 262.24,26 B05.P1 | v237.48,92.54 236.08,91.15 235.7,91.15 234.43,89.88 234.43,85.05 233.79,84.42 233.79,83.53 227.32,77.05 226.81,77.05 224.78,75.02 v224.78,69.68 224.52,69.3 221.6,66.38 220.71,66.38 218.81,64.48 217.03,64.48 210.68,58.13 209.15,58.13 202.42,51.4 200.14,51.4 197.22,48.48 196.07,48.48 195.69,48.09 195.69,47.97 193.79,46.06 v191.88,46.06 | v235.19,96.99 v247.13,108.93 | v98.54,115.79 94.85,112.1 88.5,112.1 87.74,111.34 86.73,111.34 50.78,75.4 45.58,75.4 45.45,75.27 44.94,75.27 44.82,75.15 44.44,75.15 44.18,74.89 43.93,74.89 39.74,70.7 39.74,68.67 37.2,66.13 37.2,64.1 20.94,47.84 18.15,47.84 B23.F2
I_DATA08  (via drill 0.61)
  Top 0.152: v60.82,10.5 53.96,17.36 45.45,17.36 35.55,27.27 29.7,27.27 17.77,39.2 17.77,40.35 B23.J2 | v145.78,21.81 146.29,21.81 150.35,17.74 155.69,17.74 156.45,16.98 158.1,16.98 v163.69,11.39 | v231.12,72.22 231.38,72.22 v240.78,62.83 | v250.81,71.72 250.81,72.48 v247.64,75.65 | v241.67,39.46 241.79,39.33 241.79,37.43 247.38,31.84 247.38,31.33 259.06,19.65 259.7,19.65 260.08,19.27 261.22,19.27 B05.S1 | v244.21,42 244.21,44.54 236.97,51.78 236.59,51.78 v236.08,52.29
  Bottom 0.152: v60.82,10.5 66.53,10.5 75.93,1.1 125.08,1.1 v145.78,21.81 | v163.69,11.39 168.77,11.39 174.23,16.85 178.04,16.85 192.9,31.71 192.9,31.97 196.07,35.14 196.07,35.65 196.45,36.03 196.96,36.03 212.08,51.14 212.08,53.18 219.95,61.05 219.95,61.56 223.25,64.86 223.76,64.86 v231.12,72.22 | v240.78,62.83 242.43,64.48 243.57,64.48 244.33,65.24 | 244.33,65.24 v250.81,71.72 | v247.64,75.65 247.64,76.03 251.95,80.35 253.73,80.35 253.86,80.48 255.26,80.48 259.83,85.05 259.83,86.19 261.61,87.97 A05.S1 | v244.21,42 v241.67,39.46 | v236.08,52.29 236.08,52.92 244.33,61.18 244.33,65.24
I_DATA09  (via drill 0.61)
  Top 0.152: v160.77,33.62 160.77,38.19 v160.51,38.44 | v226.3,108.04 227.19,108.04 v228.59,106.64 | v249.29,125.18 250.56,125.18 251.7,124.04 A05.D2 | v247.64,50.76 247.51,50.76 244.97,53.3 v244.97,55.08 | v246.24,57.11 246.24,57.75 242.81,61.18 242.81,61.81 241.54,63.08 241.54,63.21 227.7,77.05 227.06,77.05 210.68,93.43 v210.55,93.43
  Bottom 0.152: v160.77,33.62 127.87,0.72 62.6,0.72 46.47,16.85 23.35,16.85 22.21,15.71 16.37,21.55 16.37,28.92 17.13,29.68 17.13,34 B23.L2 | v160.51,38.44 160.77,38.44 201.15,78.83 201.15,80.23 201.53,80.61 201.53,83.27 201.92,83.65 201.92,85.94 202.8,86.83 204.46,86.83 210.81,93.18 | 210.81,93.18 215.38,97.75 215.38,98.26 215.76,98.64 217.41,98.64 224.52,105.75 224.52,106.26 v226.3,108.04 | v228.59,106.64 230.74,106.64 v249.29,125.18 | v247.64,50.76 250.3,53.43 251.7,53.43 B05.D2 | v244.97,55.08 244.97,55.84 v246.24,57.11 | 210.81,93.18 v210.55,93.43
I_DATA10  (via drill 0.61)
  Top 0.152: v78.85,8.22 63.1,8.22 61.58,9.74 60.44,9.74 53.83,16.35 50.78,16.35 50.15,16.98 45.32,16.98 44.56,17.74 32.88,17.74 22.59,28.03 18.15,28.03 B23.N2 | v220.33,139.15 222.62,139.15 v226.05,135.72 | v229.98,137.38 229.98,136.87 232.9,133.95 233.41,133.95 v249.41,117.94 | v243.83,40.48 243.19,40.48 235.7,47.97 235.7,48.6 v234.3,50 | v232.27,49.24 229.35,49.24 227.19,51.4 226.68,51.4 v212.84,65.24 | v213.73,73.75 213.73,76.67 v185.66,104.74
  Bottom 0.152: v78.85,8.22 79.36,8.22 105.01,33.87 106.54,33.87 112.13,39.46 112.63,39.46 153.53,80.35 154.54,80.35 156.58,78.32 155.81,77.56 155.31,77.56 153.91,76.16 153.91,75.4 154.67,74.64 155.43,75.4 155.43,76.03 172.58,93.18 174.36,93.18 185.79,104.61 | 185.79,104.61 v220.33,139.15 | v226.05,135.72 228.33,135.72 v229.98,137.38 | v249.41,117.94 249.54,117.94 250.68,119.09 253.86,119.09 254.87,120.1 A05.E2 | v243.83,40.48 246.87,43.52 246.87,44.41 252.72,50.25 254.87,50.25 B05.E2 | v234.3,50 233.03,50 v232.27,49.24 | v212.84,65.24 212.84,72.86 v213.73,73.75 | 185.79,104.61 v185.66,104.74
I_DATA11  (via drill 0.61)
  Top 0.152: v111.11,97.88 112.51,97.88 v148.7,61.68 | v227.95,138.9 227.95,138.27 249.03,117.18 249.79,117.18 v253.73,113.25 | v259.83,38.19 256.27,41.74 256.27,43.02 255.89,43.4 255.89,43.52 B05.H2 | v254.37,28.79 254.11,28.79 v249.41,33.49 | v244.84,30.82 244.84,31.2 236.97,39.08 236.59,39.08 235.19,40.48 235.19,40.86 227.44,48.6 224.78,48.6 v224.65,48.73 | v222.62,46.7 222.62,47.08 214.74,54.95 213.6,54.95 203.69,64.86 203.31,64.86 v179.44,88.73
  Bottom 0.152: v111.11,97.88 104.38,91.15 103.11,91.15 101.97,90 96,90 29.2,23.2 23.35,23.2 22.59,22.44 18.15,22.44 B23.R2 | v148.7,61.68 152.39,61.68 167.62,76.92 168.01,76.92 176.64,85.56 176.64,85.94 v179.44,88.73 182.1,91.4 182.1,95.08 210.04,123.02 210.93,123.02 211.31,123.41 211.57,123.41 213.98,125.82 214.87,125.82 v227.95,138.9 | v253.73,113.25 254.37,113.25 254.87,113.75 A05.H2 | v259.83,38.19 259.83,34.25 v254.37,28.79 | v249.41,33.49 247.51,33.49 v244.84,30.82 | v222.62,46.7 v224.65,48.73
I_DATAIN  (via drill 0.61)
  Top 0.152: v103.62,4.15 86.09,21.68 83.3,21.68 B18.R2 | v163.43,38.32 163.43,38.06 164.7,36.79 168.13,36.79 175.88,29.05 176.39,29.05 178.8,26.63 179.18,26.63 189.6,16.22 191.63,16.22 199.63,8.22 207,8.22 212.08,3.14 231.12,3.14 231.25,3.01 234.94,3.01 v236.71,1.23 | v244.46,5.8 244.59,5.8 v247.38,3.01 | v263.13,16.85 263.13,19.27 v261.35,21.04 | v287.26,120.61 291.32,116.55 291.32,114.26 294.24,111.34 294.24,110.32 296.4,108.17 296.4,104.99 300.85,100.55 300.85,99.4 v303.13,97.12 | v299.2,89.75 299.2,88.23 v315.2,72.22
  Bottom 0.152: v103.62,4.15 125.84,4.15 144.51,22.82 146.29,22.82 147.05,23.58 147.56,23.58 156.7,32.73 157.85,32.73 v163.43,38.32 | v236.71,1.23 239.89,1.23 v244.46,5.8 | v247.38,3.01 248.65,1.74 249.41,2.5 249.41,3.14 v263.13,16.85 263.51,16.6 288.91,42 288.91,42.76 314.31,68.16 314.31,69.3 315.2,70.19 v315.2,72.22 | v261.35,21.04 261.35,21.17 263,22.82 263,26.25 266.3,29.55 266.69,29.55 269.1,31.97 B04.M2 | v287.26,120.61 271.51,104.86 271.51,104.48 270.24,103.21 270.24,102.2 A04.M2 | v303.13,97.12 303.13,93.69 v299.2,89.75
I_EXTA0  (via drill 0.61)
  Top 0.152: v223.76,41.49 233.79,31.46 233.79,31.08 235.44,29.43 235.44,24.73 250.43,9.74 251.7,9.74 B05.V2 | v222.24,40.73 222.24,41.11 217.92,45.43 217.54,45.43 v217.03,45.94 | v218.17,47.21 218.17,47.33 v213.98,51.52 | v243.95,86.19 243.95,86.07 248.78,81.24 250.05,81.24 251.7,79.59 A05.V2 | v75.04,23.2 79.87,23.2 v96,7.07 | v167.24,63.84 167.24,63.21 181.09,49.37 181.47,49.37 188.58,42.25 189.85,42.25 v196.84,35.27
  Bottom 0.152: v223.76,41.49 223,41.49 v222.24,40.73 | v217.03,45.94 217.03,46.06 v218.17,47.21 | v243.95,86.19 231.89,74.13 231.89,70.7 224.9,63.72 224.9,62.83 222.11,60.03 222.11,59.52 214.11,51.52 v213.98,51.52 213.6,51.78 197.09,35.27 v196.84,35.27 | v75.04,23.2 74.28,22.44 70.6,22.44 B19.R2 | v96,7.07 108.82,7.07 122.03,20.28 123.68,20.28 v167.24,63.84
I_EXTA1  (via drill 0.61)
  Top 0.152: v121.27,4.92 119.75,3.39 103.24,3.39 100.31,6.31 95.62,6.31 95.49,6.44 94.35,6.44 79.87,20.92 75.8,20.92 70.22,26.51 70.22,27.65 B19.N2 | v149.97,28.79 152,28.79 156.7,24.09 158.35,24.09 164.7,17.74 v169.91,17.74 | v221.09,65.62 225.16,65.62 v230.62,60.16 230.87,59.78 234.68,55.97 234.68,54.83 v248.02,41.49 | v248.91,75.65 248.91,77.05 v247.64,78.32 | v237.09,29.43 245.6,20.92 245.73,20.92 246.87,19.77 246.87,19.65 250.43,16.09 251.7,16.09 B05.T2
  Bottom 0.152: v121.27,4.92 126.1,4.92 v149.97,28.79 | v169.91,17.74 171.82,17.74 200.52,46.44 202.17,46.44 218.55,62.83 218.55,63.08 v221.09,65.62 | v230.62,60.16 231.25,60.16 235.95,64.86 238.11,64.86 v248.91,75.65 | v247.64,78.32 247.64,79.46 248.78,80.61 249.03,80.61 250.3,81.88 250.3,83.02 252.08,84.8 A05.T2 | v237.09,29.43 237.6,29.43 240.52,32.35 240.52,34 v248.02,41.49
I_EXTA2  (via drill 0.61)