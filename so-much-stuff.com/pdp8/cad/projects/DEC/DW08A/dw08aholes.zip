# EAGLE board dw08aholes (EAGLE 4.11), part 4 of 4
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
O_MB07  (via drill 0.61) (continued)
  Top 0.152: v140.32,131.92 158.48,131.92 164.7,125.69 168.77,125.69 v172.32,122.14
  Bottom 0.152: v140.32,131.92 116.57,108.17 113.4,108.17 A16.K2 | v172.32,122.14 172.71,122.14 173.85,123.28 A11.D2
O_MB07\  (via drill 0.61)
  Top 0.152: v132.95,127.98 138.54,127.98 141.72,124.8 148.07,124.8 159.5,113.37 159.75,113.37 160.01,113.12 161.78,113.12 176.64,98.26 179.44,98.26 187.56,90.13 188.07,90.13 189.09,89.12 189.72,89.12 A10.S2
  Bottom 0.152: v132.95,127.98 128.13,127.98 116.32,116.17 115.05,116.17 113.4,114.52 A16.H2
O_MB08  (via drill 0.61)
  Top 0.152: v152.39,63.46 152.26,63.46 151.24,64.48 148.19,64.48 143.75,68.92 142.61,68.92 v115.3,96.23
  Bottom 0.152: v152.39,63.46 157.21,68.29 158.23,68.29 168.01,78.07 168.64,78.07 176.26,85.69 176.26,86.07 177.4,87.21 177.4,87.97 A11.S2 | v115.3,96.23 114.16,96.23 113.4,95.47 A16.P2
O_MB08\  (via drill 0.61)
  Top 0.152: v145.53,131.15 151.24,131.15 156.7,125.69 158.35,125.69 174.23,109.82 175.37,109.82 177.02,108.17 A11.K2
  Bottom 0.152: v145.53,131.15 116.19,101.82 113.4,101.82 A16.M2
O_MB09  (via drill 0.61)
  Top 0.152: v118.86,85.69 116.19,88.35 113.4,88.35 A16.S2
  Bottom 0.152: v118.86,85.69 119.75,85.69 131.05,96.99 131.56,96.99 134.35,99.78 134.86,99.78 144,108.93 147.31,108.93 161.4,123.02 A12.D2
O_MB10  (via drill 0.61)
  Top 0.152: v126.98,71.34 113.14,85.18 110.22,85.18 A16.T2
  Bottom 0.152: v126.98,71.34 129.91,71.34 161.91,103.34 162.16,103.34 163.05,104.23 163.05,105.37 164.7,107.02 A12.K2
O_MB11  (via drill 0.61)
  Top 0.152: v144.38,105.24 162.93,86.7 v163.05,86.7
  Bottom 0.152: v144.38,105.24 138.54,99.4 134.48,99.4 131.68,96.61 131.18,96.61 114.16,79.59 110.22,79.59 A16.V2 | v163.05,86.7 163.05,86.83 164.45,88.23 A12.S2
O_MBINCR  (via drill 0.61)
  Top 0.152: v47.99,76.16 52.56,71.59 52.56,69.81 59.17,63.21 59.17,62.95 71.11,51.02 72.25,51.02 B19.E2
  Bottom 0.152: v47.99,76.16 47.99,76.29 56.63,84.92 A20.T2
O_RUN  (via drill 0.61)
  Top 0.152: v90.54,92.16 90.54,91.78 102.73,79.59 102.73,78.07 118.6,62.19 124.95,62.19 131.3,55.84 132.57,55.84 134.22,54.19 B14.D2
  Bottom 0.152: v90.54,92.16 90.54,92.04 87.61,89.12 86.47,89.12 A18.S2
O_SKIP  (via drill 0.61)
  Top 0.152: v93.58,71.59 93.58,77.69 v81.27,90
  Bottom 0.152: v93.58,71.59 92.69,70.7 92.69,69.05 90.03,66.38 90.03,59.78 86.09,55.84 86.09,51.4 B18.E2 | v81.27,90 81.27,99.66 87.61,106.01 87.61,106.77 86.47,107.91 A18.K2
O_TS1  (via drill 0.61)
  Top 0.152: v141.97,90.26 141.97,89.62 153.53,78.07 154.54,78.07 155.05,77.56 156.2,77.56 165.97,67.78 166.23,67.78 166.48,67.53 166.74,67.53 166.86,67.4 167.12,67.4 167.24,67.27 167.75,67.27 167.88,67.14 171.31,67.14 188.07,50.38 189.22,50.38 199.63,39.97 200.77,39.97 202.42,38.32 B09.K2
  Bottom 0.152: v141.97,90.26 140.45,88.73 139.69,88.73 136.89,85.94 135.62,85.94 A14.T2
O_TS3  (via drill 0.61)
  Top 0.152: v156.07,73.24 142.1,87.21 139.69,87.21 138.67,88.23 A14.S2 | v164.83,80.73 169.02,80.73 182.99,66.76 185.53,66.76 196.45,55.84 197.6,55.84 199.25,54.19 B09.D2
  Bottom 0.152: v156.07,73.24 157.47,73.24 164.83,80.61 v164.83,80.73
O_TT_INST
  Top 0.152: A18.T2 82.92,84.8 82.92,80.35 105.9,57.37 105.9,55.33 110.6,50.63 111.11,50.63 112.25,49.49 114.41,49.49 114.79,49.11 128.51,49.11 136,41.62 136,40.48 137.78,38.7 B14.K2
O_WCOV  (via drill 0.61)
  Top 0.152: v106.67,26 102.22,30.44 98.03,30.44 90.03,38.44 90.03,41.49 75.68,55.84 72.63,55.84 70.09,58.38 69.33,58.38 65.26,62.45 64.5,62.45 63.23,63.72 63.23,64.1 50.28,77.05 50.28,79.72 48.5,81.5 48.5,82 35.8,94.7 34.02,94.7 A22.P2
  Bottom 0.152: v106.67,26 111.87,26 121.78,35.9 123.05,35.9 124.7,37.55 B15.K2
VCC  (via drill 0.61)
  Top 0.381: 213.47,135.34 213.47,135.85 217.66,140.04 223,140.04 229.47,133.57 A07.A2 | 213.47,135.34 213.47,135.09 215,133.57 216.77,133.57 A08.A2 | v236.97,138.77 242.17,133.57 A06.A2 | 189.6,135.47 189.6,136.49 192.26,139.15 196.84,139.15 202.42,133.57 A09.A2 | 189.6,135.47 189.6,134.46 190.1,133.95 A10.A2 | 189.6,135.47 v186.42,135.47 | v205.73,135.34 213.47,135.34 | v236.33,69.56 242.17,63.72 B06.A2 | v183.37,68.8 184.64,68.8 189.72,63.72 B10.A2 | v197.6,68.54 202.42,63.72 B09.A2 | v225.54,67.78 229.47,63.84 229.47,63.72 B07.A2 | v219.19,61.43 217.92,62.7 B08.A2 216.77,63.72 v210.42,70.07 210.17,70.45 210.04,70.57 210.04,71.84 v177.66,104.23 | v117.08,64.99 123.43,64.99 124.7,63.72 B15.A2 | v135.24,65.62 137.15,63.72 137.4,63.72 B14.A2 | v144.64,66.89 147.81,63.72 150.1,63.72 B13.A2 | v157.85,70.45 164.45,63.84 B12.A2 165.72,62.83 v166.99,61.56 | v26.91,68.29 28.05,68.29 32.62,63.72 B22.A2 | v38.72,68.8 43.8,63.72 45.32,63.72 B21.A2 | v70.34,65.49 70.47,65.49 72.25,63.72 B19.A2 | v78.85,67.53 82.66,63.72 84.95,63.72 B18.A2 | v91.93,69.43 97.65,63.72 B17.A2 | v53.33,70.19 59.67,63.84 B20.A2 | v105.9,68.67 109.84,64.73 110.35,64.73 111.36,63.72 112,63.72 B16.A2 | v172.58,67.02 175.88,63.72 177.02,63.72 B11.A2
  Bottom 0.381: v236.97,138.77 236.08,138.77 230.87,133.57 A07.A2 | 179.82,135.22 178.93,136.11 178.17,136.11 176.52,134.46 171.05,134.46 170.17,133.57 165.85,133.57 A12.A2 | 179.82,135.22 A11.A2 | v186.42,135.47 186.29,135.34 179.94,135.34 179.82,135.22 | A09.A2 203.95,133.57 v205.73,135.34 207,135.34 207.88,134.46 v177.66,104.23 | v236.33,69.56 230.74,63.97 230.74,63.84 B07.A2 | v183.37,68.8 178.42,63.84 B11.A2 | v197.6,68.54 196.07,68.54 191.25,63.72 B10.A2 | v210.42,70.07 210.3,70.07 203.95,63.72 B09.A2 | v219.19,61.43 v225.54,67.78 | v117.08,64.99 115.81,63.72 113.4,63.72 B16.A2 | v135.24,65.62 128,65.62 126.1,63.72 B15.A2 | v144.64,66.89 141.97,66.89 138.8,63.72 B14.A2 | v157.85,70.45 157.72,70.45 151.24,63.97 B13.A2 | v26.91,68.29 22.34,63.72 21.32,63.72 B23.A2 | v38.72,68.8 38.59,68.8 33.77,63.97 B22.A2 | v70.34,65.49 64.63,65.49 62.85,63.72 61.07,63.72 B20.A2 | v78.85,67.53 77.33,67.53 73.64,63.84 B19.A2 | v91.93,69.43 86.34,63.84 B18.A2 | v53.33,70.19 46.85,63.72 46.72,63.72 B21.A2 | v105.9,68.67 104.12,68.67 99.17,63.72 B17.A2 | v172.58,67.02 172.45,67.02 v166.99,61.56