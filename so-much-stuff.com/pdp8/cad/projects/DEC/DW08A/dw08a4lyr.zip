# EAGLE board dw08a4lyr (EAGLE 4.11), part 2 of 3
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
I_ADD05  (via drill 0.61) (continued)
  Bottom 0.305: v172.21,2.03 171.96,2.29 164.85,2.29 163.58,1.02 93.98,1.02 75.69,19.3 64.52,19.3 62.48,21.34 61.47,21.34 59.44,23.37 56.13,23.37 B20.R2 | v225.3,26.16 225.3,23.62 239.27,9.65 240.03,9.65 v244.09,5.59 | v234.95,132.84 236.73,131.06 238.25,131.06 239.27,130.05 243.33,130.05 248.67,124.71 249.94,124.71 268.22,106.43 268.22,105.16 270.26,103.12 268.99,101.85 267.72,101.85 265.43,104.14 265.43,105.66 A04.L1 | v199.9,95.5 192.53,88.14 v195.07,85.6 | v181.61,67.56 181.61,67.31 v202.95,45.97 | v202.69,41.66 207.26,41.66 210.57,38.35 v212.6,38.35
I_ADD06  (via drill 0.61)
  Top 0.305: v198.37,107.7 198.63,107.7 210.06,119.13 210.06,119.38 210.57,119.89 211.07,119.89 v221.74,130.56 | v233.17,120.65 233.17,120.9 235.97,123.7 v239.52,123.7
  2 0.305: v124.46,134.87 45.72,56.13 43.43,56.13 B21.D2
  15 0.305: v221.23,84.58 221.23,83.06 221.74,82.55 222,82.55 248.41,56.13 249.68,56.13 255.52,50.29 255.52,48.77 263.65,40.64 265.43,40.64 267.97,38.1 267.97,34.04 B04.M1
  Bottom 0.305: v221.23,84.58 200.66,105.16 200.66,105.41 v198.37,107.7 198.12,107.7 166.62,139.19 154.43,139.19 151.64,141.99 131.57,141.99 v124.46,134.87 | v221.74,130.56 223.77,130.56 225.3,129.03 225.3,128.52 226.31,127.51 226.82,127.51 231.65,122.68 231.65,122.17 v233.17,120.65 | v239.52,123.7 245.62,117.6 250.7,117.6 254.51,113.79 255.78,113.79 258.32,111.25 262.13,111.25 266.45,106.93 266.45,105.41 267.97,103.89 A04.M1
I_ADD07  (via drill 0.61)
  Top 0.305: v87.63,2.54 93.47,2.54 93.98,3.05 111.51,3.05 115.06,6.6 116.59,6.6 133.1,23.11 133.1,27.18 156.46,50.55 162.81,50.55 169.16,56.9 173.99,56.9 v185.42,68.33 | v221.23,44.45 224.28,44.45 225.3,45.47 225.3,45.97 226.31,46.99 226.82,46.99 251.46,71.63 251.46,77.47 251.71,77.72 251.71,78.23 266.45,92.96 266.45,95 A04.P1
  2 0.305: v266.7,35.31 266.7,40.64 270.26,44.2 270.26,45.97 272.8,48.51 272.8,57.66 268.22,62.23 268.99,62.99 268.99,63.75 269.75,64.52 269.75,71.12 275.84,77.22 275.84,77.47 276.35,77.98 276.86,77.98 279.15,80.26 279.15,87.88 269.49,97.54 268.99,97.03 A04.P1 | v214.63,44.45 v221.23,44.45
  15 0.305: v266.7,35.31 266.95,35.05 266.95,32.77 267.72,32 267.72,31.24 267.97,30.99 267.97,27.69 B04.P1
  Bottom 0.305: v87.63,2.54 77.22,12.95 70.87,12.95 65.28,18.54 64.26,18.54 62.23,20.57 61.21,20.57 59.44,22.35 55.12,22.35 44.2,33.27 44.2,43.43 43.18,44.45 43.18,48.51 B21.F2 | v185.42,68.33 185.93,68.33 204.47,49.78 205.49,49.78 207.52,47.75 211.33,47.75 v214.63,44.45
I_ADD08  (via drill 0.61)
  Top 0.305: v252.48,5.84 255.52,5.84 266.45,16.76 266.45,18.8 B04.S1 | v238.51,115.32 234.19,111 234.19,109.98 233.93,109.73 233.93,108.97 231.9,106.93 231.9,102.87 v225.55,96.52 | v212.6,42.67 212.09,42.67 205.49,36.07 203.96,36.07 v203.2,35.31
  2 0.305: v115.57,5.59 139.19,5.59 140.72,7.11 141.99,7.11 142.24,7.37 149.86,7.37 154.18,3.05 156.97,5.84 160.27,5.84 167.89,13.46 170.18,13.46 178.82,22.1 184.15,22.1 187.96,25.91 188.98,25.91 191.52,28.45 196.34,28.45 v203.2,35.31 | v225.55,96.52 218.19,89.15 217.17,89.15 215.9,87.88 215.9,74.42 214.12,72.64 214.12,70.1 203.45,59.44 203.45,55.88 203.2,55.63 203.2,54.86 v202.95,54.61
  15 0.305: v115.57,5.59 100.84,20.32 99.06,20.32 84.33,35.05 80.52,35.05 77.22,38.35 58.17,38.35 55.12,41.4 48.77,41.4 47.75,42.42 43.43,42.42 B21.J2 | v203.2,35.31 204.47,36.58 218.19,22.86 218.19,22.35 228.6,11.94 230.63,11.94 232.92,9.65 237.24,9.65 238.76,8.13 240.79,8.13 241.05,7.87 247.65,7.87 247.9,7.62 250.7,7.62 v252.48,5.84 | v238.51,115.32 241.55,115.32 249.17,107.7 252.98,107.7 262.89,97.79 265.68,97.79 266.19,97.28 266.19,97.03 267.97,95.25 267.97,91.19 A04.S1 | v202.95,54.61 202.95,52.32 v212.6,42.67
I_ADD09  (via drill 0.61)
  Top 0.305: v31.5,60.45 31.5,65.53 49.02,83.06 49.02,84.07 51.31,86.36 51.31,87.38 53.85,89.92 53.85,105.92 52.32,107.44 63.25,118.36 v63.25,120.14 | v205.74,130.05 214.63,130.05 216.66,132.08 218.95,132.08 223.27,136.4 223.77,136.4 229.62,142.24 232.41,142.24 232.66,142.49 234.19,142.49 v234.95,143.26 | v257.3,45.47 257.3,43.43 v248.92,35.05 | v238.76,13.46 237.74,13.46 233.93,9.65 232.16,9.65 v227.58,5.08 | v201.42,22.1 196.6,22.1 183.39,8.89 182.12,8.89 v174.5,1.27 | v132.08,25.4 130.81,25.4 123.7,18.29 123.19,18.29 111.25,6.35 96.27,6.35 v94.74,4.83
  2 0.305: v257.3,45.47 260.86,49.02 259.08,50.8 259.08,54.86 B04.D2 | v248.92,35.05 247.9,34.04 247.9,30.23 250.95,27.18 250.7,26.92 250.7,25.65 241.81,16.76 241.81,16.51 v238.76,13.46
  15 0.305: v234.95,143.26 236.47,143.26 238,141.73 238.51,141.73 242.06,138.18 243.08,138.18 243.33,137.92 244.35,137.92 255.02,127.25 256.54,127.25 258.06,125.73 A04.D2 | v94.74,4.83 91.95,2.03 81.53,12.45 68.83,12.45 46.48,34.8 44.7,34.8 43.43,36.07 B21.L2
  Bottom 0.305: v31.5,60.45 32,59.94 32,58.17 35.05,55.12 35.05,42.42 40.64,36.83 42.16,36.83 B21.L2 | v63.25,120.14 63.25,122.17 57.4,128.02 57.4,129.29 71.63,143.51 187.96,143.51 197.87,133.6 202.18,133.6 v205.74,130.05 | v227.58,5.08 218.44,5.08 v201.42,22.1 | v174.5,1.27 172.72,3.05 160.78,3.05 151.38,12.45 145.03,12.45 v132.08,25.4
I_ADD10  (via drill 0.61)
  Top 0.305: 110.74,93.73 137.41,120.4 v139.7,120.4 | 110.74,93.73 94.23,77.22 94.23,75.44 92.2,73.41 92.2,69.85 43.43,21.08 41.4,23.11 41.4,24.38 42.42,25.4 42.42,29.46 B21.N2 | v248.92,22.35 247.4,22.35 243.08,18.03 242.32,18.03 240.28,16 235.71,16 v229.36,9.65 | v196.34,39.37 195.83,39.37 186.44,29.97 184.4,29.97 183.13,28.7 179.83,28.7 176.53,32 v176.28,31.75 | v114.3,90.17 110.74,93.73
  2 0.305: v139.7,120.4 143,120.4 145.54,122.94 146.3,122.94 153.42,130.05 157.73,130.05 159.26,131.57 160.27,131.57 162.56,133.86 163.58,133.86 166.12,136.4 168.4,136.4 169.93,137.92 204.72,137.92 207.52,140.72 216.66,140.72 v217.93,141.99 | v248.92,22.35 251.71,25.15 251.97,25.15 253.49,26.67 253.49,27.94 254,28.45 254,29.46 254.25,29.72 254.25,34.04 259.33,39.12 259.33,40.39 265.43,46.48 262.38,49.53 262.38,51.82 B04.E2
  15 0.305: v217.93,141.99 229.36,141.99 229.62,142.24 232.41,142.24 232.66,142.49 233.93,142.49 234.19,142.24 234.95,142.24 236.47,140.72 237.49,140.72 240.79,137.41 242.82,137.41 246.38,133.86 247.4,133.86 254.76,126.49 255.78,126.49 258.32,123.95 260.1,123.95 261.37,122.68 A04.E2
  Bottom 0.305: v229.36,9.65 226.57,9.65 219.71,16.51 218.69,16.51 216.66,18.54 216.15,18.54 207.26,27.43 207.26,28.45 v196.34,39.37 | v176.28,31.75 172.72,31.75 v114.3,90.17
I_ADD11  (via drill 0.61)
  Top 0.305: v74.42,53.59 74.42,53.34 45.47,24.38 43.43,24.38 B21.R2 | v157.48,4.83 167.89,4.83 v179.07,16 | v196.6,6.6 v204.22,6.6 | v209.3,2.54 209.3,2.79 232.41,25.91 233.17,25.91 v235.71,28.45 | v247.14,137.16 250.44,140.46 252.98,140.46 256.03,143.51 274.32,143.51 282.45,135.38 282.45,128.02 274.83,120.4 270.76,120.4 268.99,118.62 267.72,118.62 265.43,116.33 262.64,116.33 A04.H2 | v174.5,82.8 174.5,82.55 166.88,74.93 159,74.93 155.7,71.63 153.67,71.63 153.42,71.37 149.61,71.37 v105.16,26.92
  2 0.305: v235.71,28.45 240.03,28.45 244.09,32.51 244.86,32.51 248.41,36.07 249.94,36.07 258.06,44.2 260.1,44.2 B04.H2 | v247.14,137.16 242.57,137.16 240.79,135.38 239.01,135.38 230.89,127.25 226.82,127.25 222.5,122.94 222.5,118.87 205.49,101.85 200.15,101.85 184.66,86.36 183.64,86.36 183.13,85.85 177.55,85.85 v174.5,82.8
  Bottom 0.305: v74.42,53.59 74.68,53.59 93.22,35.05 97.54,35.05 105.41,27.18 | 105.41,27.18 108.46,24.13 109.47,24.13 112.01,21.59 113.03,21.59 115.32,19.3 119.13,19.3 122.94,15.49 124.46,15.49 124.71,15.24 125.73,15.24 128.02,12.95 133.1,12.95 135.89,10.16 137.16,10.16 137.67,9.65 152.65,9.65 v157.48,4.83 | v179.07,16 187.2,16 v196.6,6.6 | v204.22,6.6 205.23,6.6 v209.3,2.54 | v105.16,26.92 105.41,27.18
I_BAC00  (via drill 0.61)
  Top 0.305: v218.95,64.01 217.68,62.74 217.68,60.71 217.17,60.2 210.57,60.2 208.03,57.66 207.01,57.66 206.25,56.9 200.91,56.9 193.55,49.53 192.53,49.53 189.48,46.48 186.44,46.48 B10.H2 | v299.47,119.89 296.42,122.94 301.5,128.02 301.5,129.79 302.77,131.06 A01.B1 | v239.78,69.6 238,67.82 235.71,67.82 234.44,66.55 229.62,66.55 227.58,64.52 227.58,62.48 B07.B1
  2 0.305: v302.26,69.09 303.28,68.07 303.28,62.48 B01.B1 | v284.73,91.95 284.73,92.2 285.5,92.96 285.5,96.77 281.69,100.58 294.39,113.28 294.39,113.54 298.96,118.11 298.96,119.38 v299.47,119.89 | v239.78,69.6 243.84,69.6 248.67,74.42 249.43,74.42 252.73,77.72 255.02,77.72 v256.79,79.5 | v277.37,69.6 277.37,70.1 278.13,70.87 278.13,71.88 278.89,72.64 279.4,72.64 285.24,78.49 286,78.49 289.81,82.3 291.08,82.3 v291.34,82.55
  15 0.305: v302.26,69.09 302.26,70.61 300.48,72.39 300.48,72.9 291.08,82.3 291.08,84.33 288.04,87.38 288.04,87.88 286,89.92 286,90.68 v284.73,91.95 | v256.79,79.5 257.56,80.26 258.32,79.5 264.16,79.5 266.7,76.96 267.46,76.96 274.83,69.6 v277.37,69.6
  Bottom 0.305: v218.95,64.01 223.01,64.01 223.27,63.75 224.79,63.75 226.31,62.23 B07.B1 | v291.34,82.55 291.34,82.04 291.85,81.53 291.85,81.03 300.74,72.14 300.74,70.61 v302.26,69.09
I_BAC01  (via drill 0.61)
  Top 0.305: v196.85,41.4 186.18,30.73 183.13,30.73 B10.N2 | v203.2,36.83 205.23,36.83 213.87,45.47 214.88,45.47 223.27,53.85 225.04,53.85 226.31,55.12 B07.D1 | v298.96,51.05 300.74,51.05 302.77,53.09 302.77,54.86 B01.D1 304.8,57.15 v304.8,58.67
  2 0.305: v305.56,43.18 305.56,40.89 305.05,40.39 305.05,29.97 297.43,22.35 287.02,22.35 286,21.34 285.24,21.34 v282.96,19.05 | v254,105.16 263.4,114.55 268.99,114.55 280.42,125.98 276.35,130.05 276.35,132.33 277.62,133.6 288.29,133.6 290.07,135.38 299.72,125.73 302.51,125.73 A01.D1 | v283.72,74.93 283.72,75.18 286,77.47 286.51,77.47 v286.77,77.72
  15 0.305: v272.03,28.45 272.03,27.18 268.22,23.37 264.92,26.67 264.16,26.67 262.38,28.45 249.68,28.45 243.33,34.8 239.52,34.8 238.25,36.07 238.25,40.39 237.74,40.89 237.74,42.93 228.85,51.82 228.85,53.09 227.08,54.86 B07.D1 | v254,105.16 254,101.35 256.54,98.81 257.05,98.81 274.32,81.53 275.34,81.53 277.37,79.5 279.15,79.5 v283.72,74.93
  Bottom 0.305: v196.85,41.4 198.63,41.4 v203.2,36.83 | v298.96,51.05 298.96,50.55 300.23,49.28 300.23,48.77 305.56,43.43 v305.56,43.18 | v282.96,19.05 280.67,19.05 273.3,26.42 273.3,27.18 v272.03,28.45 | v286.77,77.72 287.27,77.72 298.7,66.29 298.7,64.52 304.55,58.67 v304.8,58.67
I_BAC02  (via drill 0.61)
  Top 0.305: v225.3,55.63 224.28,54.61 223.01,54.61 214.63,46.23 213.61,46.23 205.23,37.85 200.91,37.85 193.55,30.48 193.55,26.42 192.79,25.65 192.79,24.89 186.18,18.29 186.18,14.99 B10.U2 | v276.35,120.4 296.42,140.46 304.55,132.33 304.55,131.06 303.28,129.79 306.07,127 306.07,122.94 A01.E1
  2 0.305: v273.3,89.15 271.27,89.15 247.9,65.79 247.9,61.72 237.24,51.05 233.43,51.05 v233.17,50.8
  15 0.305: v276.35,120.4 271.02,115.06 272.8,113.28 272.8,109.22 275.08,106.93 275.08,104.65 276.1,103.63 276.1,100.58 271.27,95.76 272.8,94.23 272.8,91.69 273.05,91.44 273.05,89.41 v273.3,89.15
  Bottom 0.305: v225.3,55.63 225.3,55.37 226.57,54.1 227.84,54.1 229.62,52.32 B07.E1 230.89,52.07 232.16,50.8 v233.17,50.8 | v273.3,89.15 276.86,85.6 277.37,85.6 297.94,65.02 297.94,64.01 306.07,55.88 306.07,53.09 B01.E1
I_BAC03  (via drill 0.61)
  Top 0.305: v225.81,44.45 228.6,44.45 B07.H1 | v268.22,9.65 272.03,9.65 278.38,16 284.73,16 293.62,24.89 294.64,24.89 305.05,35.31 305.05,40.39 306.58,41.91 306.58,45.47 B01.H1 | v226.82,140.97 224.54,140.97 222.25,143.26 220.98,141.99 219.46,141.99 218.44,140.97 212.85,140.97 195.83,123.95 185.42,123.95 170.69,109.22 v170.69,108.97
  2 0.305: v177.8,37.85 181.36,37.85 187.71,44.2 187.71,44.7 191.77,48.77 192.79,48.77 194.56,50.55 199.9,50.55 200.66,51.31 201.68,51.31 204.22,53.85 208.28,53.85 209.3,54.86 209.3,55.37 v209.55,55.63
  15 0.305: v268.22,9.65 263.14,9.65 246.38,26.42 246.38,26.92 237.49,35.81 237.49,36.83 231.9,42.42 231.9,44.2 230.63,45.47 B07.H1 | v226.82,140.97 227.08,140.97 231.65,136.4 236.98,136.4 239.01,134.37 240.03,134.37 258.83,115.57 263.4,120.14 263.4,121.16 263.14,121.41 268.48,126.75 278.38,126.75 287.78,117.35 300.48,117.35 301.5,116.33 305.82,116.33 A01.H1 | v170.69,108.97 171.7,108.97 178.82,101.85 182.63,101.85 183.9,100.58 183.9,94.23 187.2,90.93 187.2,88.9 183.64,85.34 183.39,85.34 179.32,81.28 179.32,80.26 180.59,78.99 180.59,77.98 181.86,76.71 190.25,76.71 v207.77,59.18
  Bottom 0.305: v177.8,37.85 173.48,42.16 173.48,45.47 B11.H2 | v225.81,44.45 225.55,44.7 223.27,44.7 217.68,50.29 216.41,50.29 211.07,55.63 v209.55,55.63 209.55,55.88 207.77,57.66 v207.77,59.18
I_BAC04  (via drill 0.61)
  Top 0.305: v186.44,35.31 185.93,34.8 178.82,34.8 176.78,32.77 175.51,32.77 173.48,30.73 170.43,30.73 B11.N2 | v198.37,28.96 199.9,27.43 201.17,28.7 203.45,28.7 205.74,30.99 206.76,30.99 210.57,34.8 215.14,34.8 222,41.66 225.55,41.66 226.31,42.42 B07.J1 | v222.25,62.99 222.25,65.53 223.27,66.55 223.77,66.55 229.62,72.39 230.12,72.39 230.63,72.9 233.17,72.9 v234.44,74.17
  2 0.305: v247.4,96.52 247.14,96.77 251.71,101.35 258.06,101.35 264.41,107.7 268.48,107.7 v287.02,126.24 | v243.33,70.61 243.84,70.61 248.41,75.18 249.17,75.18 252.48,78.49 253.49,78.49 v258.32,83.31
  15 0.305: v289.56,54.1 289.81,53.85 294.39,53.85 302.77,45.47 302.77,43.43 B01.J1 | v222.25,62.99 222.5,62.74 222.5,58.17 223.01,57.66 223.01,56.39 225.55,53.85 225.55,48.77 228.35,45.97 227.58,45.21 227.58,43.43 B07.J1 | v234.44,74.17 237.74,74.17 241.3,70.61 v243.33,70.61
  Bottom 0.305: v186.44,35.31 188.21,35.31 188.47,35.05 192.28,35.05 v198.37,28.96 | v289.56,54.1 288.54,54.1 258.83,83.82 | 258.83,83.82 252.48,90.17 252.48,90.68 251.71,91.44 251.71,92.2 v247.4,96.52 | v287.02,126.24 287.78,126.24 290.07,123.95 293.88,123.95 301.5,116.33 301.5,114.55 302.77,113.28 A01.J1 | v258.32,83.31 258.83,83.82
I_BAC05  (via drill 0.61)
  Top 0.305: v190.25,1.27 190.25,1.78 207.26,18.8 211.58,18.8 v221.74,28.96 | v295.4,30.99 296.42,32 300.74,32 302.77,34.04 302.77,35.81 B01.L1 | v292.61,75.44 292.61,73.41 288.54,69.34 288.54,68.33 279.65,59.44 279.65,57.91 284.23,53.34 v285.24,54.36
  2 0.305: v221.74,28.96 221.74,29.21 225.3,32.77 225.3,34.54 226.57,35.81 B07.L1 | v288.8,114.05 288.54,114.05 281.94,107.44 281.43,107.44 v271.53,97.54
  Bottom 0.305: v190.25,1.27 177.55,13.97 173.74,13.97 B11.U2 | v295.4,30.99 295.4,28.19 306.07,17.53 306.07,17.02 290.07,1.02 260.6,1.02 258.83,2.79 252.98,2.79 250.19,5.59 248.16,5.59 239.27,14.48 238.25,14.48 227.58,25.15 227.08,25.15 226.57,25.65 226.57,26.42 224.54,28.45 222.25,28.45 v221.74,28.96 | v288.8,114.05 291.08,114.05 293.12,112.01 295.15,112.01 300.48,106.68 302.51,106.68 A01.L1 | v271.53,97.54 271.53,96.52 v292.61,75.44 | v285.24,54.36 287.27,54.36 298.2,43.43 298.2,42.93 299.47,41.66 299.97,41.66 301.5,40.13 301.5,38.35 302.77,37.08 B01.L1
I_BAC06  (via drill 0.61)
  Top 0.305: v243.33,43.94 243.08,43.69 242.32,43.69 241.81,43.18 241.81,42.93 234.19,35.31 233.93,35.31 232.41,33.78 230.89,33.78 B07.M1 | v278.89,12.95 283.97,12.95 302.51,31.5 304.55,31.5 B01.M1 | v187.45,39.37 188.72,39.37 194.31,44.96 195.33,44.96 200.91,50.55 204.98,50.55 206.25,51.82 206.25,52.32 v206.5,52.58 | v303.02,73.41 303.02,71.63 298.7,67.31 298.7,61.72 294.64,57.66 294.64,57.15 294.39,56.9 294.39,55.12 292.35,53.09 292.35,51.82 v294.39,49.78
  2 0.305: v179.07,36.58 181.86,33.78 v187.45,39.37
  15 0.305: v297.43,98.04 290.07,90.68 296.16,84.58 296.16,83.57 298.2,81.53 298.2,78.74 298.7,78.23 298.7,77.72 v303.02,73.41 | v294.39,49.78 300.99,43.18 300.99,41.66 v302.51,40.13
  Bottom 0.305: v243.33,43.94 243.33,43.69 245.62,41.4 250.44,41.4 v278.89,12.95 | v179.07,36.58 177.55,35.05 175.77,35.05 165.1,45.72 161.04,45.72 B12.H2 | v206.5,52.58 208.03,52.58 221.74,38.86 222.76,38.86 226.57,35.05 228.35,35.05 229.62,33.78 B07.M1 | v297.43,98.04 302.01,102.62 305.82,102.62 A01.M1 | v302.51,40.13 302.51,39.12 304.55,37.08 304.55,35.56 306.07,34.04 B01.M1
I_BAC07  (via drill 0.61)
  Top 0.305: v221.49,8.38 222.25,8.38 232.66,18.8 233.43,18.8 v234.95,20.32 | v255.02,4.83 256.03,3.81 261.87,3.81 266.7,8.64 268.73,8.64 268.99,8.89 272.29,8.89 273.05,9.65 284.73,9.65 292.35,17.27 293.37,17.27 298.45,22.35 303.78,22.35 305.82,24.38 305.82,26.42 B01.P1
  2 0.305: v277.11,68.33 279.15,68.33 279.91,69.09 279.91,70.61 281.94,72.64 283.46,72.64 285.24,74.42 285.24,75.69 286.26,76.71 287.27,76.71 290.07,79.5 291.08,79.5 295.4,83.82 295.4,87.88 303.78,96.27 305.82,96.27 A01.P1
  15 0.305: v221.49,8.38 208.28,21.59 207.26,21.59 203.2,25.65 197.87,25.65 196.34,27.18 193.55,24.38 191.26,24.38 180.59,35.05 175.77,35.05 175.51,35.31 174.5,34.29 174.5,33.27 174.75,33.02 170.43,28.7 163.07,28.7 162.05,29.72 157.73,29.72 B12.N2 | v255.02,4.83 252.98,6.86 252.48,6.86 243.59,15.75 239.52,15.75 v234.95,20.32 | v277.11,68.33 279.65,68.33 282.45,65.53 282.45,59.18 291.85,49.78 291.85,45.47 v292.86,44.45
  Bottom 0.305: v234.95,20.32 231.9,23.37 231.9,25.15 230.63,26.42 B07.P1 | v292.86,44.45 292.86,43.69 302.77,33.78 302.77,32.77 304.55,30.99 304.55,29.21 306.07,27.69 B01.P1
I_BAC08  (via drill 0.61)
  Top 0.305: v168.4,19.81 163.32,14.73 161.04,14.73 B12.U2 | v201.17,8.64 207.52,8.64 209.3,10.41 209.3,14.48 v217.17,22.35 | v284.48,4.32 289.05,8.89 291.34,8.89 292.1,9.65 297.43,9.65 305.82,18.03 305.82,20.07 B01.S1 | v234.95,25.15 232.66,25.15 231.9,24.38 231.9,22.61 230.63,21.34 B07.S1 | v291.34,70.1 301.75,80.52 301.75,81.53 305.82,85.6 305.82,89.92 A01.S1 | v303.78,40.39 303.78,39.12 298.7,34.04 298.7,33.53 v298.45,33.27
  2 0.305: v217.17,22.35 228.85,22.35 229.87,21.34 B07.S1
  15 0.305: v168.4,19.81 175.26,26.67 v184.4,17.53 | v291.34,70.1 291.34,62.99 291.85,62.48 291.85,58.17 v292.86,57.15
  Bottom 0.305: v184.4,17.53 186.94,17.53 191.52,12.95 193.8,12.95 195.33,14.48 v201.17,8.64 | v284.48,4.32 261.11,4.32 252.98,12.45 247.65,12.45 v234.95,25.15 | v292.86,57.15 292.86,55.37 299.47,48.77 299.47,48.51 301.5,46.48 301.5,42.67 v303.78,40.39 | v298.45,33.27 298.45,30.48 304.55,24.38 304.55,22.86 306.07,21.34 B01.S1
I_BAC09  (via drill 0.61)
  Top 0.305: v164.85,60.96 150.37,46.48 148.34,46.48 B13.H2 | v275.34,94.23 273.05,94.23 271.02,96.27 263.65,88.9 v263.65,88.65 | v238,87.63 238,87.12 236.98,86.11 236.47,86.11 235.2,84.84 235.2,84.07 233.93,82.8 233.17,82.8 231.9,81.53 231.9,81.03 217.93,67.06 216.66,67.06 v214.63,65.02
  2 0.305: 301.24,70.1 304.04,72.9 304.04,74.42 304.55,74.93 304.55,76.45 v306.07,77.98 | 301.24,70.1 296.42,65.28 296.42,64.77 294.13,62.48 296.42,60.2 296.42,56.13 B01.D2 | v164.85,60.96 166.88,60.96 169.16,63.25 173.23,63.25 v192.28,82.3 | v299.72,71.63 301.24,70.1
  15 0.305: v306.07,77.98 307.09,78.99 307.09,81.53 305.05,83.57 305.05,87.38 303.78,88.65 303.78,91.19 301.75,93.22 301.75,101.35 v304.04,103.63 | v299.72,71.63 297.94,71.63 v275.34,94.23 | v263.65,88.65 256.79,88.65 252.98,84.84 250.44,84.84 246.63,88.65 239.01,88.65 v238,87.63
  Bottom 0.305: v304.04,103.63 304.04,104.9 306.58,107.44 305.05,108.97 305.05,114.05 304.29,114.81 304.29,116.08 301.75,118.62 301.75,119.13 299.97,120.9 299.47,120.9 298.7,121.67 298.7,123.19 297.18,124.71 A01.D2 | v192.28,82.3 192.28,82.04 210.82,63.5 211.07,63.5 212.09,62.48 | 212.09,62.48 212.85,61.72 212.85,61.47 216.92,57.4 218.44,57.4 219.96,55.88 B07.D2 | 212.09,62.48 v214.63,65.02
I_BAC10  (via drill 0.61)
  Top 0.305: v278.89,92.2 v273.3,86.61 | B13.N2 145.03,30.73 149.35,30.73 150.11,31.5 154.18,31.5 175.26,52.58 177.55,52.58 178.82,53.85 180.85,53.85 181.61,53.09 181.86,53.34 184.66,53.34 188.21,56.9 193.55,56.9 194.31,57.66 195.33,57.66 197.87,60.2 209.55,60.2 210.31,60.96 211.07,60.96 v211.58,61.47 213.87,63.75 214.88,63.75 v215.9,64.77 | v279.65,132.08 270.51,141.22 v241.05,111.76 | v247.65,103.12 247.65,99.57 240.28,92.2 235.71,92.2 v231.9,88.39
  2 0.305: v278.89,92.2 278.89,92.71 279.15,92.96 279.15,99.31 298.2,118.36 298.2,120.4 A01.E2 | v231.9,88.39 231.9,81.79 224.28,74.17 224.28,73.41 217.93,67.06 217.42,67.06 216.15,65.79 216.15,65.02 v215.9,64.77
  15 0.305: v273.3,86.61 273.3,83.57 274.57,82.3 278.38,82.3 284.48,76.2 286.77,76.2 292.35,70.61 292.35,64.52 299.72,57.15 299.72,53.09 B01.E2 | v211.58,61.47 212.85,61.47 220.22,54.1 222,54.1 223.27,52.83 B07.E2 | v241.05,111.76 242.57,111.76 247.4,106.93 247.4,103.38 v247.65,103.12
  Bottom 0.305: v279.65,132.08 281.69,130.05 294.13,130.05 299.72,124.46 299.72,122.94 A01.E2
I_BAC11  (via drill 0.61)
  Top 0.305: v281.69,37.08 282.96,38.35 294.39,38.35 298.2,42.16 298.2,43.43 299.47,44.7 299.47,45.47 B01.H2
  2 0.305: v304.8,53.59 300.48,49.28 300.48,46.74 B01.H2 | v292.61,82.8 290.32,85.09 291.85,86.61 291.85,104.65 295.91,108.71 295.91,109.73 298.2,112.01 298.2,114.05 A01.H2 | v168.66,4.06 169.67,5.08 172.72,5.08 175.26,7.62 182.12,7.62 195.33,20.83 196.6,20.83 v199.64,23.88 207.26,31.5 211.33,31.5 222,42.16 222,43.69 223.77,45.47 B07.H2 | v281.69,37.08 274.32,29.72 274.32,29.21 257.56,12.45 255.78,12.45 252.98,9.65 250.95,9.65 248.92,7.62 247.65,7.62 244.6,4.57 244.09,4.57 v241.55,2.03
  15 0.305: v304.8,53.59 304.8,57.15 303.78,58.17 303.78,59.44 301.75,61.47 301.75,63.75 304.29,66.29 304.29,68.58 303.02,69.85 303.02,70.87 301.24,72.64 301.24,73.15 297.18,77.22 297.18,77.72 294.64,80.26 294.64,80.77 v292.61,82.8 | v241.55,2.03 239.27,4.32 229.87,4.32 228.09,6.1 221.74,6.1 217.68,10.16 217.17,10.16 214.88,12.45 209.55,12.45 200.41,21.59 200.41,23.11 v199.64,23.88
  Bottom 0.305: v168.66,4.06 164.59,8.13 162.56,8.13 161.04,9.65 156.72,9.65 154.18,12.19 153.16,12.19 151.38,13.97 148.34,13.97 B13.U2
I_BREAK  (via drill 0.61)
  Top 0.305: v229.36,18.03 229.62,18.03 237.74,26.16 240.03,26.16 245.36,31.5 249.68,31.5 v250.7,32.51 | v180.59,3.3 189.48,3.3 209.55,23.37 v209.55,23.62 | v216.15,17.53 216.41,17.53 222,23.11 222,25.15 B07.P2
  2 0.305: B14.U2 134.37,13.72 130.05,13.72 129.29,12.95 101.85,12.95 101.35,12.45 31.5,12.45 B22.V2 | v272.29,85.6 272.29,84.84 266.19,78.74 266.19,77.22 263.14,74.17 263.14,73.41 258.83,69.09 258.83,67.06 258.57,66.8 258.57,64.26 261.37,61.47 260.86,60.96 260.86,59.69 260.6,59.44 260.6,50.29 264.41,46.48 250.7,32.77 v250.7,32.51
  15 0.305: v272.29,85.6 272.03,85.85 271.02,85.85 262.38,94.49 262.38,96.27 A04.P2 | v180.59,3.3 177.04,6.86 166.37,6.86 164.34,8.89 162.81,8.89 162.05,9.65 156.72,9.65 154.18,12.19 153.16,12.19 152.4,12.95 140.72,12.95 139.7,13.97 135.64,13.97 B14.U2
  Bottom 0.305: B23.V2 18.03,10.67 22.35,10.67 23.37,9.65 29.46,9.65 29.97,10.16 29.72,10.41 B22.V2 | v229.36,18.03 224.28,23.11 224.28,26.42 B07.P2 | v250.7,32.51 254.51,32.51 258.32,28.7 260.1,28.7 261.37,27.43 B04.P2 | v209.55,23.62 210.06,23.62 v216.15,17.53
I_BRKRQ  (via drill 0.61)
  Top 0.305: v247.14,28.7 248.92,28.7 258.06,37.85 260.1,37.85 B04.K2
  2 0.305: v176.02,5.84 188.98,5.84 192.28,9.14 197.61,9.14 204.22,15.75 209.04,15.75 216.66,23.37 218.19,23.37 219.96,25.15 230.38,25.15 232.41,27.18 232.92,27.18 235.2,29.46 236.73,29.46 v241.05,33.78 | v302.26,65.79 302.26,62.99 301.75,62.48 301.75,58.17 300.99,57.4 300.99,55.37 295.4,49.78 295.4,49.28 294.89,48.77 294.39,48.77 289.05,43.43 289.05,42.93 287.78,41.66 284.99,41.66 281.69,38.35 276.35,38.35 271.78,33.78 270.76,33.78 v268.73,31.75
  15 0.305: v150.62,8.13 151.13,8.13 151.89,7.37 159.51,7.37 160.02,6.86 164.85,6.86 165.61,6.1 175.77,6.1 v176.02,5.84 | v302.26,65.79 293.62,74.42 292.1,74.42 287.02,79.5 283.72,79.5 275.08,88.14 272.8,88.14 272.29,88.65 272.29,91.19 271.78,91.69 271.53,91.69 269.75,93.47 269.75,103.63 268.48,104.9 264.67,104.9 262.38,107.19 262.38,108.97 A04.K2
  Bottom 0.305: v150.62,8.13 149.86,8.89 131.06,8.89 130.3,9.65 124.97,9.65 122.43,12.19 121.41,12.19 120.65,12.95 115.32,12.95 114.3,13.97 112.27,13.97 103.89,22.35 93.22,22.35 90.17,25.4 87.63,25.4 83.31,29.72 81.53,29.72 B18.N2 | v241.05,33.78 241.05,33.27 245.62,28.7 v247.14,28.7 | v268.73,31.75 267.97,31.75 263.65,36.07 263.65,37.85 262.38,39.12 B04.K2
I_CAINCR  (via drill 0.61)
  Top 0.305: v100.84,13.46 102.11,13.46 104.39,11.18 112.01,18.8 116.59,18.8 159.26,61.47 160.02,61.47 162.56,64.01 163.58,64.01 166.12,66.55 170.18,66.55 179.07,75.44 180.09,75.44 v182.37,77.72
  2 0.305: v225.3,66.04 225.3,68.07 231.14,73.91 231.65,73.91 232.92,75.18 234.19,75.18 236.47,77.47 236.47,80.26 240.03,83.82 240.03,85.6 241.05,86.61 241.05,94.49 v241.3,94.74
  15 0.305: v225.3,66.04 243.08,48.26 243.59,48.26 244.35,47.5 245.36,47.5 249.43,43.43 249.94,43.43 252.48,40.89 247.9,36.32 247.9,34.54 248.67,33.78 B05.M2 | v241.3,94.74 242.82,94.74 249.68,101.6 248.67,102.62 A05.M2 | v182.37,77.72 183.64,77.72 192.53,86.61 194.56,84.58 196.34,84.58 v198.88,87.12
  Bottom 0.305: v100.84,13.46 91.95,22.35 86.87,22.35 68.58,40.64 68.58,42.16 B19.J2 | v198.88,87.12 199.9,87.12 212.09,74.93 213.87,74.93 216.15,72.64 217.93,72.64 218.69,71.88 219.46,71.88 v225.3,66.04
I_DATA00  (via drill 0.61)
  Top 0.305: v171.45,140.97 171.2,141.22 154.43,141.22 149.61,136.4 147.07,136.4 143.76,133.1 137.41,133.1 135.13,130.81 134.11,130.81 120.65,117.35 96.27,117.35 94.74,115.82 90.17,120.4 67.56,120.4 60.2,113.03 60.2,108.97 56.9,105.66 56.9,92.96 54.61,90.68 54.61,89.66 52.07,87.12 52.07,86.11 50.55,84.58 50.55,80.26 34.8,64.52 34.8,58.17 32.77,56.13 30.73,56.13 B22.D2 | v235.46,73.15 235.46,75.69 v237.49,77.72
  2 0.305: A05.B1 251.71,131.32 250.44,130.05 248.67,130.05 245.36,126.75 239.01,126.75 233.93,121.67 232.66,121.67 223.77,112.78 v222.25,112.78 222.5,112.52 213.87,103.89 v214.12,103.63
  15 0.305: v235.46,73.15 235.71,72.9 238,72.9 245.62,65.28 247.14,65.28 250.19,62.23 251.71,62.23 B05.B1
  Bottom 0.305: v171.45,140.97 177.04,140.97 183.64,134.37 184.4,134.37 188.47,130.3 194.82,130.3 201.17,123.95 204.98,123.95 209.3,119.63 209.3,119.13 210.57,117.86 212.6,117.86 213.87,116.59 214.88,116.59 216.92,114.55 220.73,114.55 222.25,113.03 v222.25,112.78 | v237.49,77.72 237.49,78.74 233.93,82.3 233.43,82.3 232.41,83.31 232.41,85.34 v214.12,103.63
I_DATA01  (via drill 0.61)
  Top 0.305: 199.9,120.65 205.23,120.65 209.3,124.71 209.3,126.75 v209.8,127.25 | v196.34,120.65 199.9,120.65 | v190.25,107.44 190.25,111 199.9,120.65
  2 0.305: v111.25,133.35 37.08,59.18 36.07,59.18 30.73,53.85 30.73,49.78 B22.F2 | v209.8,127.25 209.8,132.08 210.57,132.84 213.36,132.84 216.92,136.4 222.25,136.4 223.01,137.16 232.41,137.16 234.95,139.7 238,139.7 238.76,140.46 242.32,140.46 v243.08,141.22 | v244.6,45.72 251.97,53.09 251.97,54.86 B05.D1
  15 0.305: v225.3,61.72 222.5,64.52 222.5,65.79 224.79,68.07 226.82,66.04 228.09,66.04 229.11,67.06 228.35,67.82 228.35,68.58 225.3,71.63 222,71.63 219.71,73.91 217.93,73.91 211.33,80.52 210.31,80.52 208.53,82.3 204.72,82.3 200.15,86.87 200.15,91.19 199.14,92.2 199.14,94.23 197.1,96.27 197.1,100.58 v190.25,107.44
  Bottom 0.305: v111.25,133.35 120.65,142.75 168.15,142.75 182.63,128.27 183.13,128.27 188.21,123.19 189.23,123.19 191.52,120.9 196.09,120.9 v196.34,120.65 | v243.08,141.22 244.86,141.22 250.7,135.38 250.7,127.25 251.97,125.98 A05.D1 | v244.6,45.72 244.6,46.23 243.33,47.5 239.52,47.5 v225.3,61.72
I_DATA02  (via drill 0.61)
  Top 0.305: v253.75,54.1 252.98,54.1 246.63,47.75 242.57,47.75 241.55,46.74 241.55,46.23 v241.3,45.97 | v219.2,62.74 220.22,63.75 v220.22,67.82
  2 0.305: v116.84,133.6 81.53,98.3 77.22,98.3 37.85,58.93 37.85,54.86 30.73,47.75 30.73,43.43 B22.J2 | v203.2,76.71 203.2,78.49 205.74,81.03 205.74,81.79 207.26,83.31 207.26,84.58 215.65,92.96 215.65,99.31 218.95,102.62 218.95,106.68 226.31,114.05 228.6,114.05 229.87,112.78 230.12,113.03 231.65,113.03 239.01,120.4 243.59,120.4 244.35,121.16 248.41,121.16 250.44,119.13 251.71,120.4 253.75,120.4 A05.E1
  15 0.305: v253.75,54.1 255.02,52.83 B05.E1 | v220.22,67.82 219.2,67.82 217.93,69.09 216.41,69.09 213.11,72.39 209.04,72.39 208.53,72.9 207.01,72.9 v203.2,76.71
  Bottom 0.305: v116.84,133.6 146.05,133.6 159.51,120.14 160.53,120.14 166.12,114.55 169.93,114.55 177.55,106.93 177.55,101.09 186.69,91.95 187.2,91.95 194.56,84.58 195.33,84.58 v203.2,76.71 | v241.3,45.97 239.52,45.97 233.68,51.82 233.17,51.82 229.36,55.63 228.85,55.63 224.28,60.2 220.47,60.2 219.2,61.47 v219.2,62.74
I_DATA03  (via drill 0.61)
  Top 0.305: v249.43,42.42 252.48,45.47 255.02,45.47 B05.H1
  2 0.305: v211.33,143 210.82,143.51 200.66,143.51 199.14,141.99 184.15,141.99 182.63,140.46 173.99,140.46 172.21,138.68 169.67,138.68 168.15,137.16 165.86,137.16 163.32,134.62 162.31,134.62 160.78,133.1 156.46,133.1 154.18,130.81 153.16,130.81 146.05,123.7 140.72,123.7 v139.7,122.68 98.81,81.79 98.81,81.53 85.6,68.33 85.6,64.52 77.98,56.9 73.91,56.9 69.6,52.58 69.6,48.51 63.25,42.16 63.25,35.81 45.97,18.54 30.48,34.04 30.48,35.81 B22.L2 | v224.03,56.9 217.93,56.9 v210.06,49.02
  15 0.305: v211.33,143 214.12,140.21 219.71,140.21 220.22,139.7 221.49,139.7 230.63,130.56 232.66,130.56 232.92,130.3 238,130.3 239.01,129.29 240.28,129.29 246.13,123.44 246.38,123.44 247.9,121.92 247.9,121.67 251.97,117.6 253.75,117.6 255.02,116.33 A05.H1 | v249.43,42.42 245.11,46.74 244.09,46.74 243.33,47.5 239.52,47.5 230.12,56.9 v224.03,56.9 | v174.5,89.41 174.5,91.19 169.67,96.01 169.67,96.77 165.35,101.09 165.35,102.62 159,108.97 159,109.98 157.99,111 156.46,111 v152.91,114.55
  Bottom 0.305: v210.06,49.02 208.53,50.55 204.72,50.55 190.75,64.52 190.75,65.79 178.56,77.98 178.56,83.06 174.75,86.87 174.75,89.15 v174.5,89.41 | v152.91,114.55 152.91,115.06 152.65,115.32 152.65,119.13 148.08,123.7 140.72,123.7 v139.7,122.68
I_DATA04  (via drill 0.61)
  Top 0.305: v99.06,18.8 83.31,3.05 47.75,3.05 46.48,1.78 43.94,1.78 32,13.72 32,14.99 36.58,19.56 30.48,25.65 30.48,29.46 B22.N2 | v164.59,73.66 166.88,73.66 185.17,91.95 189.23,91.95 202.95,105.66 202.95,106.17 203.45,106.68 205.99,106.68 v212.85,113.54 | v246.13,104.65 246.38,104.65 250.7,108.97 250.7,110.74 251.97,112.01 A05.J1
  2 0.305: v99.06,18.8 105.66,18.8 108.97,22.1 113.03,22.1 v164.59,73.66 | v235.46,60.2 240.03,60.2 246.38,66.55 246.38,70.61 v249.17,73.41
  15 0.305: v212.85,113.54 214.88,115.57 232.66,97.79 233.43,97.79 235.71,95.5 235.97,95.5 | 235.97,95.5 238.51,95.5 246.63,103.63 246.63,104.14 v246.13,104.65 | v235.46,60.2 236.98,60.2 251.97,45.21 251.97,43.43 B05.J1 | v235.2,94.23 236.22,95.25 235.97,95.5
  Bottom 0.305: v249.17,73.41 240.28,82.3 239.78,82.3 238,84.07 238,84.58 236.98,85.6 236.47,85.6 235.46,86.61 235.46,87.88 235.2,88.14 v235.2,94.23
I_DATA05  (via drill 0.61)
  Top 0.305: v47.24,22.35 68.83,22.35 91.95,45.47 91.95,49.53 96.27,53.85 100.33,53.85 105.41,58.93 106.43,58.93 131.06,83.57 133.6,83.57 135.38,81.79 v135.89,82.3 | v161.8,61.72 161.8,62.23 162.81,63.25 167.39,63.25 169.93,65.79 171.45,65.79 180.09,74.42 180.59,74.42 187.71,81.53 187.71,81.79 202.44,96.52 | 202.44,96.52 219.96,114.05 224.03,114.05 v235.71,125.73 | 202.44,96.52 v203.2,96.52
  15 0.305: v135.89,82.3 139.7,82.3 143.76,78.23 145.29,78.23 v161.8,61.72 | v226.06,73.41 226.57,72.9 226.57,71.37 229.11,68.83 229.11,68.07 236.22,60.96 237.24,60.96 255.52,42.67 252.98,40.13 252.98,37.08 B05.L1
  Bottom 0.305: v47.24,22.35 36.07,22.35 35.05,23.37 30.73,23.37 B22.R2 | v235.71,125.73 235.97,125.73 242.32,119.38 242.57,119.38 245.11,116.84 245.11,115.57 250.7,109.98 250.7,108.2 251.97,106.93 A05.L1 | v226.06,73.41 226.06,73.66 212.85,86.87 212.85,90.68 211.58,91.95 207.77,91.95 v203.2,96.52
I_DATA06  (via drill 0.61)
  Top 0.305: v250.95,20.32 240.28,9.65 237.24,9.65 234.19,6.6 232.16,6.6 231.9,6.35 230.38,6.35 228.09,4.06 224.79,4.06 v223.01,2.29 | v253.24,98.55 253.75,99.06 253.75,99.57 255.02,100.84 255.02,102.62 A05.M1
  2 0.305: v250.95,20.32 254.25,23.62 254.25,27.69 254.76,28.19 254.76,29.21 255.02,29.46 255.02,32.77 B05.M1 | v170.69,26.16 167.89,26.16 161.04,19.3 160.02,19.3 159.77,19.05 159.77,18.03 154.69,12.95 149.35,12.95 148.08,11.68 147.07,11.68 145.03,9.65 29.46,9.65 1.52,37.59 15.75,51.82 15.75,53.59 17.02,54.86 B23.D2 | v250.7,96.01 v253.24,98.55 | v238.25,94.49 238.25,94.23 235.2,91.19 235.2,80.77 233.93,79.5 230.63,79.5 225.04,73.91 225.04,72.39 223.77,71.12 223.77,67.06 222.5,65.79 222.5,64.52 224.54,62.48 224.79,62.74 225.81,62.74 226.31,63.25 227.58,63.25 229.11,61.72 v228.6,61.21 | v232.92,59.94 232.92,57.15 231.9,56.13 231.9,52.07 231.39,51.56 231.39,50.04 231.14,49.78 231.14,49.02 228.85,46.74 228.85,39.88 226.82,37.85 219.96,37.85 204.47,22.35 203.2,22.35 201.93,21.08 200.91,21.08 199.14,19.3 196.34,19.3 v195.83,19.81
  15 0.305: v223.01,2.29 223.01,3.81 217.42,9.4 212.6,9.4 211.84,10.16 210.82,10.16 202.18,18.8 196.85,18.8 v195.83,19.81 | v250.7,96.01 250.7,97.28 249.68,98.3 247.4,98.3 240.28,91.19 238.25,93.22 v238.25,94.49
  Bottom 0.305: v195.83,19.81 194.82,19.81 192.53,22.1 174.75,22.1 v170.69,26.16 | v228.6,61.21 230.12,61.21 231.39,59.94 v232.92,59.94
I_DATA07  (via drill 0.61)
  Top 0.305: v282.45,50.04 278.13,45.72 278.13,44.7 277.62,44.2 277.11,44.2 264.41,31.5 258.06,31.5 256.79,30.23 256.79,28.19 256.29,27.69 256.29,27.43 B05.P1 255.27,26.42 254,25.15 v259.33,19.81 | v40.39,3.81 31.24,12.95 31.24,15.24 34.04,18.03 16,36.07 16,43.43 17.02,44.45 17.02,48.51 B23.F2
  2 0.305: v282.45,50.04 282.45,51.05 284.23,52.83 285.24,52.83 v289.81,57.4 | v40.39,3.81 112.27,3.81 116.59,8.13 149.1,8.13 150.11,9.14 151.64,9.14 151.89,9.4 153.16,9.4 v162.56,18.8 | v217.42,2.54 218.69,1.27 220.73,3.3 233.93,3.3 241.3,10.67 242.82,10.67 v243.84,11.68
  15 0.305: v289.81,57.4 289.81,58.42 287.78,60.45 287.78,61.47 286.51,62.74 286.51,64.01 286,64.52 286,65.02 283.21,67.82 281.69,67.82 279.15,70.36 278.13,70.36 275.59,72.9 275.08,72.9 268.22,79.76 268.22,82.3 266.95,83.57 266.95,87.38 259.33,95 257.81,95 256.29,96.52 A05.P1 | v162.56,18.8 172.97,18.8 182.12,9.65 206.5,9.65 207.52,8.64 211.33,8.64 v217.42,2.54
  Bottom 0.305: v243.84,11.68 243.84,11.43 247.65,7.62 254.76,7.62 257.05,5.33 259.08,5.33 260.86,3.56 283.72,3.56 283.97,3.3 284.99,3.3 286,4.32 283.97,6.35 278.13,6.35 272.03,12.45 268.22,12.45 266.95,13.72 265.43,13.72 v259.33,19.81
I_DATA08  (via drill 0.61)
  Top 0.305: v75.44,5.33 84.07,5.33 98.55,19.81 100.33,19.81 102.62,22.1 106.68,22.1 107.7,23.11 107.7,27.18 112.01,31.5 116.33,31.5 119.38,34.54 120.4,34.54 130.81,44.96 131.83,44.96 137.41,50.55 141.48,50.55 149.1,58.17 v149.1,59.69
  2 0.305: v236.47,1.27 238.25,3.05 240.03,3.05 253.75,16.76 253.75,18.8 B05.S1 | v240.79,101.6 251.46,90.93 255.02,90.93 A05.S1 | v237.49,107.7 229.62,107.7 228.35,106.43 228.35,104.39 228.09,104.14 228.09,103.12 212.85,87.88 212.85,77.47 211.84,76.45 211.84,72.14 211.58,71.88 211.58,69.85 202.95,61.21 202.95,60.71 v193.55,51.31
  Bottom 0.305: v75.44,5.33 71.12,9.65 61.47,9.65 51.82,19.3 32.77,19.3 31.75,20.32 30.73,20.32 22.1,28.96 22.1,40.13 19.81,42.42 18.03,42.42 B23.J2 | v149.1,59.69 151.13,59.69 153.42,57.4 158.24,57.4 159.51,56.13 161.04,56.13 166.12,51.05 171.2,51.05 172.72,49.53 174.5,49.53 175.51,50.55 183.13,50.55 187.96,45.72 | 187.96,45.72 202.95,30.73 202.95,26.92 220.22,9.65 222,9.65 222.5,9.14 225.04,9.14 229.36,4.83 232.92,4.83 v236.47,1.27 | v240.79,101.6 240.79,103.38 238.25,105.92 238.25,106.93 v237.49,107.7 | v193.55,51.31 187.96,45.72
I_DATA09  (via drill 0.61)
  Top 0.305: v154.94,140.21 144.78,130.05 134.37,130.05 107.7,103.38 107.7,99.31 100.33,91.95 96.27,91.95 94.74,90.42 83.82,101.35 80.26,101.35 44.2,65.28 44.2,61.21 40.39,57.4 40.13,57.4 38.61,55.88 38.61,55.63 25.91,42.93 25.91,41.91 21.08,37.08 18.03,37.08 B23.L2
  2 0.305: v223.27,140.46 220.98,140.46 219.46,138.94 213.11,138.94 193.8,119.63 193.8,118.11 v193.04,117.35
  15 0.305: v196.6,111.25 196.6,107.95 v199.64,104.9 | v223.27,140.46 224.28,139.45 224.54,139.45 227.58,136.4 230.63,136.4 232.92,134.11 235.2,134.11 239.27,130.05 243.33,130.05 245.62,127.76 245.62,125.98 A05.D2
  Bottom 0.305: v154.94,140.21 169.67,140.21 192.79,117.09 | 192.79,117.09 196.6,113.28 v196.6,111.25 | v199.64,104.9 213.61,90.93 213.61,89.92 215.65,87.88 215.65,87.12 216.41,86.36 217.93,86.36 236.47,67.82 236.73,67.82 241.81,62.74 241.81,61.72 244.35,59.18 244.35,57.4 245.62,56.13 B05.D2 | 192.79,117.09 v193.04,117.35
I_DATA10  (via drill 0.61)
  Top 0.305: v48.51,1.27 93.73,1.27 93.98,1.02 124.71,1.02 135.89,12.19 135.89,13.21 136.4,13.72 136.4,17.78 147.07,28.45 166.12,28.45 v172.72,35.05 | v240.79,38.1 243.33,38.1 244.35,39.12 244.35,43.94 v250.19,49.78
  2 0.305: v172.72,35.05 172.72,35.81 174.5,37.59 174.5,38.35 183.64,47.5 185.17,47.5 201.17,63.5 v201.42,63.5 | v234.44,126.75 232.66,126.75 222.25,116.33 v222.25,116.08 | v229.36,105.92 229.36,104.39 228.85,103.89 228.85,101.35 233.93,96.27 228.85,91.19 228.85,84.84 225.55,81.53 225.55,77.72 213.36,65.53 213.36,62.99 212.85,62.48 v212.85,59.18
  Bottom 0.305: v48.51,1.27 20.07,29.72 18.03,29.72 B23.N2 | v201.42,63.5 203.2,63.5 203.71,62.99 204.98,62.99 207.52,60.45 212.85,60.45 | 212.85,60.45 216.66,56.64 217.68,56.64 235.97,38.35 240.54,38.35 v240.79,38.1 | v250.19,49.78 250.19,51.31 249.68,51.82 B05.E2 | v234.44,126.75 240.28,126.75 244.35,122.68 244.35,122.43 245.36,121.41 245.62,121.41 246.13,120.9 246.89,121.67 248.67,121.67 A05.E2 | v222.25,116.08 222.25,115.32 224.28,113.28 224.28,111 v229.36,105.92 | 212.85,60.45 v212.85,59.18
I_DATA11  (via drill 0.61)
  Top 0.305: B23.R2 17.78,23.11 17.78,19.05 20.57,16.26 19.3,14.99 19.3,13.72 32,1.02 46.74,1.02 48.01,2.29 85.85,2.29 87.38,3.81 89.66,3.81 119.63,33.78 120.65,33.78 131.06,44.2 v132.84,44.2 133.35,44.7 135.64,44.7 137.92,46.99 138.94,46.99 140.97,49.02 142.24,49.02 154.18,60.96 v155.7,59.44
  2 0.305: v193.8,14.73 196.85,14.73 197.87,15.75 203.2,15.75 203.96,16.51 204.98,16.51 213.61,25.15 218.95,25.15 219.71,25.91 220.73,25.91 223.27,28.45 227.33,28.45 232.41,33.53 232.41,33.78 232.92,34.29 235.46,34.29 235.97,34.8 240.03,34.8 244.35,39.12 244.35,43.18 245.36,44.2 247.4,44.2 B05.H2 | v240.54,117.6 241.81,118.87 244.35,116.33 248.67,116.33 A05.H2 | v218.95,129.79 218.95,128.02 214.88,123.95 210.31,123.95 199.14,112.78 197.36,112.78 195.33,114.81 187.45,106.93 187.45,102.87 186.44,101.85 182.37,101.85 162.05,81.53 162.05,78.99 v149.35,66.29
  15 0.305: v240.54,117.6 237.74,117.6 233.68,121.67 232.66,121.67 227.58,126.75 223.01,126.75 221.23,128.52 220.22,128.52 v218.95,129.79 | v149.35,66.29 149.35,65.79 v155.7,59.44
  Bottom 0.305: v132.84,44.2 141.22,44.2 144.02,41.4 148.34,41.4 169.42,20.32 171.45,20.32 172.47,19.3 189.23,19.3 v193.8,14.73
I_DATAIN  (via drill 0.61)
  Top 0.305: v142.75,5.08 155.45,5.08 162.81,12.45 v168.4,12.45 | v246.89,14.73 249.17,12.45 249.68,12.95 249.94,12.95 v257.3,20.32
  2 0.305: v199.14,2.29 200.41,1.02 203.71,1.02 205.49,2.79 205.99,2.79 206.76,3.56 211.07,3.56 211.33,3.81 214.88,3.81 215.65,4.57 217.93,4.57 218.19,4.83 225.81,4.83 227.08,6.1 232.66,6.1 239.01,12.45 243.08,12.45 243.33,12.7 244.35,12.7 245.36,13.72 245.87,13.72 v246.89,14.73 | v257.3,20.32 260.1,23.11 260.1,31.5 B04.M2 | v250.95,94.49 251.97,95.5 256.29,95.5 261.37,100.58 261.37,102.62 A04.M2 | v246.38,89.66 241.55,84.84 241.55,77.72 v239.78,75.95
  15 0.305: v168.4,12.45 177.04,12.45 181.1,8.38 188.98,8.38 191.26,6.1 193.8,6.1 195.83,4.06 197.36,4.06 v199.14,2.29 | v250.95,94.49 250.95,91.69 251.46,91.19 251.46,90.17 253.75,87.88 253.75,86.61 252.73,85.6 250.7,85.6 246.63,89.66 v246.38,89.66 | v269.24,44.7 269.24,40.64 269.75,40.13 269.75,26.16 268.48,24.89 263.65,29.72 263.65,31.5 262.38,32.77 B04.M2
  Bottom 0.305: v142.75,5.08 124.97,5.08 123.95,6.1 116.59,6.1 113.03,9.65 99.57,9.65 90.68,18.54 89.66,18.54 87.38,20.83 86.36,20.83 83.82,23.37 81.53,23.37 B18.R2 | v239.78,75.95 240.28,75.95 269.75,46.48 269.75,45.21 v269.24,44.7
I_EXTA0  (via drill 0.61)
  Top 0.305: v241.81,9.65 242.82,10.67 245.36,10.67 B05.V2 | v237.24,71.88 245.62,80.26 A05.V2
  2 0.305: v190.5,124.97 170.18,104.65 166.12,104.65 159.77,98.3 147.07,98.3 138.94,90.17 137.67,90.17 91.95,44.45 91.95,39.12 89.92,37.08 89.92,36.07 78.99,25.15 73.91,25.15 73.15,24.38 68.83,24.38 B19.R2 | v206.5,45.72 206.5,49.78 216.92,60.2 229.62,60.2 232.66,63.25 238.25,63.25 239.27,64.26 239.27,66.8 235.71,70.36 v237.24,71.88
  15 0.305: v241.81,9.65 239.27,9.65 206.5,42.42 v206.5,45.72
  Bottom 0.305: v190.5,124.97 194.56,129.03 211.84,111.76 213.36,111.76 213.87,111.25 219.71,111.25 242.82,88.14 242.82,87.12 245.62,84.33 245.62,81.53 A05.V2
I_EXTA1  (via drill 0.61)
  Top 0.305: v94.49,2.03 124.71,2.03 133.1,10.41 133.1,16.76 136.4,20.07 136.4,24.13 v147.32,35.05 | v231.39,7.37 233.93,7.37 239.01,12.45 239.52,12.45 240.03,12.95 240.03,13.46 242.32,15.75 244.09,15.75 245.36,17.02 B05.T2 | v237.49,82.8 238.25,83.57 239.52,83.57 242.82,86.87 245.36,86.87 A05.T2
  2 0.305: v182.37,1.52 182.88,1.52 183.64,2.29 190.75,2.29 191.52,3.05 198.37,3.05 198.63,3.3 200.41,3.3 200.91,3.81 205.99,3.81 206.5,4.32 210.82,4.32 211.07,4.57 214.63,4.57 215.39,5.33 217.68,5.33 217.93,5.59 225.55,5.59 226.82,6.86 230.89,6.86 v231.39,7.37 | v214.63,96.52 214.63,97.79 211.58,100.84 211.33,100.58 210.57,100.58 209.3,99.31 209.3,91.69 209.04,91.44 209.04,90.42 206.5,87.88 206.5,83.57 204.98,82.04 204.98,81.28 193.29,69.6 192.28,69.6 174.75,52.07 174.75,51.56 v153.42,30.23
  15 0.305: v237.49,82.8 235.97,82.8 233.93,84.84 231.39,84.84 221.23,95 216.15,95 v214.63,96.52
  Bottom 0.305: v94.49,2.03 68.58,27.94 68.58,29.46 B19.N2 | v147.32,35.05 148.34,35.05 153.16,30.23 | 153.16,30.23 177.04,6.35 177.04,5.33 180.09,2.29 181.61,2.29 v182.37,1.52 | 153.16,30.23 v153.42,30.23
I_EXTA2  (via drill 0.61)
  Top 0.305: v244.35,17.78 246.63,20.07 248.67,20.07 B05.S2 | v166.37,101.6 167.13,101.6 180.85,115.32 180.85,117.6 v181.1,117.86
  2 0.305: v171.7,130.05 159.77,130.05 157.23,127.51 156.21,127.51 97.28,68.58 90.93,68.58 69.6,47.24 69.6,42.16 68.83,41.4 68.83,37.08 B19.L2
  15 0.305: v187.45,115.06 189.99,115.06 195.33,109.73 195.33,108.2 196.6,106.93 196.6,104.14 197.1,103.63 197.1,102.62 197.87,101.85 208.79,101.85 210.06,100.58 211.84,100.58 213.87,98.55 225.55,98.55 226.31,97.79 227.33,97.79 232.92,92.2 236.73,92.2 239.27,89.66 240.03,89.66 244.09,93.73 245.62,92.2 247.4,92.2 248.67,90.93 A05.S2 | v244.35,17.78 241.3,17.78 236.98,22.1 233.17,22.1 225.55,29.72 225.55,36.07 206.76,54.86 205.99,54.86 204.72,56.13 202.95,56.13 202.18,56.9 198.37,56.9 185.93,69.34 183.13,69.34 178.56,73.91 178.56,83.06 178.05,83.57 178.05,88.65 170.43,96.27 170.43,97.54 v166.37,101.6
  Bottom 0.305: v171.7,130.05 173.48,130.05 181.1,122.43 | 181.1,122.43 187.2,116.33 187.2,115.32 v187.45,115.06 | v181.1,117.86 181.1,122.43
I_INIT  (via drill 0.61)
  Top 0.305: v264.92,73.41 v270.51,78.99 | v282.7,66.8 282.7,67.06 296.16,80.52 A01.V2 | v283.46,5.33 287.78,9.65 291.08,9.65 292.1,10.67 296.16,10.67 B01.V2
  2 0.305: v230.63,37.59 231.9,38.86 231.9,49.53 232.16,49.78 232.16,51.31 258.32,77.47 258.32,80.26 A04.V2
  Bottom 0.305: v264.92,73.41 259.08,79.25 259.08,80.26 A04.V2 | v270.51,78.99 v282.7,66.8 | v283.46,5.33 264.67,5.33 259.33,10.67 B04.V2 258.06,10.92 256.03,12.95 255.02,12.95 241.55,26.42 241.55,26.67 240.03,28.19 240.03,29.46 B06.N1 239.01,29.72 236.73,32 235.97,32 235.2,32.77 235.2,33.02 233.93,34.29 233.68,34.29 230.63,37.34 v230.63,37.59
I_IOP1  (via drill 0.61)
  Top 0.305: v289.81,67.06 v300.99,78.23 | v304.8,52.07 307.09,49.78 307.09,48.26 306.58,47.75 306.07,47.75 301.75,43.43 301.75,41.66 300.48,40.39 B01.K2
  15 0.305: v285.5,22.35 285.24,22.61 299.47,36.83 299.47,39.12 B01.K2 | v300.99,78.23 298.96,80.26 298.96,81.79 296.93,83.82 296.93,84.84 291.34,90.42 299.47,98.55 299.47,99.57 298.7,100.33 298.7,102.87 298.2,103.38 299.47,104.65 299.47,108.97 A01.K2
  Bottom 0.305: v285.5,22.35 285.5,24.38 246.63,63.25 245.11,63.25 243.59,64.77 B06.A1 | v304.8,52.07 v289.81,67.06
I_IOP2  (via drill 0.61)
  Top 0.305: v257.05,71.88 252.48,67.31 251.97,67.31 250.7,66.04 250.7,64.52 242.32,56.13 240.28,56.13 B06.D1 | v286.26,75.18 290.58,79.5 291.08,79.5 298.2,86.61 298.2,86.87 298.7,87.38 295.4,90.68 295.4,94.23 299.47,98.3 299.47,102.62 A01.M2
  2 0.305: v276.86,84.58 276.86,83.82 265.43,72.39 264.67,72.39 v260.6,68.33
  15 0.305: v257.05,71.88 v260.6,68.33 263.4,65.53 263.4,65.02 264.41,64.01 267.46,64.01 v267.97,63.5
  Bottom 0.305: v267.97,63.5 267.97,62.99 281.94,49.02 282.45,49.02 296.42,35.05 298.2,35.05 299.47,33.78 B01.M2 | v276.86,84.58 v286.26,75.18
I_IOP4  (via drill 0.61)
  Top 0.305: v252.48,59.94 243.59,51.05 243.33,51.05 242.06,49.78 240.28,49.78 B06.F1 | v304.8,81.79 304.8,78.23 290.32,63.75 v290.32,63.5 | v304.8,49.02 304.8,48.77 299.72,43.69 299.47,43.69 298.96,43.18 298.96,41.91 294.39,37.34 294.39,36.07 286,27.69 286,26.42 288.29,24.13 289.81,25.65 v290.07,25.65
  2 0.305: v290.07,25.65 298.7,25.65 B01.P2
  15 0.305: v304.8,81.79 301.5,85.09 301.5,90.93 300.48,91.95 300.48,96.27 A01.P2
  Bottom 0.305: v252.48,59.94 271.02,41.4 274.83,41.4 288.8,27.43 288.8,26.92 v290.07,25.65 | v290.32,63.5 290.83,63.5 304.55,49.78 304.55,49.28 v304.8,49.02
I_IRQ  (via drill 0.61)
  Top 0.305: v260.1,6.86 262.89,6.86 272.8,16.76 272.8,21.08 v273.3,21.59 | v265.18,121.92 262.13,124.97 261.87,124.71 260.1,124.71 240.28,104.9 238.76,104.9 v238.25,104.39 | v204.72,78.23 203.2,78.23 187.45,62.48 187.45,59.94 v187.2,59.69
  2 0.305: v134.87,12.7 135.64,11.94 135.89,12.19 137.16,12.19 137.41,12.45 147.83,12.45 149.1,13.72 149.1,18.54 155.19,24.64 155.19,25.15 156.21,26.16 156.21,27.18 180.85,51.82 180.85,52.32 181.86,53.34 182.37,53.34 187.2,58.17 v187.2,59.69 | v270,117.6 265.43,122.17 v265.18,121.92 | v226.06,110.74 226.06,109.47 221.74,105.16 221.74,103.12 219.2,100.58 219.2,95.25 210.82,86.87 210.82,85.85 206.5,81.53 206.5,80.01 v204.72,78.23
  15 0.305: v273.3,21.59 273.3,32 B03.M2 | v270,117.6 270,112.27 272.03,110.24 272.03,108.97 274.32,106.68 274.32,103.89 A03.M2 | v238.25,104.39 235.71,106.93 234.7,106.93 233.93,107.7 228.6,107.7 226.31,109.98 226.31,110.49 v226.06,110.74
  Bottom 0.305: v134.87,12.7 134.62,12.7 131.32,16 124.97,16 124.71,16.26 123.19,16.26 113.79,25.65 108.97,25.65 97.03,37.59 96.01,37.59 84.84,48.77 81.53,48.77 B18.F2 | v187.2,59.69 188.21,59.69 199.14,48.77 199.14,48.26 202.44,44.96 203.96,44.96 204.22,44.7 209.04,44.7 212.09,41.66 213.61,41.66 213.87,41.4 218.19,41.4 221.49,38.1 222.5,38.1 226.31,34.29 227.33,34.29 239.27,22.35 244.6,22.35 v260.1,6.86
I_LINE  (via drill 0.61)
  Top 0.305: v224.28,2.03 225.3,1.02 230.12,1.02 231.65,2.54 237.74,2.54 238.25,3.05 246.63,3.05 v257.05,13.46
  2 0.305: v141.48,3.3 151.38,3.3 153.67,1.02 161.8,1.02 177.55,16.76 177.55,17.78 178.05,18.29 181.36,18.29 188.21,25.15 191.52,25.15 v191.77,25.4
  15 0.305: v295.4,65.28 301.75,58.93 301.75,48.77 304.55,45.97 304.55,42.67 305.05,42.16 305.05,39.12 305.56,38.61 305.56,37.34 305.82,37.08 303.78,35.05 302.77,35.05 300.74,37.08 297.43,33.78 297.43,32.51 299.47,30.48 281.94,12.95 280.42,12.95 278.89,14.48 276.1,11.68 272.03,11.68 B03.V2 | v289.56,68.83 283.72,68.83 276.61,75.95 276.35,75.95 275.08,77.22 275.08,77.47 272.03,80.52 A03.V2 | v141.48,3.3 131.83,12.95 115.32,12.95 114.3,13.97 112.27,13.97 91.19,35.05 86.87,35.05 85.85,36.07 81.53,36.07 B18.L2
  Bottom 0.305: v295.4,65.28 294.13,66.55 291.85,66.55 v289.56,68.83 | v191.77,25.4 215.65,1.52 220.47,1.52 220.73,1.27 223.52,1.27 v224.28,2.03 | v257.05,13.46 260.86,13.46 261.37,12.95 266.7,12.95 267.97,11.68 270.51,11.68 270.76,11.43 B03.V2
I_MB00  (via drill 0.61)
  Top 0.305: A07.H2 224.28,116.59 224.28,118.36 235.97,130.05 237.74,130.05 239.01,131.32 A06.B1 240.28,132.33 240.28,134.37 242.32,136.4 244.86,136.4 v251.21,142.75 | v300.74,98.55 300.74,101.85 301.5,102.62 301.5,115.32 304.55,118.36 304.55,119.89 302.77,121.67 299.97,118.87 298.96,118.87 288.54,129.29 290.32,131.06 A02.B1
  2 0.305: v305.82,79.25 291.34,64.77 291.34,62.99 291.08,62.74 291.08,62.48 B02.B1
  Bottom 0.305: v305.82,79.25 305.82,82.8 305.05,83.57 305.05,87.38 303.78,88.65 303.78,91.19 301.75,93.22 301.75,97.54 v300.74,98.55 | v251.21,142.75 277.62,142.75 286.77,133.6 288.29,133.6 289.81,132.08 A02.B1
I_MB01  (via drill 0.61)
  Top 0.305: v217.42,105.92 217.42,106.43 235.46,124.46 238.51,124.46 239.01,124.97 A06.D1 | v284.73,51.82 288.04,55.12 289.81,55.12 B02.D1 | v261.37,75.18 261.37,74.68 257.56,70.87 257.05,70.87 v252.48,66.29
  2 0.305: v254.25,130.05 252.73,130.05 246.63,123.95 241.3,123.95 240.28,124.97 A06.D1
  15 0.305: v217.42,105.92 220.22,103.12 220.22,100.58 A07.N2 | v254.25,130.05 275.08,130.05 277.62,127.51 278.64,127.51 283.46,122.68 285.75,124.97 289.81,124.97 A02.D1
  Bottom 0.305: v261.37,75.18 v284.73,51.82 | v252.48,66.29 252.22,66.29 234.44,84.07 234.44,84.33 222.5,96.27 222.5,97.79 220.98,99.31 A07.N2
I_MB02  (via drill 0.61)
  Top 0.305: v232.41,101.35 225.3,94.23 225.3,89.92 224.28,88.9 224.28,84.84 A07.U2 | v244.35,105.92 244.35,107.44 v249.68,112.78
  2 0.305: v299.72,66.8 298.2,65.28 298.2,54.86 296.16,52.83 294.39,52.83 B02.E1 | v275.34,124.97 273.05,124.97 272.03,123.95 261.62,123.95 250.95,113.28 250.19,113.28 v249.68,112.78
  15 0.305: v232.41,101.35 234.44,101.35 236.73,99.06 238.76,99.06 239.27,98.55 240.54,98.55 245.62,103.63 245.11,104.14 245.11,105.16 v244.35,105.92 | v249.68,112.78 249.68,113.54 243.84,119.38 243.84,121.16 243.33,121.67 A06.E1
  Bottom 0.305: v299.72,66.8 291.59,74.93 291.59,75.44 268.73,98.3 264.16,98.3 v249.68,112.78 | v275.34,124.97 276.61,123.7 287.78,123.7 288.8,122.68 293.12,122.68 A02.E1
I_MB03  (via drill 0.61)
  Top 0.305: v210.31,98.81 211.33,99.82 212.09,99.82 216.92,104.65 217.68,104.65 218.44,105.41 218.44,106.17 229.62,117.35 230.38,117.35 v231.65,118.62 | v286.77,43.18 289.81,43.18 B02.J1 | v276.86,76.96 v264.92,65.02 | v281.43,105.41 281.43,105.66 288.04,112.27 289.81,112.27 A02.J1 | v268.73,111.25 266.95,111.25 v254.76,99.06
  15 0.305: v210.31,98.81 209.55,99.57 208.53,99.57 A08.N2
  Bottom 0.305: v231.65,118.62 231.9,118.62 235.97,114.55 237.49,114.55 239.01,113.03 A06.J1 240.28,112.78 241.55,112.78 255.02,99.31 | v264.92,65.02 v286.77,43.18 | v276.86,76.96 274.32,79.5 274.32,80.01 255.02,99.31 | v281.43,105.41 280.67,105.41 278.38,107.7 272.29,107.7 v268.73,111.25 | 255.02,99.31 v254.76,99.06
I_MB03\  (via drill 0.61)
  Top 0.305: v226.82,128.52 214.63,116.33 211.84,116.33 A08.H2 | v241.05,114.3 241.3,114.3 A06.H1 | v266.7,71.37 266.7,71.88 275.08,80.26 | 275.08,80.26 284.48,89.66 284.48,90.17 285.75,91.44 285.75,93.22 291.85,99.31 291.85,109.98 294.13,112.27 294.13,115.32 A02.H1 | v275.34,80.01 275.08,80.26