# EAGLE board dw08a4lyr (EAGLE 4.11), part 3 of 3
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
I_MB03\  (via drill 0.61) (continued)
  Bottom 0.305: v226.82,128.52 v241.05,114.3 v275.34,80.01 | v266.7,71.37 266.7,71.12 283.72,54.1 283.97,54.1 285.75,52.32 285.75,52.07 291.34,46.48 293.12,46.48 B02.H1
I_MB04  (via drill 0.61)
  Top 0.305: v216.41,127 212.6,127 205.49,119.89 204.47,119.89 202.18,117.6 200.41,117.6 199.14,116.33 A09.H2 | v278.38,66.04 278.64,66.04 299.72,87.12 v299.72,87.38 | v268.22,117.6 267.97,117.6 258.06,107.7 251.71,107.7 248.16,104.14 247.14,104.14 246.63,103.63 243.59,103.63 A06.M1
  15 0.305: v278.38,66.04 279.65,64.77 279.65,58.17 283.72,54.1 283.97,54.1 285.75,52.32 285.75,52.07 291.08,46.74 291.08,45.21 291.85,44.45 291.85,43.94 292.35,43.43 292.35,39.12 293.37,38.1 293.37,34.04 B02.M1 | v268.22,117.6 270.26,119.63 270.26,119.89 274.57,124.21 291.85,106.93 291.85,105.41 293.37,103.89 A02.M1
  Bottom 0.305: v216.41,127 216.66,126.75 221.23,126.75 242.57,105.41 242.57,103.89 A06.M1 | v299.72,87.38 295.66,91.44 295.66,91.95 293.37,94.23 293.37,95.25 289.05,99.57 289.05,100.58 292.61,104.14 293.12,103.63 A02.M1
I_MB04\  (via drill 0.61)
  Top 0.305: v236.22,104.9 237.24,104.9 239.01,106.68 A06.L1 | v221.23,90.68 219.71,90.68 214.88,85.85 213.11,85.85 211.84,84.58 A08.U2 210.82,84.84 210.82,88.14 215.65,92.96 215.65,97.03 v230.63,112.01 245.87,127.25 249.94,127.25 259.33,136.65 v262.13,136.65
  15 0.305: v281.18,22.35 280.92,22.61 290.07,31.75 290.07,35.81 B02.L1
  Bottom 0.305: v230.63,112.01 236.22,106.43 v236.22,104.9 | v281.18,22.35 265.68,37.85 265.18,37.85 263.91,39.12 263.91,40.39 259.08,45.21 259.08,46.99 222.5,83.57 222.5,89.41 v221.23,90.68 | v262.13,136.65 290.07,108.71 290.07,106.93 A02.L1
I_MB05  (via drill 0.61)
  Top 0.305: 233.17,83.82 v236.47,87.12 | v217.42,68.07 233.17,83.82 | v239.01,84.58 241.05,86.61 241.05,88.65 A06.S1 | 233.17,83.82 v233.43,83.82 | v272.03,69.09 272.54,69.6 275.84,69.6 293.12,86.87 293.12,89.92 A02.S1 | v263.65,76.2 263.65,75.95 v252.73,65.02
  2 0.305: v236.47,87.12 v239.01,84.58
  Bottom 0.305: v217.42,68.07 201.68,83.82 199.14,83.82 A09.U2 | v233.43,83.82 252.48,64.77 | 252.48,64.77 293.37,23.88 293.37,21.34 B02.S1 | v272.03,69.09 270.76,69.09 v263.65,76.2 | 252.48,64.77 v252.73,65.02
I_MB05\  (via drill 0.61)
  Top 0.305: v238.76,97.28 242.32,97.28 A06.P1 | v230.38,104.9 229.87,104.9 212.85,87.88 212.85,87.38 v211.84,86.36 | v296.67,91.95 301.24,87.38 274.57,60.71 v274.57,60.45
  15 0.305: v288.8,41.15 288.8,46.48 284.48,50.8 284.23,50.8 283.72,51.31 283.72,52.83 276.86,59.69 275.59,59.69 274.83,60.45 v274.57,60.45
  Bottom 0.305: v238.76,97.28 238,97.28 v230.38,104.9 | v211.84,86.36 200.91,97.28 199.9,97.28 198.88,98.3 197.1,98.3 195.83,99.57 A09.N2 | v288.8,41.15 289.05,40.89 289.05,36.07 291.08,34.04 291.08,31.5 292.1,30.48 292.1,29.46 293.37,28.19 293.37,27.69 B02.P1 | v274.57,60.45 274.57,60.71 268.73,66.55 268.22,66.55 255.78,78.99 255.78,82.04 254.25,83.57 254.25,87.38 246.63,95 245.11,95 243.59,96.52 A06.P1 | v296.67,91.95 294.13,94.49 294.13,96.27 A02.P1
I_MB06  (via drill 0.61)
  Top 0.305: v303.53,75.44 300.74,72.64 300.74,70.87 296.42,66.55 296.42,64.77 291.85,60.2 291.85,54.86 289.81,52.83 288.04,52.83 B02.E2 | v282.7,98.04 282.7,100.84 288.29,106.43 288.29,107.44 293.37,112.52 293.37,114.3 286.51,121.16 287.02,121.67 A02.E2 287.02,122.94 287.78,123.7 v284.48,127
  2 0.305: v231.14,114.55 231.14,114.81 234.7,118.36 234.7,120.4 A06.E2 | A10.N2 183.13,100.58 187.45,100.58 197.87,111 201.93,111 210.06,119.13 210.06,119.38 210.57,119.89 212.09,119.89 215.39,123.19 216.41,123.19 216.92,123.7 v219.46,123.7 219.2,123.95 219.2,125.98 226.31,133.1 230.38,133.1 230.63,133.35 231.9,133.35 235.71,137.16 237.49,137.16 239.27,138.94 243.84,138.94 245.11,140.21 250.44,140.21 250.7,140.46 251.46,140.46 v252.48,141.48
  Bottom 0.305: v219.46,123.7 224.03,119.13 225.04,119.13 229.62,114.55 v231.14,114.55 | v303.53,75.44 303.53,77.22 v282.7,98.04 | v252.48,141.48 266.19,141.48 280.42,127.25 284.23,127.25 v284.48,127
I_MB06\  (via drill 0.61)
  Top 0.305: v213.11,137.41 212.85,137.16 210.31,137.16 189.48,116.33 186.44,116.33 A10.H2 | v285.75,58.42 284.73,57.4 284.73,56.13 B02.D2 | v282.96,73.66 v278.64,69.34 | v257.05,99.82 257.3,100.08 257.3,100.58 264.92,108.2 268.99,108.2 283.72,122.94 283.72,124.71 A02.D2
  Bottom 0.305: v213.11,137.41 219.46,137.41 229.62,127.25 231.14,127.25 232.66,125.73 A06.D2 233.68,124.71 235.2,123.19 235.2,121.41 240.03,116.59 240.28,116.59 v257.05,99.82 271.27,85.6 271.27,85.09 275.34,81.03 275.84,81.03 282.96,73.91 v282.96,73.66 | v285.75,58.42 279.65,64.52 279.65,68.33 v278.64,69.34
I_MB07  (via drill 0.61)
  Top 0.305: v246.38,77.98 250.19,81.79 250.19,83.06 257.05,89.92 257.05,91.95 | 257.05,91.95 257.05,95.25 268.73,106.93 270,106.93 v277.37,114.3 | v258.32,91.95 257.05,91.95
  15 0.305: 241.05,104.65 241.05,103.89 236.98,99.82 229.87,106.93 228.35,106.93 225.04,110.24 225.04,111.51 222.76,113.79 221.49,113.79 217.93,117.35 215.14,117.35 214.88,117.6 194.31,117.6 193.55,118.36 191.52,118.36 189.48,120.4 179.58,120.4 174.5,115.32 173.74,116.08 A11.H2 | 241.05,104.65 241.05,106.93 238.76,109.22 237.24,109.22 A06.K2 | 241.05,104.65 v243.84,104.65
  Bottom 0.305: v246.38,77.98 258.57,65.79 258.57,65.28 285.75,38.1 B02.K2 | v277.37,114.3 280.67,114.3 283.72,111.25 285.5,111.25 286.77,109.98 A02.K2 | v243.84,104.65 244.6,104.65 247.14,102.11 248.16,102.11 v258.32,91.95
I_MB07\  (via drill 0.61)
  Top 0.305: v253.24,76.71 253.24,77.47 258.06,82.3 262.13,82.3 270,90.17 v270,90.42 | v265.18,95.25 266.19,96.27 266.19,96.77 270.76,101.35 275.84,101.35 283.72,109.22 283.72,110.24 285.5,112.01 285.5,114.05 A02.H2 | v227.08,68.33 228.85,68.33 230.38,69.85 238.51,69.85 241.3,72.64 245.11,72.64 v250.7,78.23
  2 0.305: v240.03,110.49 241.81,110.49 242.32,111 245.87,111 249.94,106.93 v251.71,108.71
  15 0.305: v282.7,45.72 286.77,45.72 B02.H2 | v192.02,79.5 207.77,79.5 212.34,74.93 213.87,74.93 216.15,72.64 219.96,72.64 221.74,70.87 224.54,70.87 v227.08,68.33 | v240.03,110.49 236.98,113.54 236.98,115.32 A06.H2
  Bottom 0.305: v282.7,45.72 282.7,46.23 265.68,63.25 265.18,63.25 263.91,64.52 263.91,66.55 257.56,72.9 257.05,72.9 v253.24,76.71 251.71,78.23 v250.7,78.23 | v270,90.42 270,90.68 265.43,95.25 v265.18,95.25 264.16,96.27 264.16,96.52 251.97,108.71 v251.71,108.71 | v192.02,79.5 192.02,79.76 187.96,83.82 186.44,83.82 A10.U2
I_MB08  (via drill 0.61)
  Top 0.305: v306.07,48.77 300.99,43.69 300.99,42.16 300.48,41.66 300.23,41.66 299.47,40.89 298.96,40.89 295.15,37.08 295.15,32.77 289.81,27.43 288.04,27.43 B02.P2 | v289.56,65.79 290.07,65.79 v303.28,78.99 | v204.98,111.25 204.72,111 204.22,111 185.93,92.71 184.91,92.71 176.78,84.58 173.74,84.58 A11.U2 | v275.08,71.88 v278.89,75.69 | v246.13,101.6 243.33,101.6 240.28,98.55 238.51,98.55 237.24,97.28 A06.P2
  15 0.305: v204.98,111.25 209.04,111.25 214.63,116.84 232.92,98.55 234.7,98.55 235.97,97.28 A06.P2
  Bottom 0.305: v306.07,48.77 306.07,49.28 v289.56,65.79 289.31,66.04 288.54,66.04 v278.89,75.69 | v303.28,78.99 289.05,93.22 289.05,95 287.78,96.27 A02.P2 | v275.08,71.88 275.08,72.9 255.78,92.2 255.78,92.46 246.89,101.35 246.38,101.35 v246.13,101.6
I_MB08\  (via drill 0.61)
  Top 0.305: v184.15,87.38 186.94,87.38 v204.47,104.9 | v211.84,98.81 213.61,98.81 214.63,97.79 v227.33,110.49 | v247.9,77.98 247.9,78.49 v253.24,83.82
  2 0.305: v282.7,109.73 282.7,109.22 281.69,108.2 275.34,108.2 264.92,97.79 264.67,97.79 264.16,97.28 264.16,94.74 v253.24,83.82
  15 0.305: v285.75,39.62 285.75,39.37 287.02,38.1 287.02,34.04 B02.M2
  Bottom 0.305: v184.15,87.38 184.15,87.63 172.21,99.57 170.43,99.57 A11.N2 | v204.47,104.9 205.74,104.9 v211.84,98.81 | v227.33,110.49 232.92,104.9 234.7,104.9 235.97,103.63 A06.M2 236.98,102.62 238.25,101.35 238.25,99.57 253.24,84.58 v253.24,83.82 | v285.75,39.62 285.24,39.62 259.33,65.53 259.33,66.55 v247.9,77.98 | v282.7,109.73 287.02,105.41 287.02,103.89 A02.M2
I_MB09  (via drill 0.61)
  Top 0.305: v204.47,68.33 216.15,68.33 227.58,79.76 227.84,79.76 230.38,82.3 | 230.38,82.3 234.7,86.61 234.7,88.14 234.95,88.39 234.95,88.9 A06.S2 | 230.38,82.3 v230.12,82.3 | v287.53,86.36 286,84.84 286,80.77 284.73,79.5 284.23,79.5 v275.34,70.61 | v256.03,66.8 v267.21,77.98 | v245.36,67.06 v249.17,70.87
  Bottom 0.305: v204.47,68.33 204.47,68.58 160.78,112.27 160.78,115.32 A12.H2 | 245.11,66.8 240.79,71.12 240.79,71.63 v230.12,82.3 | 245.11,66.8 246.63,65.28 247.14,65.28 251.46,60.96 251.46,59.44 287.02,23.88 287.02,21.34 B02.S2 | v287.53,86.36 287.27,86.61 287.27,89.92 A02.S2 | v275.34,70.61 274.57,70.61 v267.21,77.98 | v256.03,66.8 255.02,66.8 252.48,69.34 250.7,69.34 v249.17,70.87 | 245.11,66.8 v245.36,67.06
I_MB10  (via drill 0.61)
  Top 0.305: v219.96,76.71 230.12,86.87 232.66,86.87 A06.T2 | v279.91,17.02 283.46,17.02 B02.T2 | v198.63,66.8 203.45,66.8 203.96,67.31 210.82,67.31 213.11,65.02 v210.57,62.48 | v266.7,65.28 266.7,65.53 267.46,66.29 267.72,66.29 277.88,76.45 277.88,76.71 283.72,82.55 283.72,86.61 A02.T2
  2 0.305: v210.57,62.48 212.6,64.52 212.6,67.56 214.88,69.85 214.88,71.63 v219.96,76.71
  15 0.305: v246.63,83.06 245.87,83.06 243.33,85.6 235.2,85.6 233.93,86.87 A06.T2
  Bottom 0.305: v219.96,76.71 220.22,76.71 230.38,66.55 230.63,66.55 279.91,17.27 v279.91,17.02 | v198.63,66.8 166.88,98.55 163.07,98.55 162.05,99.57 157.73,99.57 A12.N2 | v266.7,65.28 266.19,65.28 248.41,83.06 v246.63,83.06
I_MB11  (via drill 0.61)
  Top 0.305: v238.25,64.77 241.81,68.33 v241.81,71.63 242.06,71.88 245.36,71.88 245.87,72.39 v250.44,72.39 | v182.37,58.17 184.91,55.63 191.52,62.23 192.02,62.23 v213.87,84.07
  2 0.305: v273.56,67.31 277.37,71.12 277.37,72.64 280.16,75.44 280.16,75.95 283.72,79.5 283.72,80.26 A02.V2 | v256.03,76.96 255.02,76.96 v250.44,72.39
  15 0.305: v273.56,67.31 265.68,67.31 v256.03,76.96
  Bottom 0.305: v241.81,71.63 233.68,79.76 233.68,80.26 A06.V2 | v238.25,64.77 238.76,64.77 241.05,62.48 241.05,57.66 | 241.05,57.66 241.05,57.4 280.92,17.53 280.92,16.26 282.45,14.73 282.45,12.95 283.72,11.68 B02.V2 | v182.37,58.17 160.78,79.76 160.78,83.57 A12.U2 | v213.87,84.07 214.12,84.07 225.04,73.15 225.04,72.9 230.12,67.82 230.89,67.82 241.05,57.66
I_MBINCR  (via drill 0.61)
  Top 0.305: v226.82,45.97 257.05,76.2 257.05,76.96 v260.6,80.52 | v112.78,14.99 114.55,14.99 v140.97,41.4 | v184.15,1.27 188.72,1.27 v226.31,38.86
  2 0.305: v226.31,38.86 226.31,40.39 223.27,43.43 225.3,45.47 226.31,45.47 v226.82,45.97
  15 0.305: v260.6,80.52 262.13,82.04 260.6,83.57 260.6,85.09 259.08,86.61 A04.T2 | v112.78,14.99 75.18,52.58 73.91,52.58 71.37,55.12 68.83,55.12 B19.D2
  Bottom 0.305: v226.82,45.97 255.02,17.78 258.06,17.78 B04.T2 | v140.97,41.4 143,41.4 146.81,37.59 147.83,37.59 v184.15,1.27
I_RUN  (via drill 0.61)
  Top 0.305: v182.63,78.99 180.85,78.99 178.56,81.28 161.04,63.75 155.7,63.75 141.73,49.78 140.72,49.78 138.68,47.75 136.91,47.75 135.64,46.48 B14.H2 | v251.97,68.33 263.65,80.01 263.65,81.53 272.29,90.17 274.07,90.17 A03.S2
  2 0.305: v247.4,26.92 244.86,26.92 243.59,25.65 241.3,25.65 v241.05,25.4
  15 0.305: v247.4,26.92 252.22,22.1 268.73,22.1 270.26,20.57 274.07,20.57 B03.S2 275.08,21.34 276.1,22.35 276.1,33.78 272.8,37.08 272.8,43.43 268.22,48.01 v268.22,50.55
  Bottom 0.305: v182.63,78.99 222,39.62 223.27,39.62 B07.K2 224.28,39.12 225.55,37.85 227.58,37.85 228.6,36.83 228.6,36.07 229.87,34.8 230.63,34.8 231.65,33.78 231.65,33.53 233.68,31.5 234.19,31.5 240.28,25.4 v241.05,25.4 | v251.97,68.33 253.49,66.8 253.49,65.79 253.75,65.53 253.75,65.02 v268.22,50.55
I_SKIP  (via drill 0.61)
  Top 0.305: v295.4,56.39 295.4,57.4 303.28,65.28 303.28,68.58 v305.56,70.87 | v94.23,64.52 131.06,101.35 137.41,101.35 162.81,126.75 164.08,126.75 v165.1,127.76 | v235.2,110.49 v244.86,120.14 | v254.76,112.27 254.76,113.03 257.05,115.32 257.05,119.38 258.06,120.4 260.6,120.4 260.86,120.65 v262.38,120.65
  2 0.305: v295.4,56.39 291.85,52.83 291.85,48.51 290.83,47.5 280.42,47.5 278.13,45.21 278.13,44.7 277.62,44.2 277.11,44.2 275.08,42.16 275.08,40.39 B03.K2 | v94.23,64.52 85.85,56.13 81.53,56.13 B18.D2
  15 0.305: v280.92,98.55 282.96,100.58 282.96,102.87 287.53,107.44 281.94,113.03 280.16,113.03 276.1,108.97 275.34,109.73 A03.K2 | v165.1,127.76 165.61,127.76 166.12,127.25 185.17,127.25 188.47,123.95 206.5,123.95 207.26,123.19 208.28,123.19 210.57,120.9 222,120.9 229.62,113.28 230.89,113.28 232.92,111.25 234.44,111.25 v235.2,110.49 | v244.86,120.14 245.87,121.16 v254.76,112.27
  Bottom 0.305: v305.56,70.87 305.56,72.39 303.53,74.42 303.02,74.42 299.97,77.47 299.97,79.76 284.73,95 280.92,95 279.65,96.27 279.65,97.79 280.67,98.81 v280.92,98.55 | v262.38,120.65 262.38,119.89 271.02,111.25 272.8,111.25 274.07,109.98 A03.K2
I_TS1  (via drill 0.61)
  Top 0.305: 263.65,38.35 v264.92,39.62 | v251.71,26.42 263.65,38.35 | v279.4,71.63 282.7,74.93 282.7,75.44 294.13,86.87 296.16,86.87 A01.T2 | v274.07,76.96 274.07,75.69 263.91,65.53 263.91,62.48 v261.87,60.45 | v277.11,45.21 275.84,45.21 268.99,38.35 263.65,38.35
  15 0.305: v274.07,76.96 v279.4,71.63
  Bottom 0.305: v251.71,26.42 242.06,36.07 240.28,36.07 B06.L1 | v264.92,39.62 281.18,23.37 282.7,23.37 286.77,19.3 294.64,19.3 296.16,17.78 B01.T2 | v261.87,60.45 262.13,60.45 277.11,45.47 v277.11,45.21
I_TS3  (via drill 0.61)
  Top 0.305: v243.59,49.78 240.28,46.48 240.28,43.43 B06.J1 | v289.81,45.72 292.86,42.67 v290.07,39.88
  2 0.305: v276.35,58.67 276.35,62.48 282.96,69.09 282.96,70.1 298.7,85.85 298.7,87.88 299.47,88.65 299.47,89.92 A01.S2
  Bottom 0.305: v243.59,49.78 283.72,9.65 297.69,9.65 305.31,17.27 303.78,18.8 302.26,18.8 300.74,20.32 B01.S2 299.97,21.34 298.2,23.11 298.2,24.38 292.86,29.72 292.86,30.73 291.85,31.75 291.85,37.08 290.07,38.86 v290.07,39.88 | v276.35,58.67 276.61,58.67 283.72,51.56 283.72,51.31 284.23,50.8 284.73,50.8 v289.81,45.72
I_TT_INST  (via drill 0.61)
  Top 0.305: v260.1,8.38 268.73,17.02 270.76,17.02 B03.T2 | v229.62,36.58 229.11,36.58 227.58,35.05 225.81,35.05 224.54,33.78 B07.M2
  2 0.305: v170.18,4.06 171.45,2.79 175.51,6.86 182.63,6.86 191.52,15.75 196.85,15.75 197.61,16.51 198.63,16.51 200.91,18.8 206.25,18.8 217.17,29.72 218.19,29.72 219.96,31.5 222,31.5 B07.M2 | A03.T2 271.02,86.61 271.02,84.84 265.68,79.5 263.14,79.5 256.03,72.39 256.03,70.87 252.48,67.31 251.97,67.31 251.46,66.8 251.46,64.77 250.44,63.75 250.44,61.98 235.2,46.74 235.2,40.64 231.14,36.58 v229.62,36.58
  15 0.305: v260.1,8.38 259.59,8.38 234.44,33.53 234.44,33.78 233.93,34.29 231.9,34.29 v229.62,36.58
  Bottom 0.305: v170.18,4.06 165.35,8.89 162.81,8.89 158.75,12.95 153.42,12.95 136.65,29.72 132.33,29.72 B14.N2
I_WCOV  (via drill 0.61)
  Top 0.305: v192.02,2.03 197.36,2.03 198.63,3.3 200.41,3.3 200.91,3.81 203.96,3.81 216.66,16.51 219.46,16.51 219.96,17.02 B07.T2 | v250.95,88.65 250.95,87.88 247.9,84.84 247.9,83.57 249.43,82.04 247.14,79.76 246.63,79.76 245.36,78.49 v245.36,75.69 | v251.46,63.25 250.44,63.25 242.57,55.37 241.55,55.37 227.33,41.15 v227.08,41.15
  2 0.305: v229.11,12.95 232.16,12.95 235.71,16.51 236.73,16.51 245.36,25.15 | 245.36,25.15 247.4,25.15 B05.P2 | v257.05,64.26 256.79,64.26 256.29,63.75 251.97,63.75 v251.46,63.25 | v245.11,25.4 245.36,25.15
  15 0.305: v192.02,2.03 187.96,6.1 180.34,6.1 178.82,7.62 166.62,7.62 164.59,9.65 163.07,9.65 159.77,12.95 153.42,12.95 147.83,18.54 146.81,18.54 146.05,19.3 134.37,19.3 132.08,21.59 131.06,21.59 122.94,29.72 119.63,29.72 B15.N2 | v250.95,88.65 250.7,88.9 250.7,90.93 249.68,91.95 249.68,96.27 A05.P2 | v245.36,75.69 245.87,76.2 248.16,76.2 257.05,67.31 v257.05,64.26
  Bottom 0.305: v229.11,12.95 227.33,14.73 225.3,14.73 223.01,17.02 221.23,17.02 B07.T2 | v227.08,41.15 230.63,41.15 244.35,27.43 244.35,26.16 v245.11,25.4
N$1  (via drill 0.61)
  Top 0.305: v230.89,68.83 211.58,49.53 211.58,46.74 B08.H2
  Bottom 0.305: v230.89,68.83 235.97,63.75 237.49,63.75 239.01,62.23 B06.B1
N$2  (via drill 0.61)
  Top 0.305: v216.66,30.73 216.92,30.73 225.3,39.12 225.3,39.37 225.81,39.88 227.33,39.88 229.62,42.16 230.63,42.16 239.01,50.55 241.05,50.55 B06.E1
  Bottom 0.305: v216.66,30.73 217.68,29.72 218.19,29.72 219.46,28.45 219.46,26.92 218.19,25.65 216.92,25.65 214.63,27.94 213.61,27.94 211.84,29.72 208.53,29.72 B08.N2
N$3  (via drill 0.61)
  Top 0.305: v233.43,33.27 v242.82,42.67
  2 0.305: v238.25,25.15 238,25.15 228.6,15.75 223.27,15.75 220.73,13.21 219.71,13.21 218.19,11.68 215.9,13.97 211.84,13.97 B08.U2
  15 0.305: v238.25,25.15 238.25,28.45 v233.43,33.27
  Bottom 0.305: v242.82,42.67 242.82,42.93 242.32,43.43 242.32,45.47 B06.H1
N$4  (via drill 0.61)
  2 0.305: v228.85,54.61 221.74,47.5 216.92,47.5 214.88,45.47 214.12,45.47 212.85,44.2 207.01,44.2 204.98,42.16 201.42,45.72 199.14,45.72 B09.H2
  15 0.305: v228.85,54.61 230.89,54.61 234.19,51.31 234.19,50.29 241.05,43.43 241.05,41.91 242.57,40.39 B06.K1
N$5  (via drill 0.61)
  Top 0.305: v204.47,35.05 200.15,30.73 195.83,30.73 B09.N2 | v217.68,28.7 217.68,29.21 219.96,31.5 225.04,31.5 v226.57,33.02 | v230.38,29.72 232.92,27.18 235.2,29.46 236.98,29.46 239.01,31.5 241.05,31.5 B06.M1
  15 0.305: v226.57,33.02 228.6,33.02 229.62,32 229.62,30.48 v230.38,29.72
  Bottom 0.305: v204.47,35.05 206.5,35.05 210.31,31.24 211.33,31.24 213.87,28.7 v217.68,28.7
N$6  (via drill 0.61)
  Top 0.305: v213.36,1.52 218.95,1.52 220.73,3.3 221.23,3.3 242.06,24.13 242.06,26.16 B06.P1
  Bottom 0.305: v213.36,1.52 200.91,13.97 199.14,13.97 B09.U2
O_3CYCLE  (via drill 0.61)
  Top 0.305: v78.23,48.01 77.72,47.5 77.22,47.5 76.2,46.48 72.14,46.48 B19.H2
  Bottom 0.305: v78.23,48.01 78.23,48.26 73.41,53.09 73.41,54.86 44.7,83.57 44.7,88.65 43.94,89.41 43.94,90.68 41.4,93.22 41.4,99.57 35.05,105.92 35.05,107.7 33.78,108.97 A22.K2
O_AC00  (via drill 0.61)
  Top 0.305: v131.57,82.55 131.32,82.55 125.98,77.22 125.98,74.42 118.11,66.55 118.11,64.26 109.98,56.13 109.98,53.09 B16.E2
  Bottom 0.305: v131.57,82.55 131.57,84.58 104.14,112.01 104.14,113.03 95.5,121.67 95.5,123.19 93.98,124.71 A17.D2
O_AC01
  15 0.305: B16.H2 109.22,46.74 109.22,50.8 95.5,64.52 95.5,107.95 94.74,108.71 94.74,109.73 82.8,121.67 82.8,123.19 88.39,128.78 93.22,123.95 95,123.95 96.27,122.68 A17.E2
O_AC02  (via drill 0.61)
  Top 0.305: v58.67,82.3 60.2,82.3 80.01,102.11 81.03,102.11 92.96,114.05 95,114.05 A17.H2
  15 0.305: v58.67,82.3 89.15,51.82 89.15,45.47 93.47,41.15 103.63,41.15 104.65,40.13 108.97,40.13 B16.K2
O_AC03  (via drill 0.61)
  Top 0.305: v119.89,46.74 109.98,36.83 109.98,34.04 B16.M2
  15 0.305: v119.89,46.74 124.97,51.82 119.13,57.66 119.13,59.94 117.6,61.47 117.6,74.42 112.52,79.5 112.27,79.5 111.25,80.52 111.25,90.68 106.93,95 106.93,97.54 98.55,105.92 98.55,107.7 97.28,108.97 A17.K2
O_AC04  (via drill 0.61)
  Top 0.305: v102.11,37.08 102.62,37.08 120.4,54.86 v120.4,57.91
  Bottom 0.305: v102.11,37.08 109.22,29.97 109.22,27.69 B16.P2 | v120.4,57.91 120.4,58.67 117.6,61.47 117.6,66.04 108.71,74.93 108.71,76.71 104.9,80.52 104.9,93.22 98.55,99.57 98.55,101.35 97.28,102.62 A17.M2
O_AC05  (via drill 0.61)
  Top 0.305: v120.14,32.77 118.87,31.5 118.36,31.5 109.98,23.11 109.98,21.34 B16.S2 | v82.3,68.33 82.3,71.63 v99.57,88.9
  Bottom 0.305: v120.14,32.77 118.36,32.77 106.93,44.2 103.12,44.2 95.5,51.82 95.5,55.63 84.58,66.55 84.07,66.55 v82.3,68.33 | v99.57,88.9 99.57,92.2 98.55,93.22 98.55,95 97.28,96.27 A17.P2
O_AC06  (via drill 0.61)
  Top 0.305: v80.77,71.37 80.77,72.14 95,86.36 95,88.65 A17.S2
  Bottom 0.305: v80.77,71.37 96.52,55.63 96.52,53.09 B17.E2
O_AC07  (via drill 0.61)
  Top 0.305: v72.9,66.55 72.9,69.09 77.72,73.91 78.23,73.91 89.92,85.6 91.69,85.6 92.96,86.87 A17.T2
  Bottom 0.305: v72.9,66.55 82.8,56.64 82.8,51.82 84.07,50.55 87.88,50.55 89.66,48.77 91.44,48.77 93.73,46.48 96.27,46.48 B17.H2
O_AC08  (via drill 0.61)
  Top 0.305: v90.93,47.75 90.93,49.53 v107.19,65.79
  Bottom 0.305: v90.93,47.75 96.52,42.16 96.52,40.39 B17.K2 | v107.19,65.79 103.38,69.6 103.38,70.87 93.98,80.26 A17.V2
O_AC09  (via drill 0.61)
  Top 0.305: v124.97,74.93 117.35,67.31 117.35,64.52 107.7,54.86 107.7,48.51 99.06,39.88 99.06,38.86 97.28,37.08 97.28,34.04 B17.M2
  Bottom 0.305: v124.97,74.93 124.97,76.45 121.16,80.26 121.16,80.77 112.52,89.41 112.52,90.93 110.49,92.96 110.49,93.98 108.2,96.27 108.2,106.43 84.58,130.05 83.57,130.05 80.01,126.49 80.52,125.98 A18.D2
O_AC10  (via drill 0.61)
  Top 0.305: v111.25,41.91 111,41.66 111,39.12 99.31,27.43 97.54,27.43 B17.P2
  15 0.305: v111.25,41.91 111.25,54.1 110.49,54.86 110.49,55.88 108.2,58.17 108.2,63.25 106.17,65.28 106.17,79.25 104.9,80.52 104.9,92.2 101.09,96.01 101.09,97.03 98.55,99.57 98.55,104.9 97.79,105.66 97.79,106.68 95.5,108.97 95.5,112.78 87.88,120.4 86.36,120.4 84.84,121.92 A18.E2
O_AC11  (via drill 0.61)
  Top 0.305: v127,47.24 126.75,47.24 106.93,27.43 106.93,27.18 104.9,25.15 99.31,25.15 97.28,23.11 97.28,21.34 B17.S2
  Bottom 0.305: v127,47.24 127,49.78 119.13,57.66 119.13,58.93 116.84,61.21 116.84,62.23 98.55,80.52 98.55,92.2 97.79,92.96 97.79,93.98 92.2,99.57 92.2,105.92 85.85,112.27 85.85,114.05 84.58,115.32 A18.H2
O_ACCEPT  (via drill 0.61)
  Top 0.305: v75.69,82.8 80.77,82.8 83.57,85.6 v85.09,85.6
  Bottom 0.305: v75.69,82.8 70.87,82.8 70.61,83.06 69.34,83.06 62.23,90.17 59.44,90.17 A20.S2 | v85.09,85.6 85.85,85.6 106.68,64.77 107.95,64.77 115.32,57.4 116.84,57.4 118.36,55.88 B15.D2
O_ACCLR  (via drill 0.61)
  Top 0.305: v107.19,68.83 104.65,66.29 104.65,64.52 84.58,44.45 84.58,40.39 B18.K2
  Bottom 0.305: v107.19,68.83 107.19,70.87 97.79,80.26 97.79,81.28 85.85,93.22 85.85,95 84.58,96.27 A18.P2
O_ADD00  (via drill 0.61)
  Top 0.305: v75.95,92.71 72.9,89.66 72.9,83.57 71.12,81.79 71.12,79.76 70.61,79.25 70.61,77.98 64.77,72.14 64.77,69.6 60.2,65.02 60.2,58.17 59.18,57.15 59.18,53.09 B20.E2
  Bottom 0.305: v75.95,92.71 75.95,95.76 72.39,99.31 72.39,100.33 66.8,105.92 66.8,119.63 66.55,119.89 66.55,123.44 67.82,124.71 A19.D2
O_ADD01  (via drill 0.61)
  Top 0.305: v38.1,88.39 38.1,93.22 44.2,99.31 44.2,103.38 64.52,123.7 69.85,123.7 70.87,122.68 A19.E2
  Bottom 0.305: v38.1,88.39 38.1,69.85 41.4,66.55 41.4,61.47 56.39,46.48 58.17,46.48 B20.H2
O_ADD02  (via drill 0.61)
  Top 0.305: v57.4,87.38 57.4,92.46 57.66,92.71 57.66,93.73 60.2,96.27 60.2,102.62 69.6,112.01 69.6,114.05 A19.H2
  15 0.305: v57.4,87.38 57.4,45.47 58.42,44.45 58.42,40.39 B20.K2
O_ADD03  (via drill 0.61)
  2 0.305: v88.65,91.95 60.2,63.5 60.2,39.12 59.18,38.1 59.18,34.04 B20.M2
  Bottom 0.305: v88.65,91.95 88.65,106.93 84.58,111 73.15,111 72.14,109.98 A19.K2
O_ADD04  (via drill 0.61)
  Top 0.305: v56.9,41.4 56.9,42.16 66.55,51.82 66.55,52.32 67.56,53.34 68.07,53.34 72.9,58.17 72.9,62.48 77.98,67.56 77.98,70.87 v85.09,77.98
  Bottom 0.305: v56.9,41.4 57.4,40.89 57.4,32.77 58.42,31.75 58.42,27.69 B20.P2 | v85.09,77.98 85.09,80.26 81.53,83.82 81.53,84.84 79.5,86.87 79.5,93.22 73.15,99.57 73.15,101.35 71.88,102.62 A19.M2
O_ADD05  (via drill 0.61)
  2 0.305: v91.44,67.56 90.42,66.55 89.92,66.55 75.95,52.58 75.95,42.16 59.18,25.4 59.18,21.34 B20.S2
  Bottom 0.305: v91.44,67.56 91.44,68.58 79.5,80.52 79.5,85.85 78.74,86.61 78.74,87.63 73.15,93.22 73.15,95 71.88,96.27 A19.P2
O_ADD06
  Top 0.305: B21.E2 46.48,53.09 46.48,56.13 54.61,64.26 54.61,65.28 69.6,80.26 69.6,82.55 67.56,84.58 69.6,86.61 69.6,88.65 A19.S2
O_ADD07  (via drill 0.61)
  Top 0.305: v69.85,84.07 69.6,83.82 70.36,83.06 70.36,80.01 69.85,79.5 69.85,78.23 47.5,55.88 47.5,51.82 46.48,50.8 46.48,46.74 B21.H2
  Bottom 0.305: v69.85,84.07 69.85,85.34 68.58,86.61 A19.T2
O_ADD08
  Top 0.305: B21.K2 45.72,40.39 45.72,44.2 39.62,50.29 53.85,64.52 53.85,66.29 67.82,80.26 A19.V2
O_ADD09  (via drill 0.61)
  Top 0.305: v31.75,82.04 31.75,91.19 33.02,92.46 33.02,93.47 35.56,96.01 35.56,97.03 37.85,99.31 37.85,104.65 44.96,111.76 44.96,112.78 53.85,121.67 53.85,123.44 55.12,124.71 A20.D2
  Bottom 0.305: v31.75,82.04 36.32,77.47 36.32,69.6 36.83,69.09 36.83,64.01 38.35,62.48 38.35,58.17 52.58,43.94 46.48,37.85 46.48,34.04 B21.M2
O_ADD10  (via drill 0.61)
  Top 0.305: v25.65,44.45 25.65,48.01 35.56,57.91 35.56,58.93 56.9,80.26 56.9,81.53 57.4,82.04 57.4,84.84 v63.25,90.68
  Bottom 0.305: v25.65,44.45 42.67,27.43 45.47,27.43 B21.P2 | v63.25,90.68 63.25,115.82 60.45,118.62 60.45,120.4 59.18,121.67 A20.E2
O_ADD11
  2 0.305: B21.S2 45.72,21.34 45.72,24.13 26.42,43.43 28.45,45.47 28.45,83.57 56.9,112.01 56.9,114.05 A20.H2
O_BAC00  (via drill 0.61)
  Top 0.305: v132.08,110.24 132.33,110.24 144.02,121.92 144.02,124.71 A13.D2
  15 0.305: v175.51,63.5 176.53,63.5 180.85,59.18 180.85,57.4 182.12,56.13 B10.D2
  Bottom 0.305: v132.08,110.24 132.08,107.95 158.5,81.53 158.5,78.74 162.81,74.42 162.81,73.41 172.47,63.75 175.26,63.75 v175.51,63.5
O_BAC01  (via drill 0.61)
  Top 0.305: v192.28,47.75 191.77,47.75 187.45,43.43 187.45,41.66 186.18,40.39 B10.K2
  15 0.305: v152.65,107.95 152.65,93.73 180.85,65.53 180.85,61.21 183.39,58.67 183.39,56.64 v192.28,47.75
  Bottom 0.305: v152.65,107.95 149.1,111.51 149.1,116.33 148.08,117.35 148.08,121.67 A13.E2
O_BAC02  (via drill 0.61)
  15 0.305: v177.8,44.7 169.93,52.58 169.42,52.58 168.15,53.85 168.15,59.18 154.18,73.15 154.18,74.17 145.8,82.55 145.8,87.88 141.22,92.46 149.1,100.33 149.1,109.98 148.08,111 148.08,115.32 A13.H2 | v177.8,32.26 177.29,32.26 176.78,32.77 175.51,32.77 172.97,30.23 181.86,21.34 184.91,21.34 185.17,21.08 B10.S2
  Bottom 0.305: v177.8,44.7 182.12,40.39 182.12,38.1 177.04,33.02 v177.8,32.26
O_BAC03  (via drill 0.61)
  Top 0.305: v164.34,89.41 166.62,87.12 v153.16,73.66
  Bottom 0.305: v164.34,89.41 148.08,105.66 148.08,108.97 A13.K2 | v153.16,73.66 153.67,73.66 168.15,59.18 168.15,57.4 169.42,56.13 B11.D2
O_BAC04  (via drill 0.61)
  Top 0.305: v183.9,52.32 182.88,51.31 182.63,51.31 173.48,42.16 173.48,40.39 B11.K2
  Bottom 0.305: v183.9,52.32 183.9,53.59 186.44,56.13 184.4,58.17 184.4,61.98 160.78,85.6 159.26,85.6 157.73,84.07 156.72,85.09 156.72,85.85 155.7,86.87 155.7,88.14 158.24,90.68 159.77,89.15 161.04,89.15 162.31,90.42 151.38,101.35 149.86,101.35 148.34,102.87 A13.M2
O_BAC05  (via drill 0.61)
  Top 0.305: v128.78,60.45 128.78,61.98 v154.18,87.38
  Bottom 0.305: v128.78,60.45 147.07,42.16 148.59,42.16 169.67,21.08 172.47,21.08 B11.S2 | v154.18,87.38 154.18,88.39 149.35,93.22 149.35,95 148.08,96.27 A13.P2
O_BAC06  (via drill 0.61)
  Top 0.305: v139.7,77.47 139.7,79.5 144.53,84.33 144.53,84.84 144.78,85.09 144.78,85.6 145.8,86.61 145.8,88.65 A13.S2
  15 0.305: v139.7,77.47 156.72,60.45 156.72,56.13 B12.D2
O_BAC07  (via drill 0.61)
  Top 0.305: v138.68,76.45 138.68,77.98 138.94,78.23 138.94,79.76 143.76,84.58 143.76,85.09 144.02,85.34 144.02,86.61 A13.T2
  15 0.305: v138.68,76.45 138.68,74.68 141.99,71.37 141.99,69.34 146.3,65.02 146.3,64.52 155.45,55.37 155.45,46.48 158.5,43.43 158.5,41.91 160.02,40.39 B12.K2
O_BAC08  (via drill 0.61)
  Top 0.305: v130.81,65.79 130.81,67.06 140.72,76.96 140.72,77.47 143.76,80.52 A13.V2
  15 0.305: v130.81,65.79 136.65,59.94 136.65,55.12 137.16,54.61 137.16,52.83 143,46.99 143,42.42 160.02,25.4 160.02,21.34 B12.S2
O_BAC09
  15 0.305: A14.D2 131.32,124.71 131.32,120.65 109.47,98.81 117.35,90.93 117.35,80.77 140.72,57.4 142.24,57.4 143.76,55.88 B13.D2
O_BAC10
  15 0.305: A14.E2 134.37,121.67 134.37,117.6 113.03,96.27 118.11,91.19 118.11,90.17 120.4,87.88 120.4,84.07 123.19,81.28 123.19,80.52 129.29,74.42 129.29,72.64 145.8,56.13 145.8,46.48 146.05,46.23 146.05,41.66 147.32,40.39 B13.K2
O_BAC11  (via drill 0.61)
  Top 0.305: v128.78,106.93 128.78,107.7 130.05,108.97 130.05,109.73 131.57,111.25 132.33,111.25 133.1,112.01 133.1,114.05 A14.H2
  2 0.305: v160.02,60.45 155.19,55.63 159.77,51.05 159.77,48.26 149.1,37.59 149.1,26.42 148.08,25.4 148.08,21.34 B13.S2
  Bottom 0.305: v160.02,60.45 160.02,60.96 146.81,74.17 146.81,78.49 146.56,78.74 146.56,80.77 145.03,82.3 137.41,82.3 135.89,80.77 134.87,81.79 134.87,82.3 133.6,83.57 133.6,88.65 132.84,89.41 132.84,90.68 130.3,93.22 130.3,105.41 v128.78,106.93
O_BREAK
  15 0.305: A20.P2 59.44,96.52 60.96,96.52 72.9,84.58 72.9,80.77 81.79,71.88 81.79,70.36 83.31,68.83 83.31,68.07 119.63,31.75 121.92,31.75 131.32,22.35 133.1,22.35 134.37,21.08 B14.S2
O_BRKRQ  (via drill 0.61)
  Top 0.305: v104.9,50.55 84.58,30.23 84.58,27.69 B18.P2
  15 0.305: v104.9,50.55 104.9,54.1 97.54,61.47 96.01,61.47 93.98,63.5 93.73,63.5 91.95,65.28 91.95,65.53 90.42,67.06 90.42,69.6 79.5,80.52 79.5,86.87 60.45,105.92 60.45,107.7 59.18,108.97 A20.K2
O_CAINCR  (via drill 0.61)
  15 0.305: v71.63,44.45 71.63,40.39 B19.K2
  Bottom 0.305: v71.63,44.45 71.12,44.45 66.8,48.77 66.8,55.12 41.4,80.52 41.4,92.2 40.64,92.96 40.64,93.98 35.05,99.57 35.05,101.35 33.78,102.62 A22.M2
O_DATA00  (via drill 0.61)
  Top 0.305: v22.35,85.6 22.35,101.85 32.26,111.76 32.26,112.78 41.15,121.67 41.15,123.44 42.42,124.71 A21.D2
  Bottom 0.305: v22.35,85.6 26.42,81.53 24.13,79.25 24.13,64.77 33.02,55.88 33.02,53.09 B22.E2
O_DATA01  (via drill 0.61)
  Top 0.305: v21.34,75.18 21.34,82.8 31.5,92.96 31.5,105.66 44.2,118.36 44.2,120.4 A21.E2
  Bottom 0.305: v21.34,75.18 23.37,73.15 23.37,64.52 32,55.88 32,51.82 33.02,50.8 33.02,46.74 B22.H2
O_DATA02  (via drill 0.61)
  Top 0.305: v22.35,72.64 22.35,82.8 32.26,92.71 32.26,93.73 34.8,96.27 34.8,102.62 44.2,112.01 44.2,114.05 A21.H2
  Bottom 0.305: v22.35,72.64 22.35,61.47 31.24,52.58 31.24,51.56 32,50.8 32,45.47 33.02,44.45 33.02,40.39 B22.K2
O_DATA03  (via drill 0.61)
  Top 0.305: v24.13,44.45 24.13,47.5 25.15,48.51 25.15,59.18 29.97,64.01 29.97,65.02 44.96,80.01 44.96,81.03 47.5,83.57 v47.5,99.57
  Bottom 0.305: v24.13,44.45 33.02,35.56 33.02,34.04 B22.M2 | v47.5,99.57 47.5,107.95 46.48,108.97 A21.K2
O_DATA04
  2 0.305: B22.P2 33.02,27.69 33.02,29.97 20.07,42.93 20.32,43.18 20.32,43.69 22.1,45.47 22.1,70.87 23.37,72.14 23.37,78.49 25.15,80.26 25.15,84.33 42.16,101.35 44.2,101.35 A21.M2
O_DATA05  (via drill 0.61)
  Top 0.305: v19.3,43.94 19.3,49.28 9.91,58.67 44.2,92.96 44.2,95 A21.P2
  Bottom 0.305: v19.3,43.94 28.7,34.54 28.7,23.37 30.99,21.08 32.77,21.08 B22.S2
O_DATA06
  Top 0.305: B23.E2 21.08,53.09 21.08,56.13 29.21,64.26 29.21,65.28 44.2,80.26 44.2,85.6 44.96,86.36 44.96,89.41 A21.S2
O_DATA07
  Top 0.305: B23.H2 20.32,46.74 20.32,49.53 11.68,58.17 39.12,85.6 40.89,85.6 42.16,86.87 A21.T2
O_DATA08
  Top 0.305: B23.K2 21.08,40.39 21.08,44.45 22.1,45.47 22.1,49.02 17.53,53.59 28.45,64.52 28.45,66.29 42.42,80.26 A21.V2
O_DATA09
  Bottom 0.305: B23.M2 20.32,34.04 20.32,38.1 16,42.42 16,92.2 15.24,92.96 15.24,93.98 12.95,96.27 12.95,122.94 21.84,131.83 26.42,127.25 27.94,127.25 29.46,125.73 A22.D2
O_DATA10
  Top 0.305: B23.P2 20.32,27.69 20.32,30.73 1.78,49.28 1.78,82.3 31.5,112.01 31.5,120.4 A22.E2
O_DATA11
  Top 0.305: B23.S2 20.32,21.34 20.32,25.4 1.02,44.7 1.02,91.95 32.77,123.7 34.04,123.7 36.58,121.16 35.05,119.63 35.05,117.86 33.78,116.59 A22.H2
O_DATAIN  (via drill 0.61)
  Top 0.305: v98.3,42.42 98.3,39.12 84.58,25.4 84.58,21.34 B18.S2
  15 0.305: v98.3,42.42 98.3,42.67 92.2,48.77 92.2,53.09 86.11,59.18 86.11,60.96 66.8,80.26 66.8,84.33 55.12,96.01 55.12,97.54 59.18,101.6 58.17,102.62 A20.M2
O_EXTA0
  Bottom 0.305: B19.S2 70.87,21.08 66.55,21.08 65.53,22.1 61.72,22.1 59.69,24.13 58.67,24.13 55.12,27.69 55.12,28.7 54.1,29.72 54.1,47.75 40.64,61.21 40.64,62.23 38.35,64.52 38.35,68.58 37.34,69.6 37.34,78.23 35.05,80.52 35.05,98.55 34.29,99.31 34.29,100.33 22.35,112.27 22.35,114.05 21.08,115.32 A23.H2
O_EXTA1  (via drill 0.61)
  Top 0.305: v50.29,25.65 65.79,25.65 66.55,26.42 70.87,26.42 B19.P2
  Bottom 0.305: v50.29,25.65 49.28,25.65 46.48,28.45 42.67,28.45 32,39.12 32,44.45 31.24,45.21 31.24,46.23 19.3,58.17 19.3,88.65 18.54,89.41 18.54,90.68 16,93.22 16,119.63 19.56,123.19 20.07,122.68 A23.E2
O_EXTA2  (via drill 0.61)
  Top 0.305: v50.8,62.99 50.8,65.53 v59.69,74.42
  Bottom 0.305: v50.8,62.99 54.1,59.69 54.1,55.12 67.82,41.4 67.82,40.39 71.12,37.08 71.12,34.04 B19.M2 | v59.69,74.42 59.69,79.5 57.4,81.79 57.4,83.57 54.1,86.87 54.1,90.68 21.08,123.7 20.07,123.7 18.03,125.73 A23.D2
O_INIT  (via drill 0.61)
  15 0.305: v165.61,30.48 149.1,46.99 149.1,52.83 146.56,55.37 146.56,56.39 142.75,60.2 142.75,65.53 132.08,76.2 132.08,80.26 A14.V2
  Bottom 0.305: v165.61,30.48 166.12,30.48 166.88,29.72 167.39,29.72 169.16,27.94 170.43,27.94 171.7,26.67 171.7,26.42 172.47,25.65 188.72,25.65 192.02,28.96 196.6,24.38 196.6,22.86 198.12,21.34 B09.S2
O_IOP1  (via drill 0.61)
  Top 0.305: v202.95,48.01 204.72,49.78 205.23,49.78 207.52,52.07 207.52,54.86 B08.D2
  15 0.305: v202.95,48.01 201.68,46.74 187.71,60.71 186.94,60.71 179.58,68.07 179.58,69.34 168.4,80.52 168.4,86.87 155.7,99.57 v155.7,101.09
  Bottom 0.305: v155.7,101.09 155.7,103.38 148.08,111 147.07,111 144.78,108.71 144.78,107.95 145.8,106.93 145.8,102.11 147.07,100.84 147.07,99.57 145.03,97.54 136.65,105.92 136.65,107.7 135.38,108.97 A14.K2
O_IOP2  (via drill 0.61)
  2 0.305: v188.72,28.45 189.23,28.45 191.01,30.23 191.01,30.48 191.52,30.99 194.06,30.99 200.91,37.85 209.3,37.85 B08.K2
  15 0.305: v188.72,28.45 158.5,58.67 158.5,62.48 141.48,79.5 137.67,79.5 135.89,81.28 135.38,81.28 133.1,83.57 133.1,94.23 131.32,96.01 134.37,99.06 134.37,102.62 A14.M2
O_IOP4  (via drill 0.61)
  15 0.305: v147.57,79.25 145.8,81.03 145.8,81.53 144.53,82.8 144.53,85.34 135.38,94.49 135.38,96.27 A14.P2 | v169.93,53.59 175.77,47.75 181.1,47.75 183.39,45.47 184.4,45.47 207.52,22.35 209.3,22.35 210.57,21.08 B08.S2
  Bottom 0.305: v147.57,79.25 147.57,74.42 162.81,59.18 164.34,59.18 v169.93,53.59
O_IRQ  (via drill 0.61)
  Top 0.305: v95,60.96 84.58,50.55 84.58,46.74 B18.H2 | v79.5,77.98 80.01,77.98 88.65,86.61 88.65,90.42 85.34,93.73 v86.87,95.25
  Bottom 0.305: v95,60.96 95,62.48 93.98,63.5 93.73,63.5 91.95,65.28 91.95,65.53 v79.5,77.98 | v86.87,95.25 86.87,98.55 85.85,99.57 85.85,101.35 84.58,102.62 A18.M2
O_LINE  (via drill 0.61)
  Top 0.305: v68.07,52.32 v88.65,72.9
  Bottom 0.305: v68.07,52.32 83.82,36.58 83.82,34.04 B18.M2 | v88.65,72.9 81.28,80.26 A18.V2
O_MB00
  15 0.305: A15.D2 119.63,125.98 119.63,128.78 124.71,133.86 127.76,133.86 128.02,133.6 185.17,133.6 188.47,130.3 201.17,130.3 204.22,127.25 208.28,127.25 209.3,126.24 211.58,126.24 213.87,123.95 218.19,123.95 219.96,125.73 A07.D2
O_MB01  (via drill 0.61)
  Top 0.305: v176.02,141.99 144.27,141.99 126.49,124.21 125.98,124.21 125.73,123.95 124.21,123.95 122.94,122.68 A15.E2
  15 0.305: v180.09,139.45 178.56,139.45 v176.02,141.99
  Bottom 0.305: v180.09,139.45 183.13,136.4 192.53,136.4 201.42,127.51 202.69,127.51 204.22,125.98 204.98,125.98 211.07,119.89 211.58,119.89 214.12,117.35 217.93,117.35 219.96,115.32 221.23,115.32 223.52,113.03 223.52,110.24 A07.K2
O_MB02  (via drill 0.61)
  Top 0.305: v130.3,124.46 130.3,121.92 125.98,117.6 124.21,117.6 122.94,116.33 A15.H2
  15 0.305: v212.85,103.38 211.58,104.65 206.25,104.65 204.98,105.92 203.96,105.92 195.83,114.05 192.02,114.05 190.25,115.82 188.21,115.82 187.96,116.08 187.45,116.08 186.18,117.35 183.13,117.35 178.31,112.52 176.78,114.05 159.26,114.05 v155.7,117.6
  Bottom 0.305: v212.85,103.38 223.52,92.71 223.52,91.19 A07.S2 | v155.7,117.6 155.19,117.6 148.34,124.46 147.32,124.46 145.03,126.75 135.13,126.75 131.57,123.19 v130.3,124.46
O_MB03  (via drill 0.61)
  2 0.305: v129.29,93.98 131.83,91.44 144.53,104.14 145.54,104.14 153.16,111.76 154.18,111.76 156.46,114.05 161.8,114.05 165.86,118.11 166.88,118.11 169.16,120.4 174.24,120.4 v183.13,129.29
  Bottom 0.305: v129.29,93.98 122.68,100.58 122.68,102.62 A15.M2 | v183.13,129.29 188.47,123.95 194.82,123.95 207.52,111.25 208.28,111.25 210.57,108.97 A08.K2
O_MB03\  (via drill 0.61)
  Top 0.305: v177.8,141.73 166.12,130.05 147.07,130.05 140.72,123.7 139.19,123.7 136.4,120.9 134.87,120.9 133.1,119.13 133.1,118.36 124.71,109.98 122.94,109.98 A15.K2
  Bottom 0.305: v177.8,141.73 182.37,141.73 184.15,139.95 190.5,139.95 197.61,132.84 198.63,132.84 204.22,127.25 205.74,127.25 207.26,125.73 A08.D2
O_MB04
  2 0.305: A15.S2 122.94,90.93 124.71,90.93 128.78,95 131.06,95 143.76,107.7 148.08,107.7 152.91,112.52 153.42,112.52 167.64,126.75 175.51,126.75 178.82,130.05 182.37,130.05 182.63,130.3 188.47,130.3 193.8,124.97 194.56,125.73 A09.D2
O_MB04\  (via drill 0.61)
  Top 0.305: v185.67,113.54 185.42,113.54 176.78,104.9 171.45,104.9 167.13,100.58 165.86,100.58 v165.1,99.82
  15 0.305: v185.67,113.54 196.34,102.87 196.34,102.36 202.18,96.52 202.18,96.01 207.26,90.93 210.57,90.93 A08.S2 | v165.1,99.82 165.1,100.33 148.08,117.35 144.78,117.35 123.7,96.27 122.94,97.03 A15.P2
O_MB05  (via drill 0.61)
  2 0.305: v169.67,111 153.42,111 132.33,89.92 131.32,89.92 123.19,81.79 121.67,81.79 121.41,81.53 119.63,81.53 A15.V2
  15 0.305: v169.67,111 176.02,111 194.82,92.2 196.6,92.2 197.87,90.93 A09.S2
O_MB05\  (via drill 0.61)
  Top 0.305: v170.69,83.82 194.56,107.7 196.6,107.7 A09.K2
  2 0.305: v152.65,66.55 161.04,74.93 161.8,74.93 v170.69,83.82
  Bottom 0.305: v152.65,66.55 140.46,78.74 131.06,78.74 122.94,86.87 119.63,86.87 A15.T2
O_MB06  (via drill 0.61)
  Top 0.305: v137.16,136.4 121.67,136.4 111.25,125.98 111.25,124.21 109.98,122.94 A16.E2
  Bottom 0.305: v137.16,136.4 167.13,136.4 172.72,130.81 173.74,130.81 187.96,116.59 187.96,116.33 189.23,115.06 186.18,112.01 186.18,110.24 A10.K2
O_MB06\  (via drill 0.61)
  Top 0.305: v146.05,100.33 149.1,100.33 157.73,108.97 157.99,108.97 159,109.98 159,110.24 169.16,120.4 175.51,120.4 178.82,123.7 180.59,123.7 181.86,124.97 A10.D2
  Bottom 0.305: v146.05,100.33 122.43,123.95 112.27,123.95 111.25,124.97 106.93,124.97 A16.D2
O_MB07  (via drill 0.61)
  Top 0.305: v131.83,88.9 131.83,89.41 143.76,101.35 148.84,101.35 151.64,104.14 151.64,105.16 155.45,108.97 155.45,113.03 166.12,123.7 167.89,123.7 169.16,124.97 A11.D2
  Bottom 0.305: v131.83,88.9 131.57,89.15 128.02,89.15 123.7,93.47 123.7,97.28 122.43,98.55 118.62,98.55 109.98,107.19 109.98,108.97 A16.K2
O_MB07\
  15 0.305: A10.S2 185.17,90.93 180.85,90.93 154.43,117.35 149.1,117.35 148.34,118.11 147.32,118.11 141.73,123.7 135.38,123.7 132.33,126.75 122.43,126.75 111,115.32 110.24,116.08 A16.H2
O_MB08  (via drill 0.61)
  Top 0.305: v150.62,104.65 146.05,104.65 v122.17,80.77
  Bottom 0.305: v150.62,104.65 163.32,91.95 167.13,91.95 168.15,90.93 172.47,90.93 A11.S2 | v122.17,80.77 113.28,89.66 113.28,91.19 111.25,93.22 111.25,95 109.98,96.27 A16.P2
O_MB08\  (via drill 0.61)
  Top 0.305: v144.27,79.25 144.78,79.25 152.15,86.61 152.15,90.68 169.16,107.7 171.2,107.7 A11.K2
  Bottom 0.305: v144.27,79.25 144.02,79.5 131.32,79.5 109.98,100.84 109.98,102.62 A16.M2
O_MB09  (via drill 0.61)
  Top 0.305: v122.43,95.25 122.94,95.25 130.56,102.87 131.57,102.87 134.11,105.41 135.13,105.41 153.42,123.7 155.19,123.7 156.46,124.97 A12.D2
  2 0.305: v122.43,95.25 122.17,95 118.36,95 114.55,91.19 113.79,91.19 113.54,90.93 110.24,90.93 A16.S2
O_MB10  (via drill 0.61)
  Top 0.305: v128.27,73.91 129.03,73.91 150.11,95 150.37,95 150.88,95.5 150.88,98.04 158.5,105.66 158.5,107.7 A12.K2
  Bottom 0.305: v128.27,73.91 124.21,73.91 115.32,82.8 108.97,82.8 106.68,85.09 106.68,86.61 A16.T2
O_MB11  (via drill 0.61)
  Top 0.305: v114.05,76.45 122.94,76.45 130.81,84.33 133.1,84.33 134.37,85.6 139.45,85.6 v149.86,96.01
  Bottom 0.305: v114.05,76.45 109.98,80.52 106.93,80.52 A16.V2 | v149.86,96.01 152.91,96.01 156.72,92.2 158.5,92.2 159.77,90.93 A12.S2
O_MBINCR  (via drill 0.61)
  Top 0.305: v50.8,75.69 50.8,79.5 51.31,80.01 51.31,81.03 53.85,83.57 53.85,85.34 55.12,86.61 A20.T2
  Bottom 0.305: v50.8,75.69 71.12,55.37 71.12,53.09 B19.E2
O_RUN  (via drill 0.61)
  Top 0.305: v103.89,72.64 107.19,72.64 v110.24,75.69
  Bottom 0.305: v103.89,72.64 86.36,90.17 84.84,90.17 A18.S2 | v110.24,75.69 110.24,75.18 128.02,57.4 129.54,57.4 131.06,55.88 B14.D2
O_SKIP  (via drill 0.61)
  Top 0.305: v72.64,70.87 72.64,81.28 v83.31,91.95
  Bottom 0.305: v72.64,70.87 76.45,67.06 76.45,64.52 83.82,57.15 83.82,53.09 B18.E2 | v83.31,91.95 83.31,95.76 82.8,96.27 82.8,108.2 A18.K2
O_TS1  (via drill 0.61)
  Top 0.305: v143.76,91.44 142.49,91.44 140.21,93.73 135.64,89.15 133.6,89.15 A14.T2
  15 0.305: v143.76,91.44 147.32,87.88 147.32,87.38 160.78,73.91 160.78,73.41 171.7,62.48 171.7,58.17 182.37,47.5 186.18,47.5 188.21,45.47 189.74,45.47 194.82,40.39 196.85,40.39 197.1,40.13 197.87,40.13 B09.K2
O_TS3  (via drill 0.61)
  Top 0.305: v158.75,71.12 165.35,71.12 166.37,72.14 166.88,72.14 v173.48,78.74
  Bottom 0.305: v158.75,71.12 139.7,90.17 135.64,90.17 A14.S2 | v173.48,78.74 184.91,67.31 185.42,67.31 193.55,59.18 193.55,57.4 194.82,56.13 B09.D2
O_TT_INST
  Bottom 0.305: A18.T2 81.28,86.61 81.28,86.11 82.3,85.09 82.3,84.07 83.57,82.8 87.63,82.8 106.43,64.01 107.7,64.01 115.06,56.64 116.08,56.64 131.32,41.4 133.1,41.4 134.37,40.13 B14.K2
O_WCOV  (via drill 0.61)
  15 0.305: v59.44,88.9 59.18,89.15 58.17,89.15 51.82,95.5 39.12,95.5 38.1,96.52 34.04,96.52 A22.P2
  Bottom 0.305: v59.44,88.9 62.48,88.9 69.09,82.3 70.36,82.3 70.61,82.04 71.63,82.04 105.92,47.75 116.08,47.75 120.4,43.43 120.4,42.16 122.17,40.39 B15.K2
VCC  (via drill 0.61)
  Top 0.381: v168.4,138.94 164.85,135.38 161.04,135.38 A12.A2 | 185.67,140.72 185.67,141.48 184.66,142.49 180.59,138.43 176.78,138.43 173.74,135.38 A11.A2 | 185.67,140.72 185.67,135.64 A10.A2 | 185.67,140.72 200.41,140.72 201.93,139.19 198.37,135.64 A09.A2 | v185.42,77.72 173.48,65.79 B11.A2 | v192.53,70.61 187.45,65.53 186.44,65.53 B10.A2 | B08.A2 210.57,65.53 206.5,65.53 205.49,66.55 204.22,66.55 203.71,66.04 199.64,66.04 199.14,65.53 B09.A2 | B13.A2 148.34,64.77 152.15,64.77 153.92,62.99 155.45,64.52 159.77,64.52 B12.A2 161.04,65.53 166.62,71.12 v166.88,71.12 | v116.33,71.37 110.49,65.53 110.24,65.53 B16.A2 | v140.21,69.6 139.7,69.6 135.64,65.53 B14.A2 | v91.19,70.61 89.92,70.61 84.84,65.53 B18.A2 | v25.15,66.8 23.88,65.53 21.34,65.53 B23.A2 | v53.59,69.85 49.28,65.53 46.74,65.53 B21.A2 | v40.13,71.37 34.29,65.53 34.04,65.53 B22.A2 | v63.75,70.1 63.5,70.1 59.18,65.79 B20.A2 | v183.9,109.22 183.39,109.22 171.7,97.54 171.7,92.96 v168.66,89.92
  2 0.381: B06.A2 235.97,64.52 231.65,64.52 230.89,63.75 228.09,63.75 226.31,65.53 225.81,65.02 224.54,65.02 B07.A2 | B16.A2 108.97,65.53 103.38,71.12 97.54,65.28 B17.A2
  15 0.381: v166.88,71.12 172.47,65.53 B11.A2
  Bottom 0.381: v168.4,138.94 168.91,138.94 172.47,135.38 A11.A2 | 207.39,138.3 210.57,135.13 A08.A2 | 207.39,138.3 202.18,143.51 198.88,140.21 198.88,135.64 A09.A2 | 219.46,138.18 213.87,138.18 213.61,138.43 207.52,138.43 207.39,138.3 | 219.46,138.18 219.71,138.18 222.5,135.38 223.27,135.38 A07.A2 | 219.46,138.18 223.27,141.99 227.33,141.99 233.93,135.38 235.97,135.38 A06.A2 | B08.A2 211.84,65.53 215.14,68.83 216.92,67.06 219.46,67.06 219.71,66.8 222,66.8 223.27,65.53 B07.A2 | v185.42,77.72 185.67,77.72 192.66,70.74 | 192.66,70.74 197.87,65.53 B09.A2 | v192.53,70.61 192.66,70.74 | B15.A2 121.92,65.79 v116.33,71.37 116.08,71.63 119.13,74.68 120.14,74.68 127.25,67.56 131.57,67.56 133.6,65.53 134.37,65.53 B14.A2 | v140.21,69.6 144.27,65.53 147.07,65.53 B13.A2 | 71.63,70.1 71.63,71.37 74.68,74.42 83.57,65.53 B18.A2 | 71.63,70.1 71.63,65.79 B19.A2 | v91.19,70.61 96.27,65.53 B17.A2 | v25.15,66.8 31.5,66.8 32.77,65.53 B22.A2 | v53.59,69.85 53.85,69.85 58.17,65.53 B20.A2 | v40.13,71.37 45.72,65.79 B21.A2 | 71.63,70.1 v63.75,70.1 | v183.9,109.22 183.9,113.54 167.13,130.3 156.46,130.3 154.94,131.83 157.48,134.37 159.77,134.37 A12.A2 | v168.66,89.92 165.86,87.12 171.2,81.79 171.2,79.5 185.17,65.53 B10.A2

## Text on the board
Bottom: VRS | DW08A | DW08A