# EAGLE board pdp8l (EAGLE 4.11), part 4 of 8
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
JMP_DIRECT\  (via drill 0.61) (continued)
  Route2 0.203: v356.82,211.58 356.41,211.58 350.72,205.89 348.29,205.89 337.72,195.33 337.72,194.92 337.31,194.51 336.09,194.51 322.27,180.7 322.27,179.88 v313.74,171.35
  Route15 0.203: v349.5,218.08 349.5,217.68 352.35,214.83 353.57,214.83 v356.82,211.58
  Bottom 0.203: v304.8,166.88 310.9,166.88 312.12,168.1 B12.N1
JMS  (via drill 0.61)
  Top 0.203: v377.95,84.38 377.95,96.57 379.17,97.79 C07.P1 | v320.24,195.33 320.24,229.46 320.65,229.87 v320.65,234.75 320.65,235.15 v320.65,258.72 | v370.64,99.42 368.61,99.42 368.61,116.48 371.04,118.92 371.04,134.37 v368.2,137.21 | v345.85,158.34 346.25,158.75 v346.25,181.1
  Route15 0.203: v320.24,195.33 331.22,184.35 334.47,184.35 B10.H2 | A13.B1 300.74,269.7 303.17,269.7 304.8,268.07 311.71,268.07 320.65,259.13 v320.65,258.72 | v368.2,137.21 362.51,142.9 361.29,142.9 v345.85,158.34
  Bottom 0.203: v377.95,84.38 323.49,84.38 322.68,85.19 C11.U2 | v320.65,234.75 316.59,234.75 A12.P1 | v320.65,258.72 330,258.72 331.22,257.5 A10.F2 | v370.64,99.42 371.04,99.82 377.55,99.82 378.76,98.6 C07.P1 | v346.25,181.1 345.03,182.32 337.31,182.32 335.69,183.95 B10.H2
JMS\  (via drill 0.61)
  Route2 0.203: v284.07,109.17 273.91,99.01 271.88,99.01 C15.P2
  Route15 0.203: v347.07,107.14 347.47,107.14 349.1,105.51 349.1,103.89 350.72,102.26 C09.N1
  Bottom 0.203: v284.07,109.17 285.7,109.17 286.11,109.58 334.87,109.58 337.72,106.73 346.66,106.73 v347.07,107.14 | C07.N1 375.51,101.45 374.29,100.23 352.75,100.23 351.54,101.45 C09.N1
KCC\  (via drill 0.61)
  Top 0.203: v50.39,113.64 50.39,84.78 52.02,83.16 C32.V2
  Bottom 0.203: v50.39,113.64 50.39,123.39 54.86,123.39 C32.E2
KEY_CONT  (via drill 0.61)
  Top 0.203: v434.85,52.68 434.85,64.06 434.44,64.47 434.44,79.5 432,81.94 432,93.32 433.22,94.54 C02.R2
  Bottom 0.203: v434.85,52.68 439.73,47.8 442.16,47.8 D02.H1
KEY_CONT\  (via drill 0.61)
  Top 0.203: v449.48,23.83 449.48,27.89 D01.P2 | v442.98,32.77 441.76,33.98 441.76,44.55 440.54,45.77 440.54,49.84 440.13,50.24 D02.F1 | v393.8,139.24 393.8,104.29 | 393.8,104.29 393.8,101.04 394.61,100.23 394.61,96.16 395.02,95.76 C05.R2 | v368.61,139.24 368.61,198.58 366.98,200.2 366.98,202.64 B08.A1 | 393.8,104.29 v395.83,104.29
  Route15 0.203: v395.83,104.29 401.12,99.01 401.12,98.6 432,67.72 432,62.84 437.69,57.15 437.69,51.46 438.1,51.05 439.32,51.05 D02.F1
  Bottom 0.203: v449.48,23.83 453.95,23.83 455.17,22.61 D01.S1 | v442.98,32.77 446.63,29.11 448.67,29.11 D01.P2 | v393.8,139.24 v368.61,139.24
KEY_DP  (via drill 0.61)
  Top 0.203: A10.S2 334.47,229.06 334.47,234.34 A10.P2 | v314.55,79.5 314.55,96.57 315.77,97.79 C12.P1 | v432,79.5 432,59.18 433.22,57.96 D02.D2 | v277.17,185.57 277.17,141.28 v278.79,139.65
  Route2 0.203: v322.68,231.9 320.24,229.46 319.43,229.46 310.49,220.52 310.49,218.49 296.67,204.67 296.27,204.67 v277.17,185.57
  Route15 0.203: v278.79,139.65 278.79,139.24 297.49,120.55 297.49,120.14 303.99,113.64 303.99,112.42 314.15,102.26 314.15,100.23 315.37,99.01 C12.P1
  Bottom 0.203: A10.P2 334.47,234.34 332.03,234.34 332.03,232.31 A10.R2 331.22,232.31 330.4,233.12 323.9,233.12 v322.68,231.9 | v314.55,79.5 314.96,79.91 431.6,79.91 v432,79.5
KEY_DP\  (via drill 0.61)
  Top 0.203: v440.13,105.1 441.35,103.89 441.35,83.97 444.19,81.13 444.19,61.62 443.38,60.81 D02.C1 442.57,59.59 441.76,58.78 441.76,53.09 447.45,47.4 447.45,14.07 446.63,13.26 D01.V2
  Route2 0.203: v440.13,105.1 438.51,106.73 438.51,121.36 439.73,122.58 439.73,126.24 C02.D1
KEY_EX+DP  (via drill 0.61)
  Top 0.203: D02.D1 439.73,57.96 438.51,59.18 438.51,76.25 438.91,76.66 438.91,81.13 438.51,81.53 438.51,119.33 439.32,120.14 C02.F1 | v303.99,242.88 304.39,242.47 304.39,231.9 v303.99,231.5 | v336.91,188.42 336.91,176.63 v337.31,176.22
  Route2 0.203: v303.99,242.88 305.21,244.09 305.21,245.31 307.24,247.34 308.86,247.34 A12.K2 | v337.31,176.22 337.31,175.82 336.91,175.41 336.91,173.79 335.28,172.16 B10.M2
  Route15 0.203: v303.99,231.5 303.99,231.09 319.84,215.24 319.84,211.18 320.24,210.77 320.24,207.11 336.09,191.26 336.09,189.23 v336.91,188.42 | v414.53,129.9 414.53,130.3 407.21,137.62 405.59,137.62 405.18,138.02 403.15,138.02 401.93,139.24 401.12,139.24 380.39,159.97 373.89,159.97 360.88,172.97 356.82,172.97 v353.57,176.22
  Bottom 0.203: v414.53,129.9 418.59,125.83 427.13,125.83 427.94,125.02 439.32,125.02 439.32,121.36 C02.F1 | v353.57,176.22 337.72,176.22 v337.31,176.22
KEY_EX+DP\  (via drill 0.61)
  Top 0.203: v445.01,115.67 444.6,115.27 444.6,56.34 442.98,54.71 D02.E1
  Route15 0.203: v454.76,31.95 455.17,31.55 455.17,29.11 D01.P1
  Bottom 0.203: 448.26,38.05 450.7,40.49 450.7,52.68 444.19,52.68 443.38,53.49 D02.E1 | 448.26,38.05 443.79,33.58 423.06,33.58 422.66,33.98 419,33.98 418.19,34.8 D04.M1 | v445.01,115.67 438.91,115.67 437.29,117.3 C02.H2 | v454.76,31.95 448.67,38.05 448.26,38.05
KEY_EX\  (via drill 0.61)
  Top 0.203: v447.04,119.33 447.85,118.52 447.85,115.27 454.36,108.76 454.36,33.58 455.57,32.36 455.57,30.33 454.36,29.11 v454.36,20.17
  Bottom 0.203: v447.04,119.33 443.38,119.33 443.38,123.39 C02.E1 | v454.36,20.17 454.36,16.51 449.48,16.51 D01.U2
KEY_LA  (via drill 0.61)
  Top 0.203: v240.18,138.43 238.15,138.43 238.15,38.46 241,35.61 | 241,35.61 242.62,33.98 242.62,32.36 D17.N2 | v238.56,8.38 241,10.82 241,35.61
  Route2 0.203: v240.18,138.43 240.59,138.43 293.42,191.26 293.42,192.89 B13.D2 | v380.8,7.98 435.66,62.84 439.32,62.84 D02.B1
  Bottom 0.203: D17.N2 243.43,32.36 245.47,34.39 D17.M2 | v380.8,7.98 317.81,7.98 317.4,8.38 v238.56,8.38
KEY_LA+EX+DP  (via drill 0.61)
  Top 0.203: v302.77,227.03 301.95,227.84 301.95,238 301.14,238.81 301.14,242.88 300.33,243.69 A13.L1
  Route2 0.203: v377.95,48.62 377.95,49.02 392.99,64.06 393.8,64.06 400.71,70.97 401.12,70.97 412.9,82.75 412.9,83.16 422.66,92.91 422.66,93.73 423.88,94.94 423.88,96.57 434.85,107.54 434.85,108.76 436.47,110.39 C02.K2
  Route15 0.203: v302.77,227.03 314.96,214.83 v315.37,214.83 | v334.47,210.36 337.72,207.11 339.34,207.11 369.42,177.04 370.64,177.04 388.93,158.75 389.74,158.75 403.15,145.34 404.37,145.34 428.35,121.36 428.35,117.3 432.82,112.83 434.85,112.83 436.07,111.61 C02.K2
  Bottom 0.203: v315.37,214.83 318.62,211.58 321.46,211.58 322.68,210.36 v334.47,210.36 | v377.95,48.62 377.55,49.02 356.01,49.02 354.79,47.8 D09.H1
KEY_LA\  (via drill 0.61)
  Top 0.203: v447.04,66.09 447.85,65.28 447.85,24.23 449.07,23.01 D01.S2 | v437.29,75.44 435.25,77.47 435.25,112.01 433.63,113.64 C02.J2
  Route2 0.203: C05.U2 399.08,86 402.34,86 420.62,104.29 420.62,105.92 431.6,116.89 431.6,120.95 432.82,122.17 434.44,122.17 436.88,119.74 435.25,118.11 435.25,116.48 433.63,114.86 C02.J2
  Route15 0.203: v437.29,75.44 441.35,71.37 441.35,69.75 442.57,68.53 442.57,67.31 D02.A1
  Bottom 0.203: D01.S2 449.88,21.79 450.7,20.98 454.76,20.98 455.17,20.57 455.17,16.51 D01.U1 | v447.04,66.09 443.38,66.09 D02.A1
KEY_PROTECT\  (via drill 0.61)
  Top 0.203: v440.54,53.09 440.94,52.68 440.94,46.99 444.19,43.74 444.19,32.77 441.76,30.33 441.76,14.88 440.13,13.26 D02.V1 | v453.14,111.61 450.7,114.05 450.7,118.92 447.85,121.77 447.85,155.09 451.1,158.34 451.1,206.7 453.95,209.55 453.95,220.52 453.54,220.93 453.54,224.59 454.36,225.4 454.36,271.73 455.17,272.54 A01.A1
  Route2 0.203: v440.54,53.09 440.54,56.34 440.94,56.74 440.94,60.4 442.16,61.62 442.16,64.06 444.19,66.09 444.19,77.88 452.73,86.41 452.73,87.22 453.95,88.44 453.95,110.79 v453.14,111.61
KEY_SS+I_REF
  Route2 0.203: D09.M1 354.38,35.61 354.38,38.86 394.61,79.1 396.24,79.1 421.03,103.89 421.03,104.7 427.13,110.79 427.13,111.61 432,116.48 432,119.33 432.82,120.14 C02.F2
KEY_SS\  (via drill 0.61)
  Top 0.203: v448.67,109.58 451.1,107.14 451.1,79.1 453.54,76.66 453.54,66.5 451.1,64.06 451.1,15.7 446.63,11.23 444.6,11.23 444.6,14.88 445.82,16.1 445.82,18.54 D01.T2
  Route15 0.203: v448.67,109.58 444.19,114.05 444.19,118.11 438.91,123.39 437.29,123.39 C02.E2
KEY_ST  (via drill 0.61)
  Top 0.203: v442.57,87.63 444.19,89.26 444.19,124.61 443.38,125.42 443.38,129.49 C02.C1 | v316.59,146.15 317.4,145.34 317.4,123.39 314.15,120.14 314.15,81.94 313.74,81.53 313.74,79.1 314.15,78.69 314.96,78.69 316.99,76.66 316.99,72.59 314.15,69.75 314.15,64.87 313.33,64.06 D12.B1 | v308.05,146.15 307.64,146.56 307.64,194.11 308.05,194.51 308.05,212.8 309.68,214.43 309.68,221.74 A12.U2 | v379.58,81.13 375.11,76.66 375.11,62.43 v375.51,62.03
  Bottom 0.203: C02.U2 437.29,86 438.91,87.63 v442.57,87.63 442.98,87.63 443.38,87.22 449.88,87.22 450.7,86.41 450.7,83.97 421.03,83.97 420.22,84.78 418.59,84.78 414.53,80.72 379.98,80.72 v379.58,81.13 | v316.59,146.15 v308.05,146.15 | v375.51,62.03 368.2,62.03 367.79,62.43 364.54,62.43 364.13,62.03 355.19,62.03 354.79,62.43 351.94,62.43 351.54,62.03 342.6,62.03 342.19,62.43 338.94,62.43 338.53,62.03 330,62.03 327.56,64.47 326.34,64.47 325.93,64.87 317.4,64.87 316.59,64.06 313.33,64.06 D12.B1
KEY_ST+EX+DP  (via drill 0.61)
  Route2 0.203: v328.37,114.45 320.24,106.32 319.02,106.32 317.81,105.1 316.59,105.1 C12.M1
  Route15 0.203: v328.37,114.45 329.59,114.45 353.16,90.88 357.23,90.88 412.5,35.61 412.5,33.98 414.12,32.36 D04.N1
KEY_ST\  (via drill 0.61)
  Top 0.203: v422.25,25.86 422.25,40.89 418.19,40.89 D04.K1 | C02.A1 443.38,135.99 444.19,135.18 444.19,125.42 444.6,125.02 444.6,117.7 453.95,108.36 453.95,26.67 453.14,25.86 D01.R1
  Bottom 0.203: D01.R1 451.92,25.04 446.63,25.04 D01.R2 445.41,25.04 444.19,23.83 424.28,23.83 v422.25,25.86
KEY_STOP  (via drill 0.61)
  Route2 0.203: v366.57,57.56 399.9,90.88 399.9,91.69 405.18,96.98 405.59,96.98 v417.37,108.76
  Bottom 0.203: v366.57,57.56 364.95,55.93 356.41,55.93 354.79,54.3 D09.E1 | v417.37,108.76 418.59,109.98 441.35,109.98 442.16,110.79 C02.K1
KEY_STOP\
  Route15 0.203: C02.H1 443.38,116.89 443.38,113.64 452.73,104.29 452.73,103.48 453.95,102.26 453.95,30.73 451.51,28.3 449.88,29.92 447.85,29.92 446.63,31.14 D01.N2
L\_ENABLE  (via drill 0.61)
  Top 0.203: v334.87,200.2 336.09,201.42 336.09,217.27 334.87,218.49 334.87,221.74 A10.U2
  Route2 0.203: v319.84,184.76 319.84,185.17 v334.87,200.2
  Bottom 0.203: v319.84,184.76 316.99,184.76 316.59,184.35 B12.H1
L_ENABLE  (via drill 0.61)
  Top 0.203: v341.78,215.24 341.78,221.74 A10.U1
  Route15 0.203: v306.83,216.05 306.83,218.49 A12.V2
  Bottom 0.203: v306.83,216.05 307.24,216.46 321.87,216.46 323.09,215.24 v341.78,215.24
LEFT_SHIFT  (via drill 0.61)
  Top 0.203: v338.53,171.35 338.53,174.19 B10.L1 | v385.27,205.49 386.49,206.7 386.49,220.12 387.3,220.93 387.3,249.78 383.24,253.85 383.24,256.69 AB06.AF2
  Route2 0.203: v385.27,205.49 347.88,168.1 347.88,165.66 B09.P2
  Route15 0.203: v338.53,171.35 344.63,165.25 347.07,165.25 B09.P2
  Bottom 0.203: 381.2,258.32 375.51,258.32 375.11,257.91 371.04,257.91 370.64,257.5 AB07.AF2 | 381.2,258.32 382.02,257.5 AB06.AF2 | 393.8,258.32 394.61,257.5 AB05.AF2 | 381.2,258.32 393.8,258.32 | 393.8,258.32 406.4,258.32 407.21,257.5 AB04.AF2 408.43,257.5 411.28,257.5 412.09,258.32 419.4,258.32 420.22,257.5 AB03.AF2 421.44,257.5 423.88,257.5 424.69,258.32 432,258.32 432.82,257.5 AB02.AF2
LINK  (via drill 0.61)
  Top 0.203: v284.48,127.86 282.85,126.24 282.85,110.39 281.23,108.76 C14.L2 | v344.63,222.56 345.85,221.34 345.85,216.46 343.41,214.02 343.41,203.05 345.85,200.61 345.85,191.67 v345.44,191.26
  Route2 0.203: v284.48,127.86 296.27,139.65 296.27,142.9 314.55,161.19 315.37,161.19 316.59,162.41 317.81,162.41 318.62,163.22 319.84,163.22 321.46,164.85 B11.P2 322.68,165.66 324.31,167.28 324.31,169.32 325.53,170.54 325.53,171.75 345.03,191.26 v345.44,191.26
  Route15 0.203: v344.63,222.56 341.38,225.81 341.38,227.84 A10.S1
LINK\  (via drill 0.61)
  Top 0.203: v312.52,160.38 310.08,160.38 310.08,163.63 310.9,164.44 310.9,203.45 v314.15,206.7 | v338.12,207.92 338.12,218.49 A10.V1
  Route2 0.203: v403.56,275.39 403.56,274.98 369.01,240.44 368.2,240.44 341.78,214.02 341.38,214.02 340.97,213.61 340.97,211.18 338.12,208.33 v338.12,207.92
  Bottom 0.203: v312.52,160.38 313.33,160.38 315.37,162.41 318.62,162.41 B11.R2 | v314.15,206.7 314.55,207.11 327.56,207.11 328.37,207.92 v338.12,207.92 | v403.56,275.39 453.95,275.39 453.95,266.45 455.17,265.23 455.57,265.23 455.57,261.16 A01.E1
LOCK  (via drill 0.61)
  Top 0.203: v244.65,86.82 244.65,83.16 250.34,77.47 250.34,72.59 247.9,70.16 247.9,43.74 250.75,40.89 250.75,25.04 247.9,22.2 247.9,11.23 249.94,11.23 250.75,12.04 250.75,12.45 254.81,12.45 D16.V2
  Route2 0.203: v244.65,86.82 244.65,88.44 269.44,113.23 269.44,115.27 271.07,116.89 C15.H2
LOCK\  (via drill 0.61)
  Top 0.203: v268.22,70.97 267,69.75 267,21.39 263.75,18.14 263.75,14.48 262.53,13.26 D16.V1 | v290.17,78.28 292.2,80.31 292.2,84.38 293.01,85.19 293.01,88.44 C13.T2 294.23,89.26 294.23,89.66 296.27,91.69 C13.S2
  Route15 0.203: C15.L1 274.73,107.14 274.73,105.92 289.76,90.88 291.39,90.88 293.01,89.26 C13.T2
  Bottom 0.203: v268.22,70.97 275.54,78.28 v290.17,78.28
MA00  (via drill 0.61)
  Top 0.203: v368.61,279.04 v368.61,241.25 | v274.32,279.04 272.29,277.01 272.29,156.31 v272.69,155.91
  Route2 0.203: v193.45,145.34 172.31,124.21 170.28,124.21 C23.E2
  Route15 0.203: v299.11,146.96 299.52,146.96 306.83,139.65 308.46,139.65 323.49,124.61 323.49,120.55 326.34,117.7 326.34,115.27 336.09,105.51 336.09,103.89 337.72,102.26 C10.N1 | v272.69,155.91 272.69,155.5 v278.79,149.4
  Bottom 0.203: v193.45,145.34 193.85,145.75 249.94,145.75 254,149.81 278.38,149.81 v278.79,149.4 280.42,147.78 295.45,147.78 295.86,148.18 297.08,148.18 298.3,146.96 v299.11,146.96 | v368.61,241.25 372.26,241.25 AB07.AM2 | v368.61,279.04 367.79,279.86 364.54,279.86 363.73,280.67 334.06,280.67 333.25,279.86 317.4,279.86 316.18,278.64 309.68,278.64 308.46,279.86 286.92,279.86 286.51,279.45 274.73,279.45 v274.32,279.04
MA00\  (via drill 0.61)
  Route2 0.203: v318.62,241.66 308.86,231.9 308.86,230.68 293.42,215.24 293.42,214.83 290.98,212.39 290.98,203.86 B14.A1 290.17,202.64 290.17,200.61 237.34,147.78 236.12,147.78 v213.77,125.42
  Route15 0.203: A35.J1 21.13,250.19 23.98,250.19 27.64,246.53 29.26,246.53 58.12,217.68 60.96,217.68 95.5,183.13 99.16,183.13 134.52,147.78 135.33,147.78 155.25,127.86 155.25,126.24 156.87,124.61 C24.E2
  Bottom 0.203: v318.62,241.66 319.43,242.47 323.09,242.47 323.49,242.06 327.15,242.06 327.56,242.47 377.95,242.47 | 377.95,242.47 378.76,241.66 AB07.AM1 | 377.95,242.47 443.79,242.47 444.6,241.66 448.67,241.66 A01.M2 | v213.77,125.42 213.36,125.02 191.41,125.02 191.01,124.61 190.19,124.61 189.79,125.02 158.5,125.02 157.68,124.21 C24.E2
MA01  (via drill 0.61)
  Top 0.203: v367.79,244.5 368.2,244.91 368.2,278.23 v367.39,279.04 | v266.19,273.36 264.16,271.32 264.16,216.05 266.6,213.61 266.6,200.61 265.38,199.39 265.38,142.9 262.53,140.06 v262.53,114.45
  Route2 0.203: v309.27,79.1 310.49,80.31 320.24,80.31 331.62,91.69 333.25,91.69 333.65,92.1 333.65,92.91 338.94,98.2 340.56,98.2 C10.P1 | v367.79,244.5 369.42,244.5 AB07.AL2
  Route15 0.203: v309.27,79.1 306.83,79.1 302.36,83.57 301.55,83.57 v274.32,110.79
  Bottom 0.203: C24.H2 157.68,116.89 158.5,116.08 167.84,116.08 169.06,117.3 C23.H2 170.28,116.89 172.31,116.89 176.38,112.83 262.53,112.83 | v274.32,110.79 272.29,112.83 262.53,112.83 | v367.39,279.04 366.98,279.45 364.13,279.45 363.32,280.26 334.47,280.26 333.65,279.45 317.81,279.45 316.59,278.23 309.27,278.23 308.05,279.45 287.32,279.45 286.92,279.04 275.54,279.04 274.32,277.83 270.66,277.83 v266.19,273.36 | 262.53,112.83 v262.53,114.45
MA01\  (via drill 0.61)
  Top 0.203: v277.17,201.83 277.57,202.23 277.57,231.9 276.35,233.12 v276.35,244.5
  Route15 0.203: v451.92,246.13 451.92,250.19 A01.J1
  Bottom 0.203: v277.17,201.83 285.7,201.83 286.92,200.61 B14.B1 | A35.L1 21.13,244.91 21.95,245.72 84.12,245.72 84.53,245.31 101.19,245.31 102.01,246.13 194.67,246.13 197.51,243.28 273.91,243.28 275.13,244.5 275.95,244.5 v276.35,244.5 277.57,245.72 370.64,245.72 371.45,244.91 375.51,244.91 AB07.AL1 376.73,244.91 378.76,244.91 379.98,246.13 v451.92,246.13
MA02  (via drill 0.61)
  Top 0.203: v390.14,240.84 387.71,243.28 387.71,250.19 384.05,253.85 384.05,266.04 383.24,266.85 383.24,268.48 388.52,273.76 v388.52,278.23 | v257.25,272.54 255.22,270.51 255.22,141.68 253.19,139.65 253.19,137.62 253.59,137.21 253.59,115.67 v253.19,115.27
  Route2 0.203: v324.31,75.84 327.56,79.1 327.56,82.75 337.72,92.91 337.72,94.54 C10.R1
  Route15 0.203: v324.31,75.84 322.68,75.84 312.93,85.6 312.52,85.6 307.64,90.47 306.83,90.47 296.27,101.04 295.86,101.04 295.05,101.85 295.05,102.26 284.89,112.42 280.82,112.42 v278.38,114.86
  Bottom 0.203: 165.41,119.33 155.25,119.33 154.43,120.14 C24.F2 | 165.41,119.33 166.22,120.14 C23.F2 | v278.38,114.86 277.57,115.67 253.19,115.67 | 253.19,115.67 199.14,115.67 195.48,119.33 165.41,119.33 | v390.14,240.84 386.89,240.84 386.49,241.25 AB06.AM2 | v388.52,278.23 364.54,278.23 362.92,279.86 334.87,279.86 334.06,279.04 318.21,279.04 316.99,277.83 308.86,277.83 307.64,279.04 287.73,279.04 287.32,278.64 275.95,278.64 274.73,277.42 271.48,277.42 266.6,272.54 v257.25,272.54 | v253.19,115.27 253.19,115.67
MA02\  (via drill 0.61)
  Top 0.203: v291.39,215.65 291.8,215.24 291.8,198.17 290.98,197.36 B14.C1 | v345.85,215.24 346.25,215.65 346.25,235.56 v348.29,237.59 | v391.77,239.22 391.77,240.84 AB06.AM1 | v33.33,272.95 25.2,264.82 25.2,264.01 19.51,258.32 19.51,239.62 20.32,238.81 A35.N1 | v264.57,276.2 267.41,276.2 v267.41,238.81
  Route15 0.203: v267.41,238.81 269.85,238.81 288.54,220.12 288.54,218.9 291.39,216.05 v291.39,215.65
  Bottom 0.203: v291.39,215.65 305.61,215.65 306.02,215.24 307.64,215.24 308.46,216.05 321.46,216.05 322.68,214.83 340.97,214.83 341.38,214.43 344.63,214.43 345.44,215.24 v345.85,215.24 | v348.29,237.59 350.32,239.62 391.36,239.62 v391.77,239.22 391.77,239.62 425.09,239.62 425.5,240.03 449.07,240.03 449.07,235.56 A01.P2 | v33.33,272.95 36.98,276.61 129.64,276.61 131.27,278.23 227.18,278.23 229.21,276.2 v264.57,276.2
MA03  (via drill 0.61)
  Top 0.203: v400.71,224.18 403.15,221.74 403.15,196.95 400.3,194.11 v400.3,169.32
  Route2 0.203: D19.E2 221.08,53.49 224.74,53.49 258.47,19.76 295.05,56.34 295.05,57.15 296.27,58.37 297.08,58.37 301.55,62.84 301.55,68.53 303.58,70.56 303.58,74.62 309.68,80.72 313.33,80.72 321.46,88.85 323.49,88.85 327.96,93.32 329.59,93.32 331.22,94.94 C10.R2 332.44,95.76 333.65,96.98 333.65,99.01 343.81,109.17 349.5,109.17 350.32,109.98 351.94,109.98 352.75,110.79 352.75,111.61 353.97,112.83 357.63,112.83 365.35,120.55 365.35,124.61 387.71,146.96 387.71,150.22 400.3,162.81 v400.3,169.32
  Route15 0.203: v400.71,224.18 382.83,242.06 382.83,243.69 AB06.AL2
MA03\  (via drill 0.61)
  Top 0.203: v232.05,132.74 232.05,123.39 234.49,120.95 234.49,55.52 233.68,54.71 D18.E2
  Route2 0.203: v232.05,132.74 232.05,133.15 234.49,135.59 234.49,139.24 281.23,185.98 281.63,185.98 285.29,189.64 285.29,190.86 287.32,192.89 B14.D1 | v377.14,253.44 375.51,253.44 359.26,237.19 358.85,237.19 358.44,236.78 358.44,235.56 345.44,222.56 345.44,222.15 339.34,216.05 335.69,216.05 332.84,213.21 332.03,213.21 329.18,210.36 327.56,210.36 312.93,195.73 v312.93,195.33
  Route15 0.203: v113.79,133.55 63.4,183.95 63.4,184.76 43.08,205.08 41.45,205.08 28.45,218.08 28.45,219.71 20.73,227.43 20.73,231.09 A35.R1 | v377.14,253.44 385.67,244.91 388.52,244.91 AB06.AL1
  Bottom 0.203: AB06.AL1 389.74,244.5 390.96,243.28 403.56,243.28 404.37,244.09 406.4,244.09 407.21,243.28 449.48,243.28 450.7,242.06 450.7,229.06 449.88,229.06 A01.S2 | v113.79,133.55 115.42,131.93 136.96,131.93 139.8,134.77 230.84,134.77 232.05,133.55 232.05,133.15 v232.05,132.74 | v312.93,195.33 289.76,195.33 288.14,193.7 B14.D1
MA04  (via drill 0.61)
  Top 0.203: v235.31,55.93 234.9,55.52 234.9,49.43 233.68,48.21 D18.H2 | v399.49,176.63 399.9,177.04 399.9,200.2 402.74,203.05 402.74,213.21 399.9,216.05 399.9,240.03 399.08,240.84 AB05.AM2 | v404.77,176.22 403.56,175.01 403.56,153.06 399.9,149.4 399.9,134.77 v394.61,129.49
  Route2 0.203: v306.43,54.71 323.49,71.78 323.49,76.25 324.31,77.06 324.31,83.57 332.03,91.29 333.65,91.29 334.06,91.69 334.47,91.69 C10.S2 | v394.61,129.49 376.73,111.61 376.73,110.39 358.85,92.51 358.85,88.85 v356.41,86.41
  Route15 0.203: v338.53,86.82 336.91,88.44 336.91,89.66 335.28,91.29 C10.S2
  Bottom 0.203: D19.H2 221.08,46.99 221.89,46.18 232.05,46.18 232.87,46.99 D18.H2 | v306.43,54.71 306.02,55.12 251.97,55.12 251.56,55.52 235.71,55.52 v235.31,55.93 | v399.49,176.63 399.9,176.22 v404.77,176.22 | v356.41,86.41 355.6,87.22 351.94,87.22 351.13,86.41 349.1,86.41 348.29,87.22 345.03,87.22 344.22,86.41 342.6,86.41 341.78,87.22 338.94,87.22 v338.53,86.82
MA04\  (via drill 0.61)
  Top 0.203: v447.85,242.47 447.85,224.18 449.07,222.96 A01.U2 | AB05.AM1 404.77,242.06 v404.77,243.28 404.77,243.69 403.56,244.91 403.56,272.54 v395.43,280.67 | v96.32,214.83 100.38,210.77 v100.38,200.61 | v272.69,279.86 276.76,279.86 276.76,259.54 279.6,256.69 279.6,222.56 282.45,219.71 282.45,208.33 279.6,205.49 279.6,194.92 280.42,194.11 B14.D2
  Bottom 0.203: v404.77,243.28 405.18,242.88 447.45,242.88 v447.85,242.47 | 168.66,194.92 167.44,193.7 B23.D2 | 168.66,194.92 174.75,194.92 175.16,194.51 178,194.51 178.82,195.33 234.49,195.33 234.9,194.92 238.56,194.92 239.37,194.11 280.42,194.11 B14.D2 | v96.32,214.83 95.1,216.05 23.57,216.05 21.13,218.49 A35.V1 | v100.38,200.61 106.07,194.92 131.27,194.92 132.49,193.7 133.3,193.7 134.52,194.92 168.66,194.92 | v395.43,280.67 365.35,280.67 364.54,281.48 333.25,281.48 332.44,280.67 316.59,280.67 315.37,279.45 310.49,279.45 309.27,280.67 286.11,280.67 285.7,280.26 273.1,280.26 v272.69,279.86
MA05  (via drill 0.61)
  Top 0.203: v396.24,254.25 396.65,253.85 396.65,245.72 395.83,244.91 AB05.AL2 | v227.58,167.69 225.55,165.66 225.55,57.56 230.02,53.09 230.02,51.46 D18.F2
  Route2 0.203: v316.18,257.5 279.2,220.52 279.2,218.49 247.9,187.2 247.09,187.2 v227.58,167.69
  Route15 0.203: v327.96,252.22 325.93,252.22 319.84,258.32 316.99,258.32 v316.18,257.5
  Bottom 0.203: D19.F2 218.24,50.65 219.46,49.43 228.8,49.43 229.62,50.24 D18.F2 | v396.24,254.25 395.02,255.47 344.63,255.47 341.38,252.22 v327.96,252.22
MA05\  (via drill 0.61)
  Top 0.203: v403.56,232.72 403.56,242.06 401.93,243.69 AB05.AL1 402.34,244.91 403.15,245.72 403.15,271.73 v393.39,281.48 | v19.1,279.86 19.1,262.79 17.48,261.16 A35.E2 | v152.4,283.11 152.81,282.7 152.81,197.76 v156.46,194.11 | v281.23,205.89 282.45,204.67 282.45,199.39 282.04,198.98 282.04,194.51 282.45,194.11 282.45,192.89 284.07,191.26 B14.E2 | v177.19,207.11 177.6,206.7 177.6,200.2 173.53,196.14 173.53,194.11 B23.D1 | v271.48,190.86 v271.48,280.67
  Route15 0.203: v403.56,232.72 443.38,192.89 443.38,192.07 449.07,186.38 449.07,184.76 B01.H2
  Bottom 0.203: v19.1,279.86 22.35,283.11 v152.4,283.11 | v156.46,194.11 158.09,192.48 171.5,192.48 172.31,193.29 B23.D1 | v281.23,205.89 280.42,206.7 177.6,206.7 v177.19,207.11 | v393.39,281.48 392.99,281.08 366.17,281.08 365.35,281.89 332.84,281.89 332.03,281.08 316.18,281.08 314.96,279.86 310.9,279.86 309.68,281.08 285.7,281.08 285.29,280.67 v271.48,280.67 | v271.48,190.86 283.67,190.86 B14.E2
MA06  (via drill 0.61)
  Top 0.203: v234.9,232.31 234.9,125.83 233.68,124.61 C18.E2 | v358.04,274.57 358.44,274.17 358.44,266.45 v359.26,265.63 | v412.9,261.98 412.5,261.57 412.5,243.28 411.28,242.06 AB04.AM2
  Route2 0.203: v275.13,272.54 v234.9,232.31
  Bottom 0.203: v275.13,272.54 277.57,274.98 304.39,274.98 305.21,274.17 308.86,274.17 309.27,274.57 325.53,274.57 326.34,275.39 352.75,275.39 353.57,274.57 v358.04,274.57 | v359.26,265.63 360.07,264.82 365.35,264.82 368.2,261.98 v412.9,261.98
MA06\  (via drill 0.61)
  Top 0.203: v424.69,205.49 422.66,207.52 422.66,220.52 422.25,220.93 422.25,234.75 418.19,238.81 418.19,240.84 AB04.AM1
  Route2 0.203: 271.88,177.44 222.71,128.27 222.71,126.64 220.68,124.61 C19.E2 | 271.88,177.44 280.42,185.98 280.42,186.79 B14.F2 | v427.13,171.75 423.47,175.41 v392.18,144.12 | 271.88,177.44 v268.22,177.44
  Route15 0.203: v424.69,205.49 425.91,204.27 425.91,198.98 449.07,175.82 449.07,172.16 B01.M2 | 172.31,170.94 170.28,170.94 B23.M2 | 172.31,170.94 193.45,149.81 193.45,149 216.61,125.83 217.83,125.83 219.86,123.8 C19.E2 | v88.19,252.63 89,252.63 98.75,242.88 100.38,242.88 172.31,170.94 | v332.84,144.53 304.39,172.97 v303.99,172.97
  Bottom 0.203: v88.19,252.63 53.24,252.63 52.83,252.22 19.1,252.22 17.88,253.44 A35.H2 | v427.13,171.75 428.35,172.97 447.45,172.97 448.67,171.75 B01.M2 | v392.18,144.12 391.77,144.53 353.16,144.53 351.94,143.31 345.85,143.31 344.22,144.93 333.25,144.93 v332.84,144.53 | v303.99,172.97 303.58,173.38 281.63,173.38 280.42,172.16 279.2,172.16 273.91,177.44 v268.22,177.44
MA07  (via drill 0.61)
  Top 0.203: v216.61,222.56 216.21,222.15 216.21,123.8 220.27,119.74 220.27,118.11 C19.H2
  Route2 0.203: v402.74,241.66 403.56,242.47 405.18,242.47 406.81,244.09 407.21,244.09 AB04.AL2 | v287.32,283.52 277.57,283.52 v216.61,222.56
  Route15 0.203: v402.74,241.66 402.34,241.66 370.23,273.76 370.23,274.17 369.82,274.57 361.7,274.57 360.07,276.2 331.22,276.2 v324.31,283.11
  Bottom 0.203: C19.H2 221.08,116.89 221.89,116.08 232.05,116.08 232.87,116.89 C18.H2 | v324.31,283.11 308.05,283.11 307.24,283.92 287.73,283.92 v287.32,283.52
MA07\  (via drill 0.61)
  Top 0.203: v445.41,205.89 445.41,205.08 450.7,199.8 450.7,166.88 449.48,165.66 B01.P2 | v421.84,213.21 421.84,222.56 419.4,224.99 419.4,230.28 415.75,233.93 415.75,242.47 414.53,243.69 AB04.AL1 414.93,244.91 415.75,245.72 v415.75,278.23 | v269.85,278.23 269.44,277.83 v269.44,187.6
  Route15 0.203: v91.44,252.63 106.07,238 107.7,238 169.06,176.63 170.69,176.63 172.31,175.01 B23.L1
  Bottom 0.203: v445.41,205.89 443.79,207.52 427.53,207.52 v421.84,213.21 | v91.44,252.63 88.59,255.47 54.86,255.47 52.02,252.63 35.76,252.63 32.92,255.47 7.72,255.47 7.72,254.25 13.01,248.97 15.44,248.97 16.66,247.75 A35.K2 | 269.44,182.73 197.92,182.73 191.01,175.82 174.35,175.82 173.53,175.01 B23.L1 | 269.44,182.73 282.85,182.73 283.67,183.54 B14.H2 | v415.75,278.23 414.12,279.86 368.61,279.86 368.2,280.26 364.95,280.26 364.13,281.08 333.65,281.08 332.84,280.26 316.99,280.26 315.77,279.04 310.08,279.04 308.86,280.26 286.51,280.26 286.11,279.86 273.91,279.86 272.29,278.23 v269.85,278.23 | 269.44,182.73 v269.44,187.6
MA08  (via drill 0.61)
  Top 0.203: v313.74,282.3 314.15,281.89 314.15,264.82 313.33,264.01 A12.D1 | v414.93,281.08 416.97,281.08 422.66,275.39 422.66,242.88 423.47,242.06 AB03.AM2 | v228.4,207.92 228.4,122.99 230.02,121.36 C18.F2
  Route2 0.203: v228.4,207.92 228.8,207.92 277.17,256.29 277.98,256.29 293.01,271.32 297.49,271.32 302.36,276.2 308.05,276.2 313.74,281.89 v313.74,282.3
  Bottom 0.203: C19.F2 218.24,120.55 219.46,119.33 228.8,119.33 229.62,120.14 C18.F2 | v313.74,282.3 330.81,282.3 331.62,283.11 368.61,283.11 369.01,282.7 383.24,282.7 383.64,283.11 412.9,283.11 v414.93,281.08
MA08\  (via drill 0.61)
  Top 0.203: v442.57,160.38 440.94,158.75 440.94,144.93 438.91,142.9 437.69,142.9 437.69,150.62 438.1,151.03 438.1,199.8 434.44,203.45 434.44,218.08 434.85,218.49 434.85,221.74 431.6,224.99 431.6,240.03 430.78,240.84 AB03.AM1
  Bottom 0.203: A35.M2 17.88,241.66 18.69,242.47 267.82,242.47 270.26,240.03 424.69,240.03 425.5,240.84 429.56,240.84 AB03.AM1 | v442.57,160.38 445.82,160.38 445.82,156.31 B01.T2
MA09  (via drill 0.61)
  Top 0.203: v169.06,114.45 165.41,110.79 165.41,91.69 156.06,82.35 156.06,72.59 158.5,70.16 158.5,55.93 157.28,54.71 D24.E2
  Route2 0.203: v169.06,114.45 184.91,130.3 184.91,130.71 185.32,131.12 186.94,131.12 194.26,138.43 195.88,138.43 265.79,208.33 265.79,209.14 266.19,209.55 266.19,216.05 275.95,225.81 277.17,225.81 299.52,248.16 300.74,248.16 306.83,254.25 307.64,254.25 318.21,264.82 323.49,264.82 329.59,270.92 330.81,270.92 331.22,271.32 336.09,271.32 339.75,274.98 349.5,274.98 352.75,271.73 360.88,271.73 v364.54,275.39
  Route15 0.203: v389.33,275.39 391.77,275.39 419,248.16 419,246.13 420.22,244.91 AB03.AL2
  Bottom 0.203: v364.54,275.39 v389.33,275.39
MA09\  (via drill 0.61)
  Top 0.203: v295.86,7.16 279.2,23.83 v279.2,56.74
  Route2 0.203: v400.71,9.6 451.1,60 451.1,64.06 454.36,67.31 454.36,118.11 455.17,118.92 455.17,123.39 C01.E1
  Route15 0.203: v451.92,221.74 431.19,242.47 429.16,242.47 427.53,244.09 AB03.AL1 | D23.E2 169.47,54.71 169.47,57.15 v167.84,58.78 115.01,111.61 115.01,113.23 92.25,135.99 92.25,139.24 80.87,150.62 80.87,156.72 60.55,177.04 60.55,181.1 36.58,205.08 36.58,206.3 24.38,218.49 24.38,219.71 19.51,224.59 19.51,232.72 17.88,234.34 A35.P2
  Bottom 0.203: v451.92,221.74 453.14,220.52 454.36,220.52 454.36,129.49 455.17,128.68 455.57,128.68 455.57,124.61 C01.E1 | v400.71,9.6 398.27,7.16 352.35,7.16 351.94,6.76 318.21,6.76 316.99,7.98 296.67,7.98 v295.86,7.16 | v279.2,56.74 279.2,58.78 v167.84,58.78
MA10  (via drill 0.61)
  Top 0.203: v364.95,273.36 365.76,274.17 365.76,280.67 332.03,280.67 v332.03,273.76 | v184.51,144.53 184.1,144.12 184.1,84.38 171.09,71.37 171.09,49.02 170.28,48.21 D23.H2
  Route2 0.203: v398.68,281.48 396.65,283.52 393.8,280.67 372.26,280.67 v364.95,273.36 | v332.03,273.76 331.22,273.76 329.18,271.73 325.12,271.73 324.31,270.92 322.27,270.92 319.84,268.48 313.33,268.48 281.63,236.78 278.79,236.78 245.87,203.86 243.84,203.86 v184.51,144.53
  Route15 0.203: v398.68,281.48 436.47,243.69 436.47,242.06 AB02.AM2
  Bottom 0.203: D24.H2 157.68,46.99 158.5,46.18 167.84,46.18 169.06,47.4 D23.H2
MA10\  (via drill 0.61)
  Top 0.203: v447.85,219.3 444.19,222.96 444.19,240.03 443.38,240.84 AB02.AM1
  Route2 0.203: v447.85,219.3 453.95,213.21 453.95,120.14 452.73,118.92 452.73,114.86 C01.J1 | v323.09,19.36 325.93,16.51 341.38,31.95 342.6,31.95 417.78,107.14 v417.78,107.54
  Route15 0.203: v41.86,229.87 45.11,229.87 57.71,217.27 58.93,217.27 102.01,174.19 102.01,173.79 128.02,147.78 129.64,147.78 206.04,71.37 206.04,66.5 v252.37,20.17
  Bottom 0.203: v41.86,229.87 18.69,229.87 17.88,229.06 A35.S2 | v252.37,20.17 252.78,20.57 319.43,20.57 320.65,19.36 v323.09,19.36 | v417.78,107.54 419.4,109.17 428.75,109.17 431.19,106.73 447.04,106.73 452.32,112.01 452.32,113.64 C01.J1
MA11  (via drill 0.61)
  Top 0.203: v426.72,267.26 431.6,262.38 431.6,246.13 432.82,244.91 AB02.AL2 | v183.29,115.67 183.69,115.27 183.69,88.85 168.66,73.81 168.66,53.09 167.03,51.46 D23.F2
  Route2 0.203: v426.72,267.26 420.22,273.76 418.19,271.73 408.43,271.73 403.56,276.61 399.9,272.95 399.9,272.54 399.08,271.73 374.7,271.73 370.64,267.67 369.82,267.67 345.44,243.28 340.97,243.28 325.12,227.43 v324.71,227.43 | v308.86,237.59 308.46,237.59 303.58,232.72 303.17,232.72 288.14,217.68 284.07,217.68 216.21,149.81 216.21,148.59 v183.29,115.67
  Route15 0.203: v324.71,227.43 319.02,227.43 v308.86,237.59
  Bottom 0.203: D24.F2 154.43,50.24 155.25,49.43 165.41,49.43 166.22,50.24 D23.F2
MA11\  (via drill 0.61)
  Top 0.203: v453.54,115.67 453.95,116.08 453.95,201.83 v452.73,203.05 | v440.13,214.02 438.51,215.65 438.51,242.47 | 438.51,242.47 439.73,243.69 AB02.AL1 | v291.39,238.81 291.8,239.22 291.8,259.54 301.95,269.7 v301.95,270.51 | v374.7,270.51 387.71,283.52 438.51,283.52 438.51,242.47
  Route2 0.203: v170.69,205.49 182.07,205.49 191.82,215.24 192.63,215.24 193.45,216.05 198.32,216.05 v219.86,237.59 | v351.54,248.16 352.35,248.16 v374.7,270.51
  Route15 0.203: v301.95,270.51 304.39,270.51 310.49,276.61 315.37,271.73 321.46,271.73 324.71,268.48 330.4,268.48 336.09,262.79 336.91,262.79 v351.54,248.16
  Bottom 0.203: v453.54,115.67 453.95,115.67 453.95,107.54 449.88,103.48 448.26,103.48 446.63,101.85 C01.N2 | v452.73,203.05 449.07,206.7 447.45,206.7 v440.13,214.02 | v170.69,205.49 108.1,205.49 107.7,205.08 3.66,205.08 3.66,213.21 5.28,214.83 5.69,214.83 11.38,220.52 15.04,220.52 16.66,222.15 A35.U2 | v219.86,237.59 221.89,239.62 290.58,239.62 v291.39,238.81
MA_ENABLE(0-4)  (via drill 0.61)
  Top 0.203: v358.85,216.05 358.85,235.15 358.44,235.56 358.44,249.38 357.63,250.19 A08.J2 | v390.96,214.43 390.96,166.47 391.77,165.66 AB06.BP1
  Route15 0.203: AB06.BR2 382.02,162.41 381.61,162.41 379.58,164.44 AB07.BP1
  Bottom 0.203: AB07.BR2 370.64,162 371.86,163.22 381.2,163.22 382.02,162.41 AB06.BR2 | 390.14,166.47 380.8,166.47 379.98,165.66 AB07.BP1 | 390.14,166.47 391.36,165.25 AB06.BP1 | 390.14,166.47 403.56,166.47 404.37,165.66 AB05.BP1 | v358.85,216.05 359.26,216.46 388.93,216.46 v390.96,214.43
MA_ENABLE(5-11)  (via drill 0.61)
  Top 0.203: AB04.BP1 418.19,164.85 420.22,162.81 420.22,162.41 AB03.BR2 | v393.8,223.37 393.8,163.22 394.61,162.41 AB05.BR2
  Route15 0.203: v345.85,247.75 344.63,248.97 344.63,250.19 A09.J2 | v371.45,246.13 371.45,245.72 v393.8,223.37
  Bottom 0.203: AB02.BP1 442.16,165.25 440.94,166.47 431.6,166.47 430.78,165.66 AB03.BP1 429.56,165.25 428.35,166.47 419.4,166.47 418.19,165.25 AB04.BP1 | AB02.BR2 432.82,162.41 432,163.22 422.66,163.22 421.44,162 AB03.BR2 420.22,162.41 419.4,163.22 405.99,163.22 | 405.99,163.22 396.65,163.22 395.83,162.41 AB05.BR2 | 405.99,163.22 407.21,162 AB04.BR2 | v345.85,247.75 345.85,246.13 v371.45,246.13
MA_LOAD  (via drill 0.61)
  Top 0.203: v367.39,162.81 367.39,159.97 366.98,159.56 B08.S1 | v405.18,200.61 405.59,201.02 405.59,201.83 405.99,202.23 405.99,246.13 405.18,246.94 AB05.AK1
  Route2 0.203: v367.39,162.81 v405.18,200.61
  Bottom 0.203: AB02.AK1 442.16,247.75 440.94,248.97 431.6,248.97 430.78,248.16 AB03.AK1 429.56,248.16 428.75,248.97 420.62,248.97 419.4,247.75 418.19,247.75 AB04.AK1 416.97,248.16 416.15,248.97 406.81,248.97 | AB07.AK1 379.98,248.16 380.8,248.97 390.14,248.97 391.36,247.75 AB06.AK1 392.58,248.16 393.39,248.97 406.81,248.97 | 406.81,248.97 405.59,247.75 AB05.AK1
MANUAL_PRESET\  (via drill 0.61)
  Top 0.203: v329.59,44.55 330,44.96 330,52.68 329.18,53.49 D11.E1 | v387.3,112.01 387.3,87.63 386.08,86.41 C06.U2 385.67,85.19 385.67,68.94 v384.45,67.72 | v413.31,146.56 412.9,146.15 412.9,128.27 413.71,127.46 C04.D1
  Route2 0.203: v334.87,179.88 334.87,179.48 333.65,178.26 333.65,177.44 332.03,175.82 330.81,175.82 330.4,175.41 330.4,171.35 319.84,160.78 315.77,160.78 308.05,153.06 308.05,151.44 v308.86,150.62 | C04.D1 414.53,126.24 414.53,122.99 417.78,119.74 412.9,114.86 412.9,112.83 411.68,111.61 C04.K2 | v359.26,42.52 359.26,42.93 384.05,67.72 v384.45,67.72
  Route15 0.203: v329.59,44.55 332.44,41.71 334.47,41.71 D10.K2 | B11.U2 322.68,151.84 322.68,149.81 324.71,147.78 327.56,147.78 351.13,124.21 351.13,123.8 353.57,121.36 353.57,118.92 351.94,117.3 356.41,112.83 358.04,112.83 359.66,111.2 C08.K2 | v413.31,146.56 369.82,190.04 367.39,190.04 B08.E1
  Bottom 0.203: 387.3,112.42 402.34,112.42 402.74,112.01 403.96,112.01 404.37,112.42 409.25,112.42 410.46,111.2 C04.K2 | 387.3,112.42 361.7,112.42 360.88,111.61 C08.K2 | v334.87,179.88 334.06,179.88 332.84,178.66 329.59,178.66 329.18,178.26 B11.K1 | v308.86,150.62 309.27,151.03 318.21,151.03 319.43,152.25 321.46,152.25 B11.U2 | 387.3,112.42 v387.3,112.01 | v359.26,42.52 356.41,42.52 356.01,42.93 336.91,42.93 335.69,41.71 D10.K2
MB00  (via drill 0.61)
  Top 0.203: v252.37,207.52 252.78,207.92 v252.78,214.02
  Route2 0.203: v252.37,207.52 182.88,138.02 182.07,138.02 155.25,111.2 155.25,107.14 115.01,66.9 113.39,66.9 D28.A1 | v252.78,214.02 271.07,232.31 271.07,236.78 302.36,268.07 303.58,268.07 v304.8,269.29 | v359.66,223.77 360.07,223.77 360.88,224.59 362.51,224.59 363.73,223.37 v364.95,224.59
  Route15 0.203: v304.8,269.29 305.61,268.48 316.18,268.48 358.44,226.21 358.44,224.99 v359.66,223.77
  Bottom 0.203: v364.95,224.59 365.35,224.99 369.42,224.99 AB07.AT2
MB00\  (via drill 0.61)
  Top 0.203: v168.66,281.89 168.66,265.63 167.03,264.01 A23.D2 | v279.6,282.7 284.07,278.23 v284.07,276.2 | v359.26,274.98 361.7,274.98 361.7,244.09 362.1,243.69 v362.1,241.66
  Route2 0.203: v373.48,226.62 373.48,222.96 AB07.AU2
  Route15 0.203: v362.1,241.66 371.04,232.72 371.04,229.06 371.86,228.24 371.86,227.84 373.07,226.62 v373.48,226.62
  Bottom 0.203: v373.48,226.62 374.29,227.43 394.21,227.43 396.65,229.87 445.82,229.87 448.26,227.43 450.29,227.43 453.95,231.09 453.95,246.94 449.48,246.94 A01.K2 | v168.66,281.89 169.06,281.48 182.47,281.48 183.69,282.7 237.74,282.7 238.15,283.11 279.2,283.11 v279.6,282.7 | v284.07,276.2 284.89,275.39 304.8,275.39 305.61,274.57 308.46,274.57 308.86,274.98 325.12,274.98 325.93,275.79 358.44,275.79 v359.26,274.98
MB01  (via drill 0.61)
  Route2 0.203: v309.68,257.5 309.27,257.5 303.99,252.22 299.52,252.22 286.11,238.81 286.11,238.4 284.07,236.37 283.26,236.37 273.91,227.03 273.1,227.03 269.04,222.96 266.19,222.96 241.4,198.17 238.96,198.17 185.32,144.53 185.32,143.71 122.73,81.13 122.73,79.91 110.95,68.12 110.95,66.9 110.13,66.09 110.13,64.06 D28.B1 | v359.26,214.02 360.88,215.65 361.7,215.65 363.73,217.68 364.13,217.68 371.04,224.59 371.04,225.81 373.07,227.84 AB07.AS2
  Route15 0.203: v309.68,257.5 310.49,257.5 312.12,255.88 316.18,255.88 353.16,218.9 353.16,218.49 353.57,218.08 354.79,218.08 358.85,214.02 v359.26,214.02
MB01\  (via drill 0.61)
  Top 0.203: v171.91,282.3 171.91,264.82 172.72,264.01 A23.D1 | v306.02,282.7 v306.02,275.39
  Route2 0.203: v414.12,254.66 384.86,225.4 382.02,228.24 379.98,228.24 AB07.AS1
  Route15 0.203: v397.05,275.79 397.05,271.32 413.71,254.66 v414.12,254.66
  Bottom 0.203: v414.12,254.66 414.93,255.47 454.36,255.47 455.17,254.66 A01.H1 | v171.91,282.3 172.72,283.11 209.7,283.11 210.51,283.92 225.96,283.92 226.77,283.11 237.34,283.11 237.74,283.52 284.48,283.52 285.29,282.7 291.8,282.7 292.2,282.3 305.61,282.3 v306.02,282.7 | v306.02,275.39 324.71,275.39 325.53,276.2 360.07,276.2 360.88,275.39 363.32,275.39 364.13,276.2 396.65,276.2 v397.05,275.79
MB02  (via drill 0.61)
  Top 0.203: v283.67,206.3 285.7,208.33 v285.7,228.24 | v382.83,228.65 382.83,226.21 AB06.AT2
  Route2 0.203: v283.67,206.3 274.73,197.36 273.51,197.36 273.1,196.95 273.1,196.54 214.58,138.02 213.77,138.02 159.72,83.97 147.12,83.97 114.2,51.05 110.13,51.05 D28.F1
  Bottom 0.203: v285.7,228.24 287.32,229.87 319.02,229.87 319.43,229.46 321.46,229.46 321.87,229.87 376.33,229.87 376.73,229.46 378.36,229.46 378.76,229.87 381.61,229.87 v382.83,228.65
MB02\  (via drill 0.61)
  Top 0.203: v173.53,259.94 173.53,260.35 171.5,260.35 168.66,257.5 168.66,246.94 169.88,245.72 169.88,242.06 A23.M2 | v292.61,283.11 305.21,283.11 305.61,283.52 320.24,283.52 320.24,281.08 v326.75,274.57
  Route2 0.203: v398.27,232.72 388.11,222.56 386.49,222.56 AB06.AU2 | v259.69,259.13 259.28,259.54 277.57,277.83 287.32,277.83 v292.61,283.11
  Route15 0.203: v352.35,273.36 352.35,270.92 358.44,264.82 359.66,264.82 374.7,249.78 374.7,248.56 v386.08,237.19
  Bottom 0.203: 399.08,233.53 v398.27,232.72 | 399.08,233.53 439.32,233.53 443.79,238 445.41,238 A01.N2 | v173.53,259.94 174.35,259.13 v259.69,259.13 | v326.75,274.57 327.15,274.98 350.72,274.98 v352.35,273.36 | v386.08,237.19 389.74,233.53 399.08,233.53
MB03  (via drill 0.61)
  Top 0.203: v332.44,110.39 332.03,109.98 332.03,108.76 C10.L2 | v382.83,189.64 384.45,191.26 384.45,226.62 385.67,227.84 AB06.AS2 | v329.59,189.23 330,188.82 330,139.24 329.59,138.84 329.59,137.62 330,137.21 330,110.39 v327.56,107.95
  Route2 0.203: v163.78,70.16 130.05,36.42 118.67,36.42 117.45,35.2 113.39,35.2 D28.M1 | v294.23,78.28 294.23,78.69 299.52,83.97 304.39,83.97 312.93,92.51 314.15,92.51 321.46,99.82 322.27,99.82 323.9,101.45 323.9,102.26 328.78,107.14 330.81,107.14 331.22,107.54 C10.L2
  Route15 0.203: v332.44,110.39 332.84,110.39 343.81,99.42 343.81,97.38 344.22,96.98 344.22,95.76 C09.R2
  Bottom 0.203: v163.78,70.16 254.81,70.16 255.63,70.97 259.69,70.97 260.5,70.16 286.11,70.16 v294.23,78.28 | v382.83,189.64 382.42,189.23 v329.59,189.23 | v327.56,107.95 331.22,107.95 C10.L2
MB03\  (via drill 0.61)
  Top 0.203: v110.95,123.39 110.95,110.79 114.61,107.14 114.61,49.84 112.98,48.21 D28.H1 | v327.15,124.61 327.15,112.42 327.96,111.61 C11.K1 | v288.54,128.27 288.54,166.88 287.73,167.69 B14.N1 | v180.44,243.28 190.6,243.28 190.6,222.56 203.61,209.55 203.61,196.95 212.95,187.6 212.95,175.01 v215.39,172.57 | v8.53,254.66 6.5,256.69 6.5,263.2 2.03,263.2 A36.D2 | v171.91,249.38 172.31,248.97 172.31,244.91 A23.L1 | v390.96,216.86 390.96,227.03 391.77,227.84 AB06.AS1 | v338.94,216.86 339.34,216.46 339.34,139.24 338.94,138.84 338.94,134.77 339.34,134.37 v339.34,125.83 | v66.24,249.38 66.24,199.39 65.02,198.17 65.02,137.21 66.24,135.99 66.24,121.77 67.46,121.77 67.87,122.17 67.87,123.39 C31.E2
  Bottom 0.203: v110.95,123.39 109.32,125.02 69.49,125.02 | 69.49,125.02 68.68,124.21 C31.E2 | 69.49,125.02 54.46,125.02 52.83,126.64 C32.D2 | AB06.AS1 392.58,229.06 393.8,230.28 444.19,230.28 445.41,231.5 A01.R2 | C13.D1 299.52,127.46 298.7,128.27 v288.54,128.27 286.11,128.27 284.48,126.64 284.07,126.64 283.67,126.24 283.67,125.02 327.15,125.02 v327.15,124.61 327.56,125.02 330,125.02 331.22,123.8 334.47,123.8 C10.E2 335.69,124.21 337.72,124.21 v339.34,125.83 | v180.44,243.28 174.35,243.28 173.53,244.09 A23.L1 | v215.39,172.57 218.24,169.72 286.11,169.72 286.92,168.91 B14.N1 | v8.53,254.66 13.82,249.38 v66.24,249.38 75.59,249.38 76.4,248.56 105.26,248.56 106.07,249.38 v171.91,249.38 | v338.94,216.86 v390.96,216.86
MB04  (via drill 0.61)
  Top 0.203: v343.81,27.89 345.85,25.86 345.85,13.26 350.32,13.26 D09.V1 350.72,12.04 350.72,5.13 v349.91,4.32 | v330.4,29.52 330,29.92 330,42.11 326.75,45.36 326.75,51.46 327.15,51.87 327.15,64.47 325.12,66.5 325.12,67.31 326.34,68.53 326.34,81.53 327.15,82.35 v327.15,94.54 | v315.37,101.45 314.55,102.26 314.55,116.08 315.37,116.89 C12.H1 | v110.95,4.32 104.44,10.82 104.44,13.26 102.01,15.7 102.01,26.26 104.85,29.11 104.85,54.71 103.23,56.34 D28.D2
  Route2 0.203: v408.03,209.55 408.03,202.23 406.81,201.02 406.81,195.73 358.44,147.37 358.44,145.75 349.1,136.4 349.1,135.99 345.03,131.93 340.97,131.93 333.65,124.61 333.65,124.21 331.22,121.77 330.81,121.77 v328.37,119.33
  Route15 0.203: v327.15,94.54 324.71,92.1 320.24,96.57 319.43,96.57 317.81,98.2 317.81,99.01 v315.37,101.45 | v408.03,209.55 395.83,221.74 395.83,224.99 AB05.AT2
  Bottom 0.203: v343.81,27.89 343,27.08 332.84,27.08 v330.4,29.52 | v110.95,4.32 111.35,4.72 297.89,4.72 298.3,4.32 332.44,4.32 333.25,5.13 334.06,5.13 334.47,4.72 349.5,4.72 v349.91,4.32 | v328.37,119.33 322.68,119.33 321.87,120.14 320.65,120.14 318.21,117.7 316.59,117.7 C12.H1
MB04\  (via drill 0.61)
  Top 0.203: D09.S1 353.97,23.01 352.35,24.64 352.35,28.3 349.1,31.55 349.1,45.77 347.88,46.99 D09.H2 | v67.87,243.69 69.49,242.06 69.49,140.87 67.06,138.43 v67.06,122.58 | v105.26,83.16 105.26,72.59 107.7,70.16 107.7,33.98 109.32,32.36 D28.N1 | v394.61,204.67 394.21,205.08 394.21,213.21 396.65,215.65 396.65,220.52 397.87,221.74 AB05.AU2 | v251.97,142.09 253.59,143.71 253.59,162.81 v254,162.81
  Route2 0.203: v166.62,151.03 165.81,151.03 154.84,140.06 154.84,138.02 122.33,105.51 122.33,103.89 108.1,89.66 108.1,85.6 105.66,83.16 v105.26,83.16 | v394.61,204.67 394.61,203.45 383.64,192.48 382.02,192.48 381.61,192.07 381.61,190.45 v360.07,168.91 | v313.74,166.47 307.24,159.97 307.24,159.56 293.83,146.15 293.83,145.75 v291.39,143.31
  Route15 0.203: v105.26,83.16 105.26,83.97 67.06,122.17 v67.06,122.58 | v254,162.81 256.44,160.38 256.44,137.62 267,127.05 267,126.24 268.63,124.61 268.63,122.17 295.45,95.35 295.45,91.29 306.83,79.91 309.68,79.91 310.49,79.1 308.46,77.06 308.46,73 308.86,72.59 308.86,71.78 325.53,55.12 329.59,55.12 331.22,53.49 332.84,53.49 344.22,42.11 347.47,45.36 347.47,46.99 D09.H2
  Bottom 0.203: AB05.AU2 399.08,222.56 399.9,223.37 403.96,223.37 404.77,224.18 429.97,224.18 430.78,223.37 432.82,223.37 433.22,222.96 435.25,222.96 436.47,224.18 444.6,224.18 445.41,224.99 A01.T2 | C32.E1 62.59,123.39 63.4,122.58 v67.06,122.58 70.71,122.58 71.53,123.39 73.97,123.39 C31.E1 | v67.87,243.69 67.46,243.28 17.88,243.28 5.69,255.47 4.88,255.47 4.88,259.54 A36.E2 | 252.78,164.03 251.97,163.22 213.77,163.22 213.36,162.81 212.14,162.81 211.73,163.22 195.48,163.22 183.29,151.03 v166.62,151.03 | 252.78,164.03 255.22,166.47 288.54,166.47 289.76,165.25 B14.P1 | 252.78,164.03 v254,162.81 | v360.07,168.91 359.26,169.72 349.5,169.72 346.66,166.88 341.38,166.88 340.97,166.47 332.44,166.47 332.03,166.88 314.15,166.88 v313.74,166.47 | v291.39,143.31 290.98,143.71 277.17,143.71 275.95,142.49 252.37,142.49 v251.97,142.09
MB05  (via drill 0.61)
  Top 0.203: v258.06,104.7 258.47,105.1 258.47,123.39 258.06,123.8 258.06,183.13 v257.66,183.54 257.25,183.54 257.25,227.84 258.06,228.65 258.06,277.01 v254.81,280.26 | v393.8,224.59 393.8,228.24 397.87,228.24 AB05.AS2 | v327.56,227.43 327.96,227.03 v327.96,223.77 | v299.92,223.77 299.92,219.71 A13.V1
  Route2 0.203: v158.5,40.08 158.5,44.55 197.92,83.97 215.8,83.97 v229.21,97.38 | v295.86,219.71 295.86,219.3 294.23,217.68 291.8,217.68 v257.66,183.54
  Route15 0.203: v356.41,223.37 355.6,223.37 v351.54,227.43
  Bottom 0.203: v158.5,40.08 107.7,40.08 106.88,40.89 D28.K2 | v229.21,97.38 235.31,103.48 258.06,103.48 | 258.06,103.48 288.54,103.48 289.76,104.7 C14.M1 | v295.86,219.71 299.52,219.71 A13.V1 | v258.06,104.7 258.06,103.48 | v393.8,224.59 392.99,223.77 385.27,223.77 384.45,222.96 380.8,222.96 379.98,223.77 362.51,223.77 361.7,224.59 358.04,224.59 356.82,223.37 v356.41,223.37 | v351.54,227.43 345.44,227.43 345.03,227.84 342.6,227.84 342.19,227.43 v327.56,227.43 | v327.96,223.77 321.87,223.77 321.46,223.37 316.59,223.37 316.18,223.77 v299.92,223.77 | v254.81,280.26 96.32,280.26 95.1,279.04 3.25,279.04 3.25,263.2 2.44,262.38 1.63,262.38 1.63,257.91 A36.F2
MB05\  (via drill 0.61)
  Top 0.203: 286.11,167.28 287.32,166.06 287.32,162.41 B14.R1 | 286.11,167.28 286.11,204.27 288.54,206.7 v288.54,207.11 | v304.39,207.11 304.39,227.03 303.58,227.84 A13.S1 | 104.44,83.57 104.44,56.34 106.07,54.71 D28.E2 | 104.44,83.57 v102.82,85.19 | 286.11,167.28 282.85,167.28 282.85,153.87 v280.01,151.03 | v119.48,146.96 114.61,142.09 114.61,129.08 104.44,118.92 104.44,83.57 | v393.39,269.7 393.8,269.29 393.8,262.79 400.3,256.29 400.3,229.06 404.37,229.06 AB05.AS1
  Route2 0.203: v393.39,269.7 393.39,266.04 392.58,265.23 387.3,265.23 380.8,258.72 379.98,258.72 364.54,243.28 361.29,243.28 360.48,242.47 359.66,242.47 356.01,238.81 356.01,234.75 344.63,223.37 344.22,223.37 341.78,220.93 339.75,220.93 v338.94,221.74
  Route15 0.203: AB05.AS1 405.18,227.84 405.18,226.21 413.71,217.68 415.34,217.68 426.72,206.3 426.72,204.67 442.16,189.23 443.79,189.23 445.41,187.6 B01.F2 | v102.82,85.19 102.41,85.19 68.68,118.92 67.46,118.92 65.84,120.55 C31.F2 | v338.94,221.74 334.06,226.62 v333.65,226.62
  Bottom 0.203: v288.54,207.11 288.95,206.7 303.99,206.7 v304.39,207.11 | C32.F1 59.33,120.14 64.62,120.14 C31.F2 | v280.01,151.03 279.2,150.22 247.9,150.22 244.65,146.96 v119.48,146.96 | v333.65,226.62 320.65,226.62 319.43,227.84 316.99,227.84 316.59,227.43 307.24,227.43 306.43,228.24 303.99,228.24 A13.S1
MB06  (via drill 0.61)
  Top 0.203: 288.95,247.34 288.95,207.92 289.36,207.52 289.36,181.51 v289.76,181.1 | 288.95,247.34 288.95,255.47 287.73,256.69 A14.F1 | v406.81,281.89 406.81,227.03 407.62,226.21 AB04.AT2 | v284.89,281.48 285.29,281.08 285.29,257.1 282.85,254.66 282.85,253.44 288.95,247.34 | v85.34,27.08 85.75,27.48 85.75,119.74 v86.16,120.14 | v347.47,2.29 349.91,2.29 351.54,3.91 351.54,4.32 355.19,7.98 355.19,14.48 354.38,15.29 D09.U1 | v238.15,3.5 121.92,3.5 121.92,4.72 115.42,11.23 104.85,11.23 104.85,23.01 103.23,24.64 D28.R2
  Route2 0.203: v289.76,181.1 289.36,181.1 280.42,172.16 278.79,172.16 254.81,148.18 253.59,148.18 202.39,96.98 189.38,96.98 157.68,65.28 141.02,65.28 104.85,29.11 104.85,27.08 103.63,25.86 D28.R2
  Bottom 0.203: v289.76,181.1 293.01,181.1 B13.J2 | v406.81,281.89 405.99,282.7 384.05,282.7 383.64,282.3 368.61,282.3 368.2,282.7 332.03,282.7 331.22,281.89 314.55,281.89 314.15,281.48 v284.89,281.48 | v85.34,27.08 86.16,26.26 88.59,26.26 89,26.67 101.19,26.67 102.41,25.45 D28.R2 | v86.16,120.14 86.16,122.17 73.15,122.17 71.93,120.95 C31.F1 | v347.47,2.29 346.66,1.47 298.3,1.47 297.08,2.69 275.54,2.69 274.73,1.88 239.78,1.88 v238.15,3.5
MB06\  (via drill 0.61)
  Top 0.203: v102.01,113.23 102.01,56.34 104.44,53.9 104.44,40.08 103.23,38.86 D28.L2 102.82,37.64 101.6,36.42 101.6,12.45 111.76,2.29 242.21,2.29 242.21,5.13 246.69,9.6 v246.69,11.63 | v61.37,149.4 63.4,147.37 63.4,119.33 62.18,118.11 C32.H1 | v417.78,214.02 414.53,217.27 411.28,217.27 411.28,221.74 AB04.AU2 | 273.51,75.44 v274.32,74.62 | 273.51,75.44 273.51,84.38 274.73,85.6 274.73,86.82 273.51,88.04 273.51,111.2 276.35,114.05 276.35,137.21 277.98,138.84 279.6,138.84 279.6,150.22 279.2,150.62 279.2,151.84 282.45,155.09 282.45,159.97 281.23,161.19 B14.R2 | v313.74,164.85 311.3,164.85 311.3,164.03 310.49,163.22 310.49,162 v311.3,161.19 | v269.44,11.63 273.51,15.7 273.51,52.27 274.32,53.09 274.32,55.52 273.51,56.34 273.51,75.44
  Route2 0.203: v436.88,162.81 445.41,171.35 445.41,174.19 B01.L2
  Route15 0.203: v61.37,149.4 23.16,187.6 23.16,188.42 19.1,192.48 19.1,198.17 12.6,204.67 12.6,213.61 9.75,216.46 9.75,220.12 6.1,223.77 6.1,248.16 5.28,248.97 5.28,253.44 A36.H2 | v417.78,214.02 423.47,208.33 423.47,207.11 423.88,206.7 423.88,205.08 425.5,203.45 425.5,198.58 445.82,178.26 445.82,175.41 B01.L2 | v274.32,74.62 305.61,43.33 305.61,42.11 330.4,17.32 341.78,17.32 343,16.1 347.07,16.1 D09.U2
  Bottom 0.203: v102.01,113.23 99.57,115.67 64.21,115.67 62.59,117.3 C32.H1 | v436.88,162.81 434.85,160.78 392.18,160.78 391.36,161.59 390.55,161.59 389.74,160.78 366.57,160.78 364.13,163.22 343.81,163.22 343.41,163.63 332.03,163.63 331.22,164.44 330,164.44 329.18,163.63 321.06,163.63 318.21,166.47 315.37,166.47 v313.74,164.85 | v311.3,161.19 310.9,161.59 308.46,161.59 306.83,163.22 282.45,163.22 281.63,162.41 B14.R2 | v246.69,11.63 247.09,11.23 269.04,11.23 v269.44,11.63
MB07  (via drill 0.61)
  Top 0.203: v126.39,122.58 126.8,122.99 126.8,135.18 125.98,135.99 C27.A1 | v288.54,105.1 288.54,123.8 286.11,126.24 v286.11,138.43 286.11,138.84 v286.11,144.53 | v289.76,138.43 289.36,138.84 289.36,174.6 292.2,177.44 v292.2,180.29 292.2,180.7 292.2,198.58 | 292.2,198.58 292.2,226.62 294.64,226.62 295.05,226.21 295.05,224.59 296.67,222.96 A13.U2 | 292.2,198.58 v292.61,198.58