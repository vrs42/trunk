# EAGLE board pdp8l (EAGLE 4.11), part 8 of 8
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
STROBE_FIELD0  (via drill 0.61) (continued)
  Top 0.203: A18.D1 236.12,262.79 235.31,261.98 235.31,233.12 236.12,232.31 A18.R1 236.12,231.09 235.31,230.28 235.31,194.92 236.12,194.11 B18.D1 | v241.4,159.97 241.4,106.32 244.25,103.48 244.25,93.73 245.47,92.51 C17.S2 | B19.D1 223.52,192.89 222.71,192.07 222.71,163.22 223.52,162.41 B19.R1
  Bottom 0.203: 221.89,233.12 212.55,233.12 211.73,232.31 A20.R1 | 221.89,233.12 223.11,231.9 A19.R1 | 235.31,233.12 236.12,232.31 A18.R1 | 235.31,233.12 221.89,233.12 | 235.31,233.12 247.9,233.12 248.72,232.31 A17.R1 | A20.D1 211.73,264.01 212.14,264.41 216.61,264.41 217.02,264.82 221.89,264.82 223.11,263.6 A19.D1 224.33,264.01 224.74,264.41 229.21,264.41 229.62,264.82 234.9,264.82 235.71,264.01 236.12,264.01 A18.D1 237.34,263.2 238.15,262.38 247.9,262.38 248.72,263.2 A17.D1 | 222.3,194.92 212.55,194.92 211.73,194.11 B20.D1 | 222.3,194.92 223.11,194.11 B19.D1 | 222.3,194.92 230.84,194.92 231.24,194.51 235.71,194.51 236.12,194.11 B18.D1 | 222.3,160.78 212.55,160.78 211.73,161.59 B20.R1 | 222.3,160.78 223.11,161.59 B19.R1 | 222.3,160.78 235.71,160.78 236.12,161.19 B18.R1 237.34,161.59 239.78,161.59 v241.4,159.97
SYNC
  Top 0.203: C11.E2 322.27,124.61 324.31,126.64 324.31,143.31 325.12,144.12 325.12,148.59 B11.V1
TAD  (via drill 0.61)
  Top 0.203: v316.59,140.87 316.59,137.62 316.18,137.21 C12.A1
  Route15 0.203: v353.97,140.06 373.07,120.95 373.89,120.95 375.51,119.33 377.14,119.33 378.76,117.7 C07.H1
  Bottom 0.203: v316.59,140.87 316.99,140.46 333.25,140.46 334.06,141.28 349.91,141.28 351.13,140.06 v353.97,140.06
TAD\  (via drill 0.61)
  Top 0.203: v351.13,122.58 351.13,126.24 C09.D1
  Route2 0.203: v322.27,101.45 336.09,115.27 336.09,115.67 341.78,121.36 343,121.36 346.66,125.02 348.69,125.02 350.32,126.64 C09.D1
  Bottom 0.203: v322.27,101.45 321.06,100.23 315.77,100.23 314.96,99.42 310.49,99.42 310.08,99.01 C12.P2 | v351.13,122.58 369.82,122.58 371.45,120.95 375.51,120.95 C07.F1
TP1  (via drill 0.61)
  Top 0.203: v387.3,39.68 387.3,45.77 386.08,46.99 D06.H2 385.27,48.21 384.45,49.02 v384.45,65.28 | v305.21,188.42 305.21,201.02 305.61,201.42 305.61,207.11 304.8,207.92 304.8,257.91 303.17,259.54 A13.E1 | v295.05,184.35 295.45,183.95 295.45,161.59 293.83,159.97 293.83,156.31 B13.T2
  Route15 0.203: v384.45,65.28 358.04,91.69 358.04,92.1 356.82,93.32 356.41,93.32 355.19,94.54 354.38,94.54 308.86,140.06 307.24,140.06 295.45,151.84 295.45,153.87 294.23,155.09 B13.T2
  Bottom 0.203: v387.3,39.68 436.47,39.68 440.94,35.2 442.16,35.2 D02.M1 | B13.T2 294.23,155.91 295.05,156.72 316.18,156.72 316.59,157.12 319.84,157.12 321.46,158.75 B11.S2 | v305.21,188.42 302.36,185.57 296.27,185.57 v295.05,184.35
TP2  (via drill 0.61)
  Top 0.203: v317.4,56.34 317.4,49.43 316.18,48.21 D12.H1 | v301.14,121.77 301.55,121.36 301.55,108.36 304.39,105.51 304.39,84.78 302.77,83.16 302.77,74.62 301.14,73 301.14,66.5 298.7,64.06 v298.7,58.37 | v386.49,107.14 386.89,106.73 386.89,92.91 386.49,92.51 C06.S2 | 390.14,52.27 389.33,51.46 D06.F1 | v390.14,92.1 390.14,52.27 | 390.14,52.27 v390.14,33.58 | v332.44,52.68 332.44,55.93 332.03,56.34 D10.D2
  Bottom 0.203: D10.D2 331.22,56.74 330.4,55.93 317.81,55.93 v317.4,56.34 316.99,56.34 314.55,58.78 310.49,58.78 310.08,58.37 v298.7,58.37 | v301.14,121.77 301.55,121.77 301.55,120.14 300.74,119.33 298.3,119.33 295.45,122.17 281.23,122.17 281.23,126.24 C14.D2 | v386.49,107.14 386.89,106.73 403.15,106.73 404.37,107.95 407.21,107.95 C04.L2 | v390.14,92.1 386.49,92.1 C06.S2 | v390.14,33.58 421.84,33.58 422.25,33.17 438.51,33.17 439.32,32.36 D02.N1 | v332.44,52.68 387.3,52.68 388.52,51.46 D06.F1
TP2\  (via drill 0.61)
  Route2 0.203: B08.N2 357.63,168.91 357.63,169.32 359.66,171.35 B08.M2 | v429.97,109.17 429.97,108.76 418.19,96.98 416.15,96.98 414.93,95.76 C04.R1
  Route15 0.203: D02.P1 443.38,29.11 443.38,31.95 444.19,32.77 444.19,62.43 441.35,65.28 441.35,66.09 416.15,91.29 416.15,92.91 414.53,94.54 C04.R1 | v429.97,109.17 429.56,109.17 390.96,147.78 388.52,147.78 378.76,157.53 372.26,157.53 367.79,162 366.98,162 360.88,168.1 360.88,170.94 B08.M2
TP3  (via drill 0.61)
  Top 0.203: 301.95,252.63 301.95,243.28 303.17,242.06 A13.M1 | 301.95,252.63 302.77,253.44 A13.H1 | 301.95,252.63 301.95,267.26 302.77,268.07 302.77,272.54 A13.A1 | C05.A1 404.37,135.99 403.15,134.77 403.15,132.74 400.3,129.9 400.3,127.46 395.83,127.46 C05.D2 395.43,126.24 397.05,124.61 397.05,114.05 397.46,113.64 397.46,112.01 397.05,111.61 v397.05,100.23 | C06.N1 388.52,101.04 387.71,100.23 387.71,45.77 388.52,44.96 D06.J1 388.52,43.74 388.52,42.11 v388.11,41.71 | v277.57,240.84 278.38,240.03 278.38,153.06 v278.79,152.65 | v290.98,138.43 291.8,137.62 291.8,125.83 290.58,124.61 C14.E1
  Route15 0.203: v298.3,120.55 298.3,120.14 303.99,114.45 305.61,114.45 C12.J2 306.83,113.64 306.83,111.61 318.21,100.23 322.68,100.23 330,92.91 330,88.85 331.22,87.63 336.5,87.63 338.12,86 338.94,86 343.81,81.13 347.47,81.13 352.35,76.25 353.57,76.25 v388.11,41.71 | v278.79,152.65 278.79,150.62 279.6,149.81 279.6,148.59 280.42,147.78 281.63,147.78 v290.98,138.43
  Bottom 0.203: v298.3,120.55 296.27,122.58 291.8,122.58 290.98,123.39 C14.E1 | 397.05,103.07 390.96,103.07 389.74,101.85 C06.N1 | 397.05,103.07 412.5,103.07 413.71,101.85 C04.N1 | 397.05,103.07 v397.05,100.23 | v277.57,240.84 279.6,242.88 301.55,242.88 302.77,241.66 A13.M1
TP4  (via drill 0.61)
  Top 0.203: v362.51,106.73 363.32,105.92 363.32,102.26 C08.N1 363.32,101.04 361.7,99.42 361.7,93.32 360.88,92.51 C08.S2 360.07,91.29 358.85,90.07 v358.85,78.28 | v420.62,131.52 421.84,130.3 v421.84,93.32 | 336.91,30.33 336.91,24.64 335.28,23.01 D10.S2 | 336.91,30.33 337.72,31.14 D10.N1 | 336.91,37.64 336.91,30.33 | 336.91,37.64 336.91,62.03 337.72,62.84 D10.B1 338.94,63.65 338.94,78.28 v338.53,78.69 | v311.3,39.68 311.3,45.77 310.08,46.99 D12.H2 309.27,48.21 308.05,49.43 308.05,137.21 309.68,138.84 309.68,151.84 B12.U2 | 336.91,37.64 v336.5,37.64
  Bottom 0.203: v362.51,106.73 358.44,106.73 357.63,107.54 C08.L2 | 421.84,90.88 441.35,90.88 442.16,91.69 C02.S1 | 421.84,90.88 412.5,90.88 411.68,91.69 C04.S2 410.46,92.51 409.65,93.32 361.7,93.32 360.88,92.51 C08.S2 | v420.62,131.52 419.81,132.33 415.75,132.33 414.93,133.15 C04.B1 | v421.84,93.32 421.84,90.88 | v311.3,39.68 311.71,39.27 330.4,39.27 331.22,38.46 D10.L2 332.44,37.64 v336.5,37.64 | v358.85,78.28 358.44,77.88 350.72,77.88 349.5,79.1 338.94,79.1 v338.53,78.69
TS1  (via drill 0.61)
  Top 0.203: v419,143.31 419,125.83 417.78,124.61 C04.E1 | v290.17,258.72 289.36,257.91 289.36,208.33 v290.17,207.52
  Route15 0.203: v372.67,143.31 372.67,143.71 365.76,150.62 364.13,150.62 335.69,179.07 334.06,179.07 332.44,180.7 B10.J2 | v290.17,207.52 312.12,185.57 312.12,185.17 312.52,184.76 313.33,184.76 318.62,179.48 319.84,179.48 v320.24,179.07
  Bottom 0.203: v419,143.31 418.59,142.9 389.33,142.9 388.52,143.71 373.07,143.71 v372.67,143.31 | v290.17,258.72 290.58,259.13 314.55,259.13 315.37,259.94 A12.E1 | v320.24,179.07 329.59,179.07 331.22,180.7 B10.J2
TS1\  (via drill 0.61)
  Top 0.203: C30.P2 80.47,99.01 78.44,101.04 78.44,101.45 C30.N2 | v89.81,140.46 88.59,139.24 v88.59,102.67
  Route2 0.203: v376.73,77.06 381.2,81.53 381.2,83.16 389.33,91.29 389.33,92.51 396.24,99.42 397.46,99.42 404.37,106.32 404.37,107.14 413.71,116.48 413.71,120.14 C04.F1 | v306.02,143.31 v303.58,140.87
  Route15 0.203: v376.73,77.06 373.48,77.06 358.44,92.1 358.44,92.51 357.23,93.73 356.82,93.73 340.16,110.39 340.16,111.61 339.34,112.42 338.12,112.42 324.31,126.24 324.31,129.9 323.49,130.71 323.49,131.12 323.09,131.52 318.21,131.52 309.27,140.46 307.64,140.46 306.83,141.28 306.83,142.49 v306.02,143.31
  Bottom 0.203: v303.58,140.87 303.17,141.28 266.19,141.28 264.97,140.06 256.03,140.06 255.22,140.87 253.59,140.87 252.78,140.06 156.87,140.06 156.46,140.46 v89.81,140.46 | v88.59,102.67 84.53,98.6 81.69,98.6 C30.P2
TS2  (via drill 0.61)
  Top 0.203: 308.05,258.32 308.05,261.16 306.43,262.79 A12.D2 | 308.05,258.32 308.05,236.78 309.27,235.56 A12.P2 | 308.05,258.32 v308.46,258.32 | C11.K2 321.87,110.39 321.06,109.58 321.06,97.38 319.43,95.76 C11.R2 319.02,94.54 318.21,93.73 318.21,90.07 317.81,89.66 v317.81,74.62 | 405.18,25.86 407.21,23.83 407.21,21.79 410.87,18.14 410.87,16.51 D04.U2 | v403.96,27.08 405.18,25.86 | 405.18,25.86 409.65,30.33 409.65,96.57 410.87,97.79 C04.P2 | v343.81,72.19 345.03,70.97 345.03,64.87 345.85,64.06 345.85,31.14 347.07,29.92 347.07,29.11 D09.P2 | v270.26,232.72 270.66,232.31 v270.66,146.15
  Route15 0.203: v293.01,146.15 293.01,143.71 296.27,140.46 296.27,139.24 302.77,132.74 302.77,132.33 303.58,131.52 303.99,131.52 320.24,115.27 320.24,114.45 321.46,113.23 321.46,112.01 321.87,111.61 C11.K2
  Bottom 0.203: A13.D2 294.23,263.2 295.05,262.38 304.8,262.38 305.61,263.2 A12.D2 | v308.46,258.32 308.86,258.72 316.18,258.72 316.99,259.54 321.06,259.54 321.46,259.13 339.75,259.13 340.56,259.94 A10.E1 | v403.96,27.08 349.5,27.08 348.29,28.3 D09.P2 | v317.81,74.62 318.62,73.81 342.19,73.81 v343.81,72.19 | v270.26,232.72 277.57,232.72 277.98,233.12 307.24,233.12 308.86,234.75 A12.P2 | v270.66,146.15 v293.01,146.15
TS3  (via drill 0.61)
  Top 0.203: v316.59,237.59 316.59,240.84 A12.M1 315.77,242.06 v315.77,244.09 | v339.34,266.85 339.34,270.92 340.97,272.54 A10.A1 | 333.25,125.83 333.65,125.42 333.65,116.89 334.47,116.08 334.47,111.61 C10.K2 | 333.25,125.83 332.44,126.64 C10.D2 | 333.65,189.23 334.47,190.04 B10.E2 | 333.65,189.23 333.65,150.62 334.47,149.81 334.47,139.24 | 334.47,139.24 334.47,138.02 333.25,136.8 333.25,125.83 | v419,107.54 419,93.32 418.19,92.51 C04.S1 | v312.93,139.24 312.93,133.96 C12.B1 | 334.47,139.24 v334.87,139.24 | v329.59,208.74 327.15,211.18 327.15,222.96 326.75,223.37 326.75,229.87 325.53,231.09 A11.R1 | v332.44,206.7 332.84,206.3 332.84,201.02 333.65,200.2 333.65,189.23
  Route2 0.203: v339.34,266.85 338.53,266.85 v315.77,244.09 | v329.59,208.74 332.03,206.3 v332.44,206.7
  Route15 0.203: v316.59,237.59 320.24,233.93 321.06,233.93 321.46,233.53 323.09,233.53 324.71,231.9 A11.R1 | C13.A1 303.99,136.4 307.64,136.4 308.86,135.18 310.49,135.18 312.12,133.55 C12.B1
  Bottom 0.203: v419,107.54 418.19,106.73 406.4,106.73 405.59,107.54 404.77,107.54 403.56,106.32 367.39,106.32 364.54,109.17 358.44,109.17 358.04,109.58 355.6,109.58 355.19,109.98 351.54,109.98 351.13,109.58 339.34,109.58 338.12,110.79 335.69,110.79 C10.K2 | v334.87,139.24 v312.93,139.24
TS3\  (via drill 0.61)
  Top 0.203: C30.J2 78.44,114.45 80.47,116.48 80.47,116.89 C30.H2
  Route2 0.203: v398.68,83.97 341.78,27.08 337.31,27.08 326.34,16.1 323.9,16.1 317.81,22.2 316.59,20.98 312.93,20.98 306.83,27.08 v307.24,27.48
  Route15 0.203: v163.78,32.77 82.91,113.64 82.91,115.27 81.28,116.89 C30.H2
  Bottom 0.203: v398.68,83.97 399.9,85.19 400.71,85.19 401.93,83.97 415.75,83.97 416.97,85.19 C04.U1 | v307.24,27.48 306.83,27.08 276.76,27.08 273.51,30.33 221.08,30.33 218.24,33.17 164.19,33.17 v163.78,32.77
TS4  (via drill 0.61)
  Top 0.203: A10.M1 340.97,242.06 340.97,246.94 A10.K1 | v272.29,84.38 272.69,84.78 272.69,103.48 271.88,104.29 C15.M2 | v408.43,69.34 408.43,81.94 C04.V2 | v298.3,105.92 298.3,118.92 299.52,120.14 C13.F1 299.92,121.36 298.7,122.58 298.7,134.37 299.11,134.77 299.11,138.84 298.3,139.65 298.3,147.37 298.7,147.78 298.7,166.88 | 298.7,166.88 298.7,191.67 299.92,192.89 B13.D1 | 298.7,166.88 v299.11,166.88 | v335.69,233.12 336.09,232.72 336.09,219.3 v335.69,218.9
  Route2 0.203: v356.82,69.34 356.82,66.09 340.56,49.84 339.34,49.84 329.59,40.08 327.56,40.08 325.93,38.46 D11.L1 | v335.69,233.12 340.97,238.4 340.97,240.84 A10.M1 | v335.69,218.9 335.28,218.9 309.27,192.89 v309.27,192.48
  Route15 0.203: v272.29,84.38 272.69,83.97 275.13,83.97 290.58,68.53 291.39,68.53 317.81,42.11 319.02,42.11 322.68,38.46 324.71,38.46 D11.L1
  Bottom 0.203: v356.82,69.34 v408.43,69.34 | v298.3,105.92 272.29,105.92 271.88,105.51 C15.M2 | v299.11,166.88 300.74,166.88 303.58,169.72 330,169.72 331.22,168.5 B10.N2 | v309.27,192.48 301.55,192.48 300.74,193.29 B13.D1
TS4\  (via drill 0.61)
  Route2 0.203: v348.69,12.45 394.61,58.37 396.65,58.37 397.05,58.78 397.05,60.81 397.87,61.62 398.27,61.62 398.68,62.03 398.68,64.87 399.9,66.09 399.9,67.31 414.53,81.94 C04.V1
  Route15 0.203: v225.15,15.7 174.75,66.09 174.75,66.5 161.34,79.91 160.12,79.91 129.64,110.39 129.24,110.39 109.73,129.9 109.73,132.74 C28.B1
  Bottom 0.203: v225.15,15.7 226.37,14.48 263.75,14.48 264.16,14.07 345.03,14.07 346.66,12.45 v348.69,12.45
TT0\  (via drill 0.61)
  Top 0.203: v92.25,109.58 95.1,109.58 95.1,203.45 89,209.55 v89,264.41
  Bottom 0.203: v92.25,109.58 57.3,109.58 56.08,110.79 C32.K2 | v89,264.41 86.97,266.45 62.59,266.45 A32.C1
TT1\
  Top 0.203: C32.R2 52.02,95.76 51.21,96.57 51.21,201.02 51.61,201.42 51.61,217.68 51.21,218.08 51.21,255.88 52.02,256.69 A32.F2
TT2\  (via drill 0.61)
  Top 0.203: v75.59,90.88 76.4,91.69 76.4,115.27 79.25,118.11 79.25,140.06 76.81,142.49 v76.81,249.38
  Bottom 0.203: v75.59,90.88 73.97,90.88 71.53,93.32 56.9,93.32 56.08,92.51 C32.S2 | v76.81,249.38 75.59,250.6 59.33,250.6 A32.J1
TT3\
  Top 0.203: A32.M2 54.86,240.84 54.05,240.03 54.05,201.83 60.55,195.33 60.55,138.02 60.15,137.62 60.15,109.98 58.93,108.76 C32.L1
TT4\
  Top 0.203: C32.M1 62.18,105.51 63.8,107.14 63.8,232.72 62.18,234.34 A32.P1
TT5\  (via drill 0.61)
  Top 0.203: v73.97,224.59 76.4,222.15 76.4,116.08 73.15,112.83 v73.15,102.67
  Bottom 0.203: v73.97,224.59 73.56,224.18 53.65,224.18 52.83,224.99 A32.T2 | v73.15,102.67 72.75,103.07 62.18,103.07 58.12,99.01 56.08,99.01 C32.P2
TT6\  (via drill 0.61)
  Top 0.203: v38.2,217.27 38.2,196.95 41.05,194.11 41.05,167.28 37.8,164.03 37.8,143.31 36.58,142.09 v36.58,92.51
  Route2 0.203: v38.2,217.27 38.2,219.71 46.33,227.84 35.36,238.81 35.36,242.06 36.17,242.88 36.17,243.69 47.95,255.47 47.95,260.76 48.77,261.57 48.77,266.04 A33.C1
  Bottom 0.203: v36.58,92.51 39.01,90.07 50.8,90.07 51.61,89.26 C32.T2
TT7\  (via drill 0.61)
  Top 0.203: v66.24,257.5 67.06,256.69 67.06,144.93 65.84,143.71 v65.84,137.62
  Route2 0.203: v65.84,137.62 65.84,135.99 51.21,121.36 51.21,103.07 52.02,102.26 C32.N2
  Bottom 0.203: v66.24,257.5 65.43,258.32 41.05,258.32 40.23,257.5 A33.F2
TT_AC_CLEAR\  (via drill 0.61)
  Top 0.203: A33.R1 45.52,232.31 45.52,237.59 A33.N1 | v76.4,77.06 82.5,83.16 v82.5,235.56
  Route2 0.203: v76.4,77.06 55.68,56.34 55.68,54.71 D32.E2
  Bottom 0.203: 47.95,236.37 46.74,237.59 46.33,237.59 A33.N1 | 47.95,236.37 48.77,235.56 A33.P1 | v82.5,235.56 81.69,236.37 47.95,236.37
TT_INT\  (via drill 0.61)
  Route15 0.203: v264.57,31.55 199.14,96.98 194.67,96.98 142.65,149 142.65,149.81 49.17,243.28 47.55,241.66 43.48,241.66 A33.M2
  Bottom 0.203: v264.57,31.55 266.6,33.58 301.95,33.58 302.77,34.39 D13.M1
TT_SKIP\
  Route15 0.203: A33.J1 46.33,250.19 46.33,248.16 146.71,147.78 149.15,147.78 262.94,33.98 264.16,33.98 271.07,27.08 283.67,27.08 289.76,20.98 296.27,20.98 299.52,17.73 301.55,17.73 302.77,16.51 D13.U1
TTI_CLOCK
  Route2 0.203: C33.R2 40.23,95.76 44.7,95.76 45.52,96.57 51.61,96.57 54.86,99.82 56.49,99.82 58.12,101.45 C32.N1
TTI_FLAG\  (via drill 0.61)
  Route2 0.203: v252.78,262.79 209.7,219.71 209.7,219.3 197.92,207.52 197.51,207.52 160.12,170.13 159.31,170.13 139.8,150.62 108.92,150.62 96.32,138.02 93.07,138.02 80.47,125.42 79.65,125.42 79.25,125.02 67.46,125.02 64.62,122.17 58.12,122.17 57.3,121.36 52.83,121.36 C32.F2
  Bottom 0.203: v252.78,262.79 253.19,263.2 280.42,263.2 A14.D2
TTI_SKIP\  (via drill 0.61)
  Route2 0.203: v242.21,234.34 165,157.12 158.9,157.12 158.5,156.72 153.21,156.72 132.89,136.4 132.89,135.59 87.38,90.07 87.38,88.44 85.34,86.41 85.34,81.53 63.8,60 63.8,58.78 56.08,51.05 56.08,48.21 D32.H2
  Bottom 0.203: v242.21,234.34 244.25,236.37 264.16,236.37 264.57,235.97 278.79,235.97 280.42,237.59 A14.N2
TTO_CLOCK\  (via drill 0.61)
  Top 0.203: v69.9,60.4 69.9,30.33 68.68,29.11 D31.P2
  Route15 0.203: v69.9,60.4 69.9,75.84 51.21,94.54 51.21,99.01 44.7,105.51 44.7,108.76 43.08,110.39 C33.K2
TTO_ENABLE
  Bottom 0.203: C31.K2 68.68,110.79 73.97,110.79 C31.K1
TTO_ENABLE\
  Top 0.203: C31.L1 71.53,108.76 72.75,109.98 72.75,115.27 74.37,116.89 C31.H1
TTO_FLAG\  (via drill 0.61)
  Top 0.203: v153.62,117.7 155.25,119.33 155.25,123.8 179.22,147.78 181.25,147.78 181.25,179.48 184.51,182.73 v184.51,233.93 | v282.45,234.34 282.45,257.91 284.07,259.54 A14.E2
  Route2 0.203: v153.62,117.7 151.18,115.27 149.96,115.27 149.15,114.45 149.15,113.64 128.83,93.32 118.26,93.32 98.35,73.41 98.35,72.19 95.1,68.94 95.1,66.09 70.71,41.71 68.68,41.71 D31.K2
  Bottom 0.203: v184.51,233.93 184.91,233.53 267,233.53 267.82,234.34 v282.45,234.34
TTO_SKIP\  (via drill 0.61)
  Route2 0.203: v260.1,234.34 163.78,138.02 162.97,138.02 118.67,93.73 117.86,93.73 97.94,73.81 97.94,72.59 96.32,70.97 95.91,70.97 69.49,44.55 65.84,44.55 D31.J2
  Bottom 0.203: v260.1,234.34 260.91,235.15 283.67,235.15 A14.P2
TXD  (via drill 0.61)
  Top 0.203: v51.61,80.72 51.61,72.59 44.7,65.68 44.7,49.84 43.08,48.21 D33.H2
  Bottom 0.203: v51.61,80.72 52.02,81.13 63.8,81.13 64.62,81.94 C31.V2
VCC  (via drill 0.61)
  Top 0.508: A23.A2 170.28,273.76 170.69,274.17 170.69,282.7 171.5,283.52 207.67,283.52 207.67,273.76 A20.A2 | A24.A2 156.87,273.76 156.87,284.33 117.86,284.33 106.88,273.36 A28.A2 106.07,273.76 102.82,277.01 86.97,277.01 86.97,209.96 93.47,203.45 v93.47,203.05 93.47,137.21 C29.A2 | C28.A2 106.88,135.99 107.7,135.18 107.7,122.99 104.04,119.33 98.35,119.33 98.35,77.06 99.57,75.84 99.57,70.56 95.91,66.9 94.28,66.9 D29.A2
  Bottom 0.508: 15.44,271.73 6.1,271.73 5.28,272.54 A36.A2 | 15.44,271.73 16.66,272.95 A35.A2 | 28.85,271.73 29.67,272.54 A34.A2 | 28.85,271.73 15.44,271.73 | 41.45,271.73 42.27,272.54 A33.A2 | 41.45,271.73 28.85,271.73 | 53.65,271.73 54.86,272.95 A32.A2 | 53.65,271.73 41.45,271.73 | 53.65,271.73 62.99,271.73 63.8,272.54 105.26,272.54 105.66,272.95 A28.A2 | A24.A2 157.68,272.54 158.09,272.14 162.15,272.14 162.56,271.73 165.81,271.73 167.03,272.95 169.06,272.95 A23.A2 | A20.A2 208.48,272.54 208.89,272.14 212.95,272.14 213.36,271.73 218.64,271.73 219.86,272.95 A19.A2 221.08,272.54 223.93,272.54 224.74,271.73 227.99,271.73 228.4,272.14 232.46,272.14 232.87,272.54 A18.A2 234.09,272.95 234.9,272.14 238.56,272.14 238.96,271.73 244.65,271.73 245.47,272.54 A17.A2 246.69,272.54 247.9,271.32 251.56,271.32 251.97,270.92 279.6,270.92 281.23,272.54 283.67,272.54 A14.A2 284.89,272.95 286.11,271.73 295.45,271.73 | 421.84,274.57 412.9,274.57 411.68,273.36 AB04.AA2 410.46,273.36 409.25,274.57 404.37,274.57 403.15,273.36 399.08,273.36 AB05.AA2 397.87,273.36 396.65,274.57 390.14,274.57 388.93,273.36 386.49,273.36 AB06.AA2 385.27,273.36 384.05,274.57 374.29,274.57 373.48,273.76 AB07.AA2 372.26,272.95 371.04,271.73 361.7,271.73 360.88,272.54 A08.A2 359.66,272.95 358.44,271.73 350.32,271.73 349.1,272.95 348.29,272.95 A09.A2 347.07,272.54 346.25,271.73 333.65,271.73 | 421.84,274.57 423.06,273.36 AB03.AA2 | 434.85,274.57 436.07,273.36 AB02.AA2 | 421.84,274.57 434.85,274.57 | 434.85,274.57 447.45,274.57 448.67,273.36 A01.A2 | 295.45,271.73 296.27,272.54 A13.A2 | 295.45,271.73 307.64,271.73 308.86,272.95 A12.A2 310.08,272.54 310.49,272.54 311.3,271.73 320.24,271.73
  Bottom 0.508: 320.24,271.73 321.46,272.95 A11.A2 | 333.65,271.73 334.47,272.54 A10.A2 | 320.24,271.73 333.65,271.73 | B01.A2 448.67,203.45 447.45,204.67 438.51,204.67 437.29,203.45 AB02.BA2 436.07,203.86 435.25,204.67 426.72,204.67 425.91,203.86 424.28,203.86 AB03.BA2 423.06,203.45 421.84,204.67 409.25,204.67 | 409.25,204.67 410.46,203.45 AB04.BA2 | 409.25,204.67 400.3,204.67 399.08,203.45 AB05.BA2 397.87,202.64 393.8,202.64 392.99,201.83 391.36,201.83 390.96,202.23 387.3,202.23 386.49,203.05 AB06.BA2 385.27,202.64 384.86,202.23 380.8,202.23 380.39,201.83 374.7,201.83 373.89,202.64 373.48,202.64 AB07.BA2 372.26,203.05 371.04,201.83 361.7,201.83 360.88,202.64 B08.A2 359.66,203.05 358.85,202.23 355.19,202.23 354.79,201.83 353.16,201.83 351.94,203.05 348.29,203.05 B09.A2 347.07,202.64 346.66,202.23 342.6,202.23 342.19,201.83 340.56,201.83 339.34,203.05 335.69,203.05 B10.A2 334.47,202.64 333.65,201.83 320.24,201.83 | 295.45,201.83 289.76,201.83 288.95,202.64 285.29,202.64 284.89,203.05 B14.A2 283.67,203.05 241.81,203.05 240.59,201.83 235.31,201.83 234.09,203.05 B18.A2 232.87,203.86 232.05,204.67 221.89,204.67 221.08,203.86 B19.A2 219.86,203.05 218.64,201.83 213.36,201.83 212.95,202.23 208.89,202.23 208.48,202.64 B20.A2 207.26,203.45 206.04,204.67 171.5,204.67 170.69,203.86 170.28,203.86 B23.A2 169.06,203.45 167.84,204.67 155.25,204.67 | 295.45,201.83 296.27,202.64 B13.A2 | 307.64,201.83 308.86,203.05 B12.A2 | 295.45,201.83 307.64,201.83 | 320.24,201.83 321.46,203.05 B11.A2 | 307.64,201.83 320.24,201.83 | B33.A2 43.48,203.05 44.3,202.23 47.95,202.23 48.36,201.83 53.65,201.83 54.86,203.05 B32.A2 56.08,202.64 56.9,201.83 86.97,201.83 88.19,203.05 v93.47,203.05 105.66,203.05 B28.A2 106.88,203.45 108.1,204.67 155.25,204.67
  Bottom 0.508: 155.25,204.67 156.46,203.45 B24.A2 | 53.65,135.18 44.3,135.18 43.48,135.99 C33.A2 | 53.65,135.18 54.86,136.4 C32.A2 | 66.24,135.18 67.46,136.4 C31.A2 | 66.24,135.18 53.65,135.18 | 79.65,135.18 80.47,135.99 C30.A2 | 79.65,135.18 66.24,135.18 | 92.25,135.18 93.07,135.99 C29.A2 | 92.25,135.18 79.65,135.18 | 104.44,135.18 105.66,136.4 C28.A2 | 104.44,135.18 92.25,135.18 | 117.04,135.18 118.26,136.4 C27.A2 | 104.44,135.18 117.04,135.18 | 117.04,135.18 130.45,135.18 131.27,135.99 C26.A2 132.49,136.8 133.71,138.02 142.65,138.02 | 142.65,138.02 143.87,136.8 C25.A2 | 155.25,138.02 156.46,136.8 C24.A2 | 142.65,138.02 155.25,138.02 | 155.25,138.02 167.84,138.02 169.06,136.8 C23.A2 170.28,137.21 171.09,138.02 221.89,138.02 | 221.89,138.02 221.08,137.21 C19.A2 | 221.89,138.02 231.65,138.02 232.87,136.8 C18.A2 234.09,136.4 235.31,135.18 244.65,135.18 245.47,135.99 C17.A2 246.69,135.99 247.5,135.18 272.69,135.18 | 272.69,135.18 271.88,135.99 C15.A2 | 272.69,135.18 282.85,135.18 283.67,135.99 C14.A2 284.89,136.4 285.7,135.59 289.36,135.59 289.76,135.18 292.61,135.18 293.42,135.99 296.27,135.99 C13.A2 297.49,135.99 297.89,135.59 301.95,135.59 302.36,135.18 305.21,135.18 306.43,136.4 308.86,136.4 C12.A2 310.08,135.99 313.33,135.99 314.15,135.18 316.99,135.18 317.81,135.99 321.06,135.99 321.46,136.4 C11.A2 322.68,136.4 326.34,136.4 327.56,135.18 330.4,135.18 331.62,136.4 334.47,136.4 C10.A2 335.69,136.4 336.91,135.18 346.25,135.18 | 434.85,138.02 425.09,138.02 424.28,137.21 CD03.AA2 423.06,136.4 422.66,135.99 419.4,135.99 418.59,135.18 416.56,135.18 415.75,135.99 411.68,135.99 C04.A2 410.46,136.4 409.25,135.18 399.9,135.18 399.08,135.99 C05.A2 397.87,136.4 394.21,136.4 392.99,135.18 384.45,135.18
  Bottom 0.508: 434.85,138.02 436.07,136.8 C02.A2 | 434.85,138.02 447.45,138.02 448.67,136.8 C01.A2 | 346.25,135.18 347.07,135.99 C09.A2 | 358.44,135.18 359.66,136.4 C08.A2 | 346.25,135.18 358.44,135.18 | 371.04,135.18 372.26,136.4 C07.A2 | 358.44,135.18 371.04,135.18 | 384.45,135.18 385.27,135.99 C06.A2 | 371.04,135.18 384.45,135.18 | 155.25,68.12 146.3,68.12 145.09,66.9 D25.A2 143.87,66.9 141.83,68.94 108.51,68.94 106.88,67.31 D28.A2 | 155.25,68.12 156.46,66.9 D24.A2 | 155.25,68.12 167.84,68.12 169.06,66.9 D23.A2 170.28,67.31 171.09,68.12 218.64,68.12 219.86,66.9 D19.A2 221.08,66.09 221.89,65.28 232.05,65.28 | 53.65,68.12 44.7,68.12 43.48,66.9 D33.A2 | 53.65,68.12 54.86,66.9 D32.A2 | 66.24,68.12 67.46,66.9 D31.A2 | 66.24,68.12 53.65,68.12 | 79.65,68.12 80.47,67.31 D30.A2 | 79.65,68.12 66.24,68.12 | 91.85,68.12 93.07,66.9 D29.A2 | 91.85,68.12 79.65,68.12 | 91.85,68.12 104.44,68.12 105.66,66.9 D28.A2 | D27.A2 118.26,66.5 117.04,65.28 107.7,65.28 106.88,66.09 D28.A2 | 435.25,68.12 436.07,67.31 D02.A2 | 435.25,68.12 425.09,68.12 424.28,67.31 CD03.BA2 423.06,66.5 421.84,65.28 412.5,65.28 411.68,66.09 D04.A2 410.46,66.9 408.03,66.9 406.81,68.12 400.3,68.12 399.08,66.9 D05.A2 397.87,66.9 396.65,68.12 387.71,68.12 386.49,66.9 D06.A2 385.27,66.5 381.61,66.5 380.39,65.28 371.04,65.28 | 435.25,68.12 447.45,68.12 448.67,66.9 D01.A2 | 232.05,65.28 232.87,66.09 D18.A2 | 244.25,65.28 245.47,66.5 D17.A2 | 244.25,65.28 232.05,65.28 | 256.85,65.28 258.06,66.5 D16.A2 | 256.85,65.28 244.25,65.28 | 269.44,65.28 270.66,66.5 D15.A2 | 269.44,65.28 256.85,65.28 | 269.44,65.28 278.79,65.28 279.2,65.68 283.26,65.68 283.67,66.09 D14.A2 284.89,66.5 285.7,65.68 289.36,65.68 289.76,65.28 298.7,65.28
  Bottom 0.508: 358.44,65.28 349.5,65.28 348.29,66.5 D09.A2 347.07,66.5 345.85,65.28 337.72,65.28 336.5,66.5 335.69,66.5 D10.A2 334.47,66.09 333.65,65.28 326.34,65.28 325.53,66.09 322.68,66.09 D11.A2 321.46,66.5 320.65,65.68 317.4,65.68 316.99,65.28 307.64,65.28 | 358.44,65.28 359.66,66.5 D08.A2 | 371.04,65.28 372.26,66.5 D07.A2 | 371.04,65.28 358.44,65.28 | 298.7,65.28 297.49,66.5 D13.A2 | 307.64,65.28 298.7,65.28 | 307.64,65.28 308.86,66.5 D12.A2
WC_OVERFLOW\  (via drill 0.61)
  Route15 0.203: v271.48,107.95 271.88,107.95 330.4,49.43 332.44,49.43 333.65,48.21 334.47,48.21 D10.H2
  Bottom 0.203: v271.48,107.95 270.26,109.17 269.85,109.17 269.44,109.58 257.66,109.58 257.25,109.17 174.75,109.17 171.5,112.42 120.29,112.42 119.48,111.61 C27.K2
WC_SET\  (via drill 0.61)
  Top 0.203: 308.05,20.98 308.86,21.79 D12.S2 | 308.05,20.98 306.83,19.76 D12.T2 | 308.05,20.98 308.05,33.17 309.27,34.39 D12.M2 | v182.07,81.13 193.85,69.34 193.85,64.06 208.89,49.02 216.21,49.02 216.21,48.62 v225.55,39.27
  Bottom 0.203: v182.07,81.13 172.31,81.13 165.81,87.63 130.05,87.63 129.24,88.44 C26.T2 | v225.55,39.27 290.58,39.27 293.42,36.42 307.64,36.42 308.86,35.2 D12.M2 310.08,34.39 310.9,33.58 320.24,33.58 321.46,34.8 D11.M2
WORD_COUNT
  Bottom 0.203: D10.P2 335.69,28.3 340.56,28.3 D10.P1
WORD_COUNT\  (via drill 0.61)
  Top 0.203: 317.4,24.23 317.4,33.17 316.18,34.39 D12.M1 | 317.4,24.23 317.4,21.79 314.55,18.95 314.55,16.51 310.08,16.51 D12.U2 | 317.4,24.23 v317.81,24.23 | v129.64,137.62 130.05,137.21 130.05,122.58 128.83,121.36 C26.F2 | v256.03,231.5 256.03,141.28 v254.81,140.06 254.81,139.65 254.81,72.59 v255.63,71.78
  Route2 0.203: D01.J2 445.82,43.74 445.82,39.68 444.6,38.46 444.6,33.17 444.19,32.77 444.19,31.95 438.51,26.26 438.51,24.64 436.88,23.01 D02.S2 | D11.H1 328.37,46.99 328.37,45.36 319.84,36.83 318.21,36.83 316.59,35.2 D12.M1
  Route15 0.203: v255.63,71.78 273.1,54.3 273.91,54.3 309.27,18.95 309.27,16.51 D12.U2
  Bottom 0.203: D02.S2 436.07,21.79 435.25,20.98 419,20.98 418.19,21.79 D04.S1 416.97,22.61 415.34,24.23 330.4,24.23 | 330.4,24.23 331.22,25.04 D10.R2 | v317.81,24.23 330.4,24.23 | v129.64,137.62 132.08,140.06 156.06,140.06 156.46,139.65 254.41,139.65 v254.81,140.06 | v256.03,231.5 256.85,230.68 280.01,230.68 280.42,230.28 317.81,230.28 318.62,231.09 A11.R2
WRITE  (via drill 0.61)
  Top 0.203: C25.L1 147.93,108.76 149.15,109.98 149.15,125.02 147.93,126.24 C25.D1 | 143.46,36.42 142.65,37.24 142.65,55.12 141.43,56.34 D25.D2 | 143.46,36.42 144.27,35.61 D25.M2 | v231.24,23.42 223.11,15.29 223.11,14.07 217.83,8.79 142.65,8.79 142.65,28.3 139.8,31.14 139.8,32.77 142.24,35.2 | 142.24,35.2 143.46,36.42 | v137.77,106.73 136.96,105.92 136.96,40.49 142.24,35.2
  Bottom 0.203: D16.S1 264.57,21.79 259.28,21.79 D16.S2 258.06,22.61 257.25,23.42 v231.24,23.42 | v137.77,106.73 146.3,106.73 147.12,107.54 C25.L1
X_R/W_RETURN  (via drill 0.61)
  Top 0.203: v139.8,184.35 139.4,183.95 139.4,52.27 v138.99,51.87 | D19.T2 217.02,18.54 216.61,18.14 216.61,14.07 182.47,14.07 182.47,12.45 180.44,10.41 149.56,10.41 149.56,39.27 150.77,40.49 D25.K1
  Route15 0.203: v139.8,184.35 130.86,193.29 129.24,193.29 B26.D2 | D25.K1 150.37,41.71 148.34,41.71 143.05,46.99 143.05,49.02 141.83,50.24 D25.F2
  Bottom 0.203: D19.T2 218.24,18.95 219.46,17.73 228.8,17.73 229.62,18.54 D18.T2 | v138.99,51.87 139.8,51.05 140.61,51.05 D25.F2
X_R/W_SOURCE  (via drill 0.61)
  Top 0.203: v136.14,121.77 136.14,182.73 133.71,185.17 133.71,263.2 129.24,263.2 A26.D2 | v154.03,109.58 155.25,108.36 155.25,90.88 154.03,89.66 C24.T2
  Route15 0.203: C25.F2 141.83,120.14 143.87,120.14 149.15,114.86 149.15,112.83 150.37,111.61 C25.K1
  Bottom 0.203: C24.T2 154.43,89.26 155.25,90.07 163.37,90.07 164.19,89.26 166.22,89.26 C23.T2 | v136.14,121.77 136.96,120.95 140.61,120.95 C25.F2 | v154.03,109.58 152.81,110.79 151.59,110.79 C25.K1
Y_R/W_RETURN
  Top 0.203: A25.D2 141.43,262.79 143.05,261.16 143.05,238.4 151.99,229.46 151.99,182.32 151.59,181.91 151.59,179.07 152.4,178.26 152.4,24.23 151.18,23.01 D25.S1 151.18,21.79 151.18,21.39 153.21,19.36 D24.T2
  Bottom 0.203: D25.P2 144.68,27.89 144.68,25.45 145.49,25.45 148.34,22.61 150.37,22.61 D25.S1 | D23.T2 166.22,18.54 165.41,17.73 155.25,17.73 154.43,18.54 D24.T2
Y_R/W_SOURCE  (via drill 0.61)
  Top 0.203: v136.14,102.67 136.14,107.14 136.96,107.95 136.96,185.98 139.4,188.42 139.4,191.26 141.02,192.89 B25.D2 | v145.09,93.73 144.68,94.13 144.68,97.79 C25.P2
  Bottom 0.203: C18.T2 229.62,89.26 228.8,90.07 219.05,90.07 218.24,89.26 C19.T2 217.02,89.26 215.8,90.47 180.03,90.47 176.78,93.73 149.15,93.73 | v136.14,102.67 140.21,98.6 143.87,98.6 C25.P2 | 149.15,93.73 150.37,92.51 C25.S1 | 149.15,93.73 v145.09,93.73