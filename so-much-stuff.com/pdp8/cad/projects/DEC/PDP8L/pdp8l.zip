# EAGLE board pdp8l (EAGLE 4.11), part 3 of 8
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
GND  (via drill 0.61) (continued)
  Bottom 0.508: D30.N1 84.94,31.55 89.81,31.55 D29.N2 91.03,31.14 96.32,31.14 D29.N1 97.54,31.95 97.94,31.95 99.16,33.17 104.04,33.17 105.66,34.8 D28.M2 | D30.U2 81.28,16.51 83.31,18.54 83.72,18.54 D30.T1 | D30.R2 78.44,25.04 83.72,25.04 D30.R1 84.94,25.04 89.81,25.04 D29.R2 | D29.U2 93.88,16.51 95.91,18.54 96.32,18.54 D29.T1 97.54,18.95 102.41,18.95 D28.T2 103.63,18.54 108.92,18.54 D28.T1 | D25.T1 147.12,18.54 145.9,17.32 127.2,17.32 125.98,16.1 D27.U1 | B32.C1 61.37,196.54 56.08,196.54 B32.C2 54.86,196.54 49.99,196.54 B33.C1 48.77,196.54 43.48,196.54 B33.C2 42.27,196.54 36.98,196.54 B34.C1 35.76,196.54 30.89,196.54 B34.C2 29.67,196.54 24.38,196.54 B35.C1 23.16,196.95 17.88,196.95 B35.C2 16.66,196.54 13.01,196.54 | 6.91,196.54 10.57,196.54 B36.C1 11.79,196.54 13.01,196.54 | 6.91,196.54 5.28,196.54 B36.C2 | B36.F2 2.03,186.79 7.32,186.79 B36.F1 8.53,186.79 13.82,186.79 B35.F2 | B35.F2 15.04,187.2 19.91,187.2 B35.F1 | B36.U2 4.88,153.06 6.91,155.09 7.32,155.09 B36.T1 | B36.R2 2.03,161.59 7.32,161.59 B36.R1 | B35.R2 15.04,161.59 19.91,161.59 B35.R1 | B34.U2 29.67,151.84 28.85,151.03 18.69,151.03 17.88,151.84 B35.U2 | B36.N1 8.53,168.1 13.82,168.1 B35.N2 15.04,168.1 19.91,168.1 B35.N1 21.13,167.69 26.42,167.69 B34.N2 | B34.N1 34.14,168.1 39.01,168.1 B33.N2 40.23,167.69 45.52,167.69 B33.N1 46.74,168.1 51.61,168.1 B32.N2 52.83,168.1 58.12,168.1 B32.N1 | B34.R2 27.64,161.59 32.92,161.59 B34.R1 34.14,161.59 39.01,161.59 B33.R2 | B33.K1 49.58,178.26 51.61,180.29 52.02,180.29 B32.J2 52.83,180.29 55.27,180.29 57.71,177.85 61.37,177.85 B32.K1 | B33.U2 43.08,153.06 45.11,155.09 45.52,155.09 B33.T1
  Bottom 0.508: B32.R2 51.61,161.59 46.74,161.59 B33.R1 | 13.01,196.54 13.01,188.01 13.82,188.01 B35.F2 | B26.E2 131.27,190.04 130.05,188.82 110.95,188.82 109.73,190.04 106.88,190.04 B28.E2 | B33.J2 39.42,180.29 37.39,178.26 36.98,178.26 B34.K1 | B34.F2 27.64,187.2 32.92,187.2 B34.F1 34.14,187.2 39.01,187.2 B33.F2 40.23,186.79 45.52,186.79 B33.F1 46.74,187.2 51.61,187.2 B32.F2 52.83,186.79 58.12,186.79 B32.F1 59.33,187.2 102.41,187.2 B28.F2 | D33.C2 42.27,60 36.98,60 D34.C1 35.76,60 30.89,60 D34.C2 29.67,60 24.38,60 D35.C1 23.16,60 17.88,60 D35.C2 16.66,60 11.79,60 D36.C1 10.57,60 5.28,60 D36.C2 | D34.F1 32.92,50.65 27.64,50.65 D34.F2 26.42,50.24 21.13,50.24 D35.F1 19.91,50.65 15.04,50.65 D35.F2 13.82,50.24 8.53,50.24 D36.F1 7.32,50.65 2.03,50.65 D36.F2 | D36.R2 2.03,25.04 7.32,25.04 D36.R1 | D35.N2 15.04,31.55 19.91,31.55 D35.N1 | D35.R2 15.04,25.04 19.91,25.04 D35.R1 21.13,25.04 26.42,25.04 D34.R2 | D34.N1 32.92,31.55 27.64,31.55 D34.N2 | C35.R1 19.91,94.94 15.04,94.94 C35.R2 13.82,94.94 8.53,94.94 C36.R1 7.32,94.94 2.03,94.94 C36.R2 | C36.U2 4.88,86.41 6.91,88.44 7.32,88.44 C36.T1 | 6.1,129.9 10.57,129.9 C36.C1 11.79,129.9 16.66,129.9 C35.C2 17.88,129.9 23.16,129.9 C35.C1 24.38,129.9 42.27,129.9 C33.C2 43.48,130.71 44.3,131.52 53.65,131.52 | 6.1,129.9 5.28,129.9 C36.C2 | 6.1,120.14 2.03,120.14 C36.F2 | 6.1,120.14 7.32,120.14 C36.F1 8.53,120.14 13.82,120.14 C35.F2 15.04,120.55 19.91,120.55 C35.F1 | C35.N2 15.04,101.45 19.91,101.45 C35.N1 | 6.1,129.9 6.1,120.14 | 53.65,131.52 54.86,130.3 C32.C2 | 66.24,131.52 67.46,130.3 C31.C2 | 66.24,131.52 53.65,131.52
  Bottom 0.508: 79.65,131.52 80.47,130.71 C30.C2 | 79.65,131.52 66.24,131.52 | 92.25,131.52 93.07,130.71 C29.C2 | 92.25,131.52 79.65,131.52 | 92.25,131.52 104.44,131.52 105.66,130.3 C28.C2 106.88,130.71 107.7,131.52 115.01,131.52 116.23,130.3 118.26,130.3 C27.C2 119.48,129.9 124.77,129.9 C27.C1 125.98,129.9 131.27,129.9 C26.C2 132.49,130.3 133.3,131.12 136.96,131.12 137.36,131.52 145.9,131.52 | C28.T1 110.13,88.44 115.42,88.44 C27.T2 116.64,88.85 121.51,88.85 C27.T1 122.73,88.44 124.77,86.41 125.17,86.41 C27.U1 125.17,85.19 124.77,85.19 122.73,83.16 C27.V1 | B24.T1 160.93,155.09 161.34,154.69 165.41,154.69 165.81,154.28 171.09,154.28 172.31,155.5 B23.T1 | 145.9,131.52 145.09,130.71 C25.C2 | 155.25,131.52 145.9,131.52 | 155.25,131.52 156.46,130.3 C24.C2 | 155.25,131.52 167.84,131.52 169.06,130.3 C23.C2 170.28,130.71 171.09,131.52 221.89,131.52 | A14.T1 288.14,225.4 288.54,225.81 291.8,225.81 293.01,227.03 298.3,227.03 299.52,225.81 A13.T1 300.74,225.81 303.17,225.81 304.39,227.03 306.83,227.03 307.24,226.62 311.3,226.62 312.12,225.81 A12.T1 313.33,225.81 315.77,225.81 316.99,227.03 319.43,227.03 320.65,225.81 324.71,225.81 A11.T1 325.93,224.99 328.37,224.99 329.59,223.77 332.44,223.77 334.06,225.4 337.72,225.4 A10.T1 338.94,225.4 340.16,226.62 343.41,226.62 343.81,227.03 345.03,227.03 346.25,225.81 350.32,225.81 A09.T1 351.54,225.81 352.75,227.03 357.63,227.03 358.04,226.62 362.1,226.62 362.92,225.81 A08.T1 364.13,225.81 364.54,226.21 368.61,226.21 369.42,227.03 370.23,227.03 371.45,225.81 372.67,225.81 373.07,225.4 375.51,225.4 AB07.AT1 376.73,224.99 377.14,224.59 381.2,224.59 382.02,223.77 384.45,223.77 385.67,224.99 388.52,224.99 AB06.AT1 389.74,225.4 392.99,225.4 394.61,227.03 399.9,227.03 401.12,225.81 AB05.AT1 402.34,225.81 403.56,227.03 408.84,227.03 410.46,225.4 413.71,225.4 AB04.AT1 414.93,225.81 416.15,227.03 425.09,227.03
  Bottom 0.508: 425.09,227.03 426.31,225.81 AB03.AT1 | 438.1,227.03 439.32,225.81 AB02.AT1 | 425.09,227.03 438.1,227.03 | 438.1,227.03 446.63,227.03 447.04,226.62 451.1,226.62 451.92,225.81 A01.T1 | B24.C2 157.68,197.36 158.5,198.17 167.84,198.17 169.06,196.95 B23.C2 170.28,197.36 171.09,198.17 202.79,198.17 204.01,196.95 207.26,196.95 B20.C2 | A24.T1 160.93,224.99 162.15,223.77 171.09,223.77 172.31,224.99 A23.T1 | A17.T1 248.72,224.99 247.5,223.77 238.96,223.77 237.34,225.4 A18.T1 236.12,224.99 234.9,223.77 225.55,223.77 | 225.55,223.77 224.33,224.99 A19.T1 | 225.55,223.77 212.95,223.77 211.73,224.99 A20.T1 | A01.C2 448.67,267.26 447.85,268.07 442.16,268.07 440.94,266.85 437.29,266.85 AB02.AC2 436.07,266.04 435.25,265.23 427.94,265.23 427.13,266.04 424.28,266.04 AB03.AC2 423.06,266.45 421.84,265.23 416.56,265.23 416.15,265.63 412.5,265.63 411.68,266.45 AB04.AC2 410.46,266.45 410.06,266.45 408.84,265.23 403.96,265.23 403.56,265.63 399.9,265.63 399.08,266.45 AB05.AC2 397.87,266.45 397.46,266.45 396.24,265.23 391.36,265.23 390.96,265.63 387.3,265.63 386.49,266.45 AB06.AC2 385.27,266.04 384.86,265.63 380.8,265.63 380.39,265.23 378.36,265.23 377.55,266.04 373.48,266.04 AB07.AC2 372.26,266.45 371.04,265.23 365.76,265.23 364.95,266.04 360.48,266.04 A08.C2 359.66,266.85 356.41,266.85 354.79,265.23 345.85,265.23 | A20.C2 208.48,266.45 209.7,265.23 216.61,265.23 217.83,266.45 219.86,266.45 A19.C2 221.08,266.04 221.49,265.63 225.55,265.63 225.96,265.23 229.21,265.23 230.02,266.04 232.87,266.04 A18.C2 234.09,266.45 235.31,265.23 244.25,265.23 245.47,266.45 A17.C2 246.69,266.45 247.9,265.23 258.88,265.23 260.91,267.26 283.67,267.26 A14.C2 284.89,266.45 285.7,265.63 289.36,265.63 289.76,265.23 295.05,265.23 296.27,266.45 A13.C2 297.49,266.45 301.14,266.45 302.36,265.23 303.99,265.23 304.39,265.63 308.05,265.63 308.86,266.45 A12.C2 310.08,266.45 313.74,266.45 314.96,265.23 316.59,265.23 317.81,266.45 321.46,266.45 A11.C2 322.68,266.04 323.09,265.63 327.15,265.63 327.56,265.23 330.4,265.23 331.22,266.04 334.47,266.04 A10.C2 335.69,266.45 338.12,266.45 339.34,265.23 345.85,265.23
  Bottom 0.508: 345.85,265.23 347.07,266.45 A09.C2 | D01.T1 451.92,18.54 451.1,17.73 441.76,17.73 440.54,18.95 D02.T1 439.32,18.54 438.51,17.73 412.9,17.73 | D17.T1 249.94,18.95 254.81,18.95 D16.T2 | 272.69,17.73 273.91,18.95 D15.T1 | 272.69,17.73 263.35,17.73 262.53,18.54 D16.T1 | 286.11,17.73 286.92,18.54 D14.T1 | 272.69,17.73 286.11,17.73 | 298.7,17.73 299.52,18.54 D13.T1 | 286.11,17.73 298.7,17.73 | 311.3,17.73 312.12,18.54 D12.T1 | 298.7,17.73 311.3,17.73 | 323.49,17.73 324.71,18.95 D11.T1 | 311.3,17.73 323.49,17.73 | 336.91,17.73 337.72,18.54 D10.T1 | 323.49,17.73 336.91,17.73 | 349.5,17.73 350.32,18.54 D09.T1 | 336.91,17.73 349.5,17.73 | 362.1,17.73 362.92,18.54 D08.T1 | 349.5,17.73 362.1,17.73 | 374.29,17.73 375.51,18.95 D07.T1 | 362.1,17.73 374.29,17.73 | 387.71,17.73 388.52,18.54 D06.T1 | 374.29,17.73 387.71,17.73 | 400.3,17.73 401.12,18.54 D05.T1 | 387.71,17.73 400.3,17.73 | 412.9,17.73 413.71,18.54 D04.T1 | 400.3,17.73 412.9,17.73 | D19.C2 221.08,60.81 221.49,61.21 225.55,61.21 225.96,61.62 228.4,61.62 229.21,60.81 232.87,60.81 D18.C2 234.09,60.4 236.12,60.4 237.34,61.62 240.59,61.62 241,61.21 245.06,61.21 245.47,60.81 D17.C2 246.69,60.81 247.09,61.21 251.16,61.21 251.56,61.62 253.59,61.62 254.81,60.4 258.06,60.4 D16.C2 259.28,60.81 262.13,60.81 262.94,61.62 266.19,61.62 266.6,61.21 269.85,61.21 270.66,60.4 D15.C2 271.88,60.81 272.29,61.21 276.35,61.21 276.76,61.62 286.11,61.62 | C02.T1 440.54,89.26 441.76,90.47 450.7,90.47 451.92,89.26 C01.T1 | 441.35,61.62 438.51,61.62 437.29,60.4 D02.C2 436.07,60 434.85,58.78 425.09,58.78 424.28,59.59 CD03.BC2 423.06,60.4 422.25,61.21 419,61.21 418.59,61.62 416.56,61.62 415.75,60.81 411.68,60.81 D04.C2 410.46,60.4 409.25,61.62 399.9,61.62 399.08,60.81 D05.C2 397.87,60.81 397.05,61.62 387.71,61.62 386.49,60.4 D06.C2 385.27,60.81 384.45,61.62 376.73,61.62 375.92,60.81 373.48,60.81 D07.C2 372.26,60.4 371.45,61.21 368.2,61.21 367.79,61.62 364.54,61.62 363.73,60.81 360.88,60.81 D08.C2 359.66,60.4 358.85,61.21 355.19,61.21 354.79,61.62 351.94,61.62 351.13,60.81 348.29,60.81 D09.C2 347.07,60.81 346.66,61.21 342.6,61.21 342.19,61.62 338.94,61.62 337.72,60.4 335.69,60.4 D10.C2 334.47,60.81 334.06,61.21 330,61.21 329.59,61.62 320.24,61.62
  Bottom 0.508: 441.35,61.62 447.85,61.62 448.67,60.81 D01.C2 | 441.35,61.62 v441.35,62.03 | 286.11,61.62 284.89,60.4 D14.C2 | 286.11,61.62 295.45,61.62 | 295.45,61.62 296.27,60.81 D13.C2 | 307.64,61.62 308.86,60.4 D12.C2 | 295.45,61.62 307.64,61.62 | 320.24,61.62 321.46,60.4 D11.C2 | 307.64,61.62 320.24,61.62 | v263.35,34.8 259.28,34.8 D16.M2 | B18.C2 234.09,196.54 234.9,195.73 238.56,195.73 238.96,195.33 281.63,195.33 282.85,196.54 283.67,196.54 B14.C2 284.89,196.95 286.11,198.17 291.39,198.17 292.2,197.36 296.27,197.36 B13.C2 297.49,197.36 300.33,197.36 301.14,198.17 303.99,198.17 304.39,197.76 308.05,197.76 308.86,196.95 B12.C2 310.08,197.36 312.93,197.36 313.74,198.17 316.99,198.17 317.4,197.76 320.65,197.76 321.46,196.95 B11.C2 322.68,197.36 325.53,197.36 326.34,198.17 329.59,198.17 330,197.76 334.06,197.76 334.47,197.36 B10.C2 335.69,196.95 336.5,197.76 340.16,197.76 340.56,198.17 342.19,198.17 343,197.36 347.07,197.36 B09.C2 348.29,197.36 348.69,197.76 352.75,197.76 353.16,198.17 354.79,198.17 355.6,197.36 360.07,197.36 B08.C2 360.88,197.36 361.29,197.76 365.35,197.76 365.76,198.17 369.01,198.17 370.23,196.95 372.26,196.95 AB07.BC2 | AB03.BC2 424.28,196.14 426.31,194.11 AB03.BD1 426.72,192.89 424.69,190.86 424.28,190.86 AB03.BE2 | AB03.BE2 423.47,190.04 423.06,190.04 421.03,188.01 AB03.BF2 420.22,186.79 414.93,186.79 AB04.BF1 414.12,188.01 412.09,190.04 411.68,190.04 AB04.BE2 | AB03.BE2 424.28,190.04 424.69,190.04 426.72,188.01 AB03.BF1 427.53,186.79 432.82,186.79 AB02.BF2 433.63,188.01 435.66,190.04 436.07,190.04 AB02.BE2
  Bottom 0.508: AB02.BH1 442.57,184.76 442.16,184.76 440.13,186.79 AB02.BF1 439.32,188.01 437.29,190.04 436.88,190.04 AB02.BE2 | AB02.BD1 439.73,192.89 437.69,190.86 437.29,190.86 AB02.BE2 | AB02.BC2 436.88,196.14 438.91,194.11 439.32,194.11 AB02.BD1 | B01.C2 448.67,196.54 448.26,196.14 444.19,196.14 441.76,193.7 440.54,193.7 AB02.BD1 | AB07.BF2 370.64,187.2 375.51,187.2 AB07.BF1 376.73,186.79 382.02,186.79 AB06.BF2 | AB04.BE2 410.46,190.04 408.43,188.01 AB04.BF2 407.21,187.2 402.34,187.2 AB05.BF1 401.52,188.01 401.12,188.01 399.08,190.04 AB05.BE2 397.87,190.04 397.46,190.04 395.43,188.01 AB05.BF2 394.61,187.2 389.74,187.2 AB06.BF1 388.52,188.01 386.49,190.04 386.08,190.04 AB06.BE2 | AB04.BE2 411.68,190.86 412.09,190.86 414.12,192.89 AB04.BD1 413.71,194.11 413.31,194.11 411.28,196.14 AB04.BC2 | AB05.BC2 398.68,196.14 400.71,194.11 401.12,194.11 AB05.BD1 | AB04.BN1 413.71,168.1 408.43,168.1 AB04.BN2 407.21,168.1 402.34,168.1 AB05.BN1 401.12,167.69 395.83,167.69 AB05.BN2 394.61,168.1 389.74,168.1 AB06.BN1 388.52,168.1 383.24,168.1 AB06.BN2 382.02,167.69 376.73,167.69 AB07.BN1 375.51,168.1 370.64,168.1 AB07.BN2 | AB03.BN2 421.44,168.1 426.31,168.1 AB03.BN1 427.53,168.1 432.82,168.1 AB02.BN2 434.04,168.1 439.32,168.1 AB02.BN1 | 298.7,154.28 289.36,154.28 288.14,155.5 B14.T1 | 298.7,154.28 299.52,155.09 B13.T1 | 311.3,154.28 312.12,155.09 B12.T1 | 311.3,154.28 298.7,154.28 | 323.49,154.28 324.71,155.5 B11.T1 | 323.49,154.28 311.3,154.28 | 323.49,154.28 332.84,154.28 333.25,154.69 337.31,154.69 337.72,155.09 B10.T1 338.94,155.5 339.75,154.69 343,154.69 343.41,154.28 352.75,154.28
  Bottom 0.508: 352.75,154.28 351.54,155.5 B09.T1 | 362.1,154.28 352.75,154.28 | 362.1,154.28 362.92,155.09 B08.T1 | 374.29,154.28 375.51,155.5 AB07.BT1 | 374.29,154.28 362.1,154.28 | 387.71,154.28 388.52,155.09 AB06.BT1 | 387.71,154.28 374.29,154.28 | 400.3,154.28 401.12,155.09 AB05.BT1 | 400.3,154.28 387.71,154.28 | 412.9,154.28 413.71,155.09 AB04.BT1 | 412.9,154.28 400.3,154.28 | 425.09,154.28 426.31,155.5 AB03.BT1 | 425.09,154.28 412.9,154.28 | 438.51,154.28 439.32,155.09 AB02.BT1 | 438.51,154.28 425.09,154.28 | 438.51,154.28 451.1,154.28 451.92,155.09 B01.T1 | 221.89,154.28 212.55,154.28 211.73,155.09 B20.T1 | 221.89,154.28 223.11,155.5 B19.T1 | 221.89,154.28 235.31,154.28 236.12,155.09 B18.T1 | 221.89,131.52 221.08,130.71 C19.C2 | 232.05,131.52 221.89,131.52 | 232.05,131.52 232.87,130.71 C18.C2 | 232.05,131.52 244.65,131.52 245.47,130.71 C17.C2 246.69,129.9 247.9,128.68 266.19,128.68 267.82,130.3 270.66,130.3 C15.C2 271.88,129.49 272.69,128.68 280.01,128.68 281.23,129.9 283.67,129.9 C14.C2 284.89,130.3 286.11,131.52 291.39,131.52 291.8,131.12 295.86,131.12 296.27,130.71 C13.C2 297.49,130.71 301.55,130.71 302.36,131.52 303.99,131.52 304.39,131.12 308.05,131.12 308.86,130.3 C12.C2 310.08,130.71 310.49,131.12 314.55,131.12 314.96,131.52 316.99,131.52 318.21,130.3 321.46,130.3 C11.C2 322.68,130.71 323.09,131.12 327.15,131.12 327.56,131.52 330,131.52 330.81,130.71 334.47,130.71 C10.C2 335.69,130.3 336.91,131.52 346.25,131.52 | 285.7,90.47 280.42,90.47 280.01,90.07 275.95,90.07 275.13,89.26 C15.T1 | 285.7,90.47 286.92,89.26 C14.T1 | 298.3,90.47 299.52,89.26 C13.T1 | 298.3,90.47 285.7,90.47
  Bottom 0.508: 298.3,90.47 306.83,90.47 307.24,90.07 311.3,90.07 312.12,89.26 C12.T1 312.93,89.66 317.4,89.66 318.21,90.47 323.49,90.47 | 323.49,90.47 324.71,89.26 C11.T1 | 323.49,90.47 336.5,90.47 337.72,89.26 C10.T1 338.53,89.66 341.78,89.66 342.6,90.47 349.1,90.47 350.32,89.26 C09.T1 351.54,89.26 352.75,90.47 357.63,90.47 358.85,89.26 362.92,89.26 C08.T1 364.13,89.26 366.57,89.26 367.79,90.47 374.29,90.47 375.51,89.26 C07.T1 376.73,89.26 377.55,90.07 381.61,90.07 382.02,90.47 384.45,90.47 385.67,89.26 388.52,89.26 C06.T1 389.74,89.26 390.55,90.07 394.21,90.07 394.61,90.47 397.05,90.47 398.27,89.26 401.12,89.26 C05.T1 402.34,88.85 407.21,88.85 C04.T2 408.43,88.44 413.71,88.44 C04.T1 | 346.25,131.52 347.07,130.71 C09.C2 | 346.25,131.52 358.44,131.52 359.66,130.3 C08.C2 360.88,129.9 363.73,129.9 364.95,128.68 371.04,128.68 | 371.04,128.68 372.26,129.9 C07.C2 | 371.04,128.68 380.39,128.68 380.8,129.08 384.45,129.08 385.27,129.9 C06.C2 386.49,130.3 387.3,131.12 390.96,131.12 391.36,131.52 394.21,131.52 395.02,130.71 397.87,130.71 C05.C2 398.68,129.49 398.68,125.42 408.84,125.42 | 408.84,125.42 410.06,124.21 410.46,124.21 C04.E2 | 408.84,125.42 408.03,126.24 C04.D2 408.43,127.46 408.84,127.46 410.87,129.49 C04.C2 411.68,130.71 412.5,131.52 418.59,131.52 419.81,130.3 423.06,130.3 CD03.AC2 424.28,129.49 427.13,129.49 427.94,128.68 434.85,128.68 436.07,129.9 C02.C2 437.29,130.3 437.69,130.3 438.91,131.52 447.85,131.52 448.67,130.71 C01.C2
GO\  (via drill 0.61)
  Top 0.203: 356.01,139.65 356.01,105.51 357.23,104.29 357.23,102.26 C08.N2 | 356.01,139.65 356.01,154.28 356.82,155.09 B08.T2 | 356.01,139.65 v356.41,139.65
  Route2 0.203: D12.C1 316.59,60.81 316.59,64.06 318.62,66.09 319.43,66.09 321.46,68.12 322.68,68.12 327.15,72.59 328.37,72.59 334.06,78.28 336.91,78.28 338.12,79.5 338.94,79.5 340.16,80.72 340.16,82.35 355.19,97.38 355.19,99.42 356.82,101.04 C08.N2
  Route15 0.203: v312.12,140.87 293.83,159.16 293.83,161.19 B13.R2
  Bottom 0.203: v312.12,140.87 312.52,140.46 315.77,140.46 316.18,140.06 333.65,140.06 334.47,140.87 349.5,140.87 351.13,139.24 356.01,139.24 v356.41,139.65
HZ880
  Top 0.203: C33.P2 42.67,99.01 41.05,100.63 41.05,110.39 39.83,111.61 39.83,113.64 C33.J2
ILLEGAL_REF\  (via drill 0.61)
  Top 0.203: v386.89,81.53 v386.89,56.74 | v298.7,235.56 298.7,247.34 299.52,248.16 299.52,248.97 298.7,249.78 298.7,261.57 299.92,262.79 A13.D1 | v429.56,145.75 432,143.31 432,128.27 432.82,127.46 C02.D2
  Route2 0.203: v386.89,81.53 386.89,81.94 386.89,82.75 429.16,125.02 431.19,125.02 432.82,126.64 C02.D2
  Route15 0.203: v298.7,235.56 298.7,235.15 v319.02,214.83 | v328.78,211.18 329.18,211.18 364.13,176.22 365.35,176.22 366.17,175.41 366.98,175.41 372.26,170.13 372.67,170.13 373.07,169.72 373.07,168.91 v395.83,146.15
  Bottom 0.203: v386.89,56.74 388.11,55.52 439.32,55.52 442.57,52.27 444.19,52.27 445.41,51.05 D01.F2 | v386.89,81.53 386.08,82.35 383.24,82.35 C06.V2 | v319.02,214.83 322.68,211.18 v328.78,211.18 | v395.83,146.15 396.24,145.75 v429.56,145.75
IN_STOP2\
  Top 0.203: D32.V2 52.02,13.26 51.21,14.07 51.21,23.83 52.02,24.64 D32.R2
INHIBIT
  Route2 0.203: D16.P2 258.47,29.11 258.47,31.14 252.37,37.24 247.9,32.77 246.28,32.77 239.78,39.27 244.25,43.74 244.25,69.75 238.15,75.84 275.95,113.64 275.95,115.27 277.57,116.89 C15.H1
INHIBIT\
  Top 0.203: D16.R2 254.81,25.45 252.78,27.48 252.78,27.89 D17.P1 | D17.D2 243.43,56.74 245.47,54.71 245.47,54.3 D17.E2 245.47,53.49 245.47,53.09 243.43,51.05 D17.F2 243.43,50.24 245.47,48.21 245.47,47.8 D17.H2 246.28,46.99 246.28,44.55 247.9,42.93 247.9,26.67 248.72,25.86 D17.R1
  Bottom 0.203: D17.R1 249.94,25.86 251.97,27.89 D17.P1
INITIALIZE  (via drill 0.61)
  Top 0.203: v400.3,84.38 400.3,97.38 401.12,98.2 401.12,101.04 C05.N1 | 67.06,49.43 67.46,49.43 67.46,53.9 D31.E2 | 67.06,49.43 v64.21,49.43 | v69.49,79.5 69.49,64.87 67.06,62.43 67.06,49.43
  Route15 0.203: v400.3,84.38 400.3,81.94 422.25,60 422.25,52.27 436.47,38.05 436.47,35.61 D02.M2 436.07,34.39 434.04,34.39 v409.25,9.6 | v302.36,7.16 297.49,2.29 297.08,2.69 242.21,2.69 234.49,10.41 234.49,11.63 v166.22,79.91
  Bottom 0.203: v64.21,49.43 53.65,49.43 52.83,50.24 D32.F2 | 126.8,79.91 126.8,79.5 v69.49,79.5 | 126.8,79.91 126.8,86.41 123.14,90.07 121.11,90.07 119.48,91.69 C27.S2 | v409.25,9.6 405.18,5.54 335.28,5.54 334.87,5.94 316.59,5.94 315.37,7.16 v302.36,7.16 | v166.22,79.91 126.8,79.91
INITIALIZE\  (via drill 0.61)
  Top 0.203: C30.V2 78.44,82.75 80.47,84.78 80.47,85.19 C30.U2 | v383.64,109.98 384.05,109.58 384.05,103.48 382.83,102.26 C06.N2 | v390.14,117.7 390.55,118.11 390.55,134.77 391.77,135.99 C06.A1 | 428.75,31.95 432.82,31.95 D02.N2 | v428.75,44.55 428.75,31.95 | v428.35,13.66 428.75,14.07 428.75,31.95
  Route2 0.203: v383.64,109.98 384.45,110.79 384.45,112.01 v390.14,117.7
  Route15 0.203: v428.75,44.55 428.75,44.96 421.84,51.87 421.84,57.96 410.06,69.75 410.06,71.37 390.14,91.29 389.74,91.29 389.33,91.69 389.33,92.91 384.45,97.79 384.45,99.42 382.83,101.04 C06.N2 | v158.5,16.92 125.98,49.43 125.98,49.84 91.44,84.38 86.56,84.38 85.34,85.6 81.69,85.6 C30.U2
  Bottom 0.203: v158.5,16.92 158.9,17.32 261.72,17.32 264.57,14.48 345.44,14.48 345.85,14.07 427.94,14.07 v428.35,13.66
INPUT_BUS00  (via drill 0.61)
  Top 0.203: v294.64,119.33 295.05,118.92 295.05,113.64 289.36,107.95 289.36,77.88 291.8,75.44 291.8,53.09 293.42,51.46 D13.F2
  Route2 0.203: v294.64,119.33 313.74,138.43 313.74,140.06 320.24,146.56 321.06,146.56 323.09,148.59 323.09,149.81 329.59,156.31 329.59,157.53 333.25,161.19 333.25,167.28 v341.38,175.41
  Bottom 0.203: v341.38,175.41 341.78,175.82 352.75,175.82 353.16,175.41 356.01,175.41 359.66,179.07 363.73,179.07 364.13,178.66 365.76,178.66 366.17,179.07 376.33,179.07 377.14,178.26 378.76,178.26 AB07.BK1
INPUT_BUS01  (via drill 0.61)
  Top 0.203: v387.3,128.68 387.71,129.08 387.71,140.06 389.33,141.68 389.33,147.37 390.14,148.18 v390.14,170.94
  Route2 0.203: v321.87,74.62 294.23,46.99 294.23,44.96 D13.J2 | v338.12,75.03 340.97,77.88 341.78,77.88 349.1,85.19 349.1,89.26 358.04,98.2 358.44,98.2 358.85,98.6 358.85,100.23 v387.3,128.68
  Bottom 0.203: v321.87,74.62 322.27,75.03 v338.12,75.03 | v390.14,170.94 388.11,172.97 381.2,172.97 379.98,171.75 AB07.BM1
INPUT_BUS02  (via drill 0.61)
  Top 0.203: v328.37,32.77 v325.12,36.02 | v395.83,140.87 396.65,141.68 396.65,158.75 393.39,162 393.39,175.82 392.18,177.04 AB06.BK1
  Route2 0.203: v328.37,32.77 339.34,43.74 339.34,44.55 340.16,45.36 340.97,45.36 384.05,88.44 384.05,92.1 384.45,92.51 384.45,94.13 398.68,108.36 399.9,108.36 403.96,112.42 403.96,114.45 405.99,116.48 405.99,122.99 415.75,132.74 415.75,140.06 v416.97,141.28
  Bottom 0.203: v325.12,36.02 324.71,36.42 311.71,36.42 311.3,36.83 295.05,36.83 294.23,37.64 D13.L2 | v416.97,141.28 416.56,140.87 v395.83,140.87
INPUT_BUS03  (via drill 0.61)
  Top 0.203: v300.33,71.78 300.33,68.12 295.45,63.25 295.45,33.58 294.23,32.36 D13.N2
  Route2 0.203: v300.33,71.78 301.14,72.59 301.14,79.5 311.71,90.07 315.77,90.07 320.65,94.94 322.27,94.94 337.72,110.39 338.94,110.39 340.16,111.61 340.16,112.01 343.81,115.67 346.25,115.67 350.32,111.61 358.44,119.74 358.44,120.95 360.07,122.58 361.29,122.58 374.29,135.59 374.29,138.02 384.45,148.18 384.45,153.47 390.14,159.16 390.14,169.32 391.77,170.94 AB06.BM1
INPUT_BUS04  (via drill 0.61)
  Top 0.203: v64.21,269.29 64.21,263.2 62.18,261.16 A32.E1 | v258.88,273.36 261.31,270.92 v261.31,266.04 | v290.98,264.01 291.8,264.82 291.8,283.52 293.01,284.73 369.42,284.73 v369.42,273.76 | v408.84,234.34 409.25,233.93 409.25,215.24 407.21,213.21 407.21,201.42 406.4,200.61 406.4,179.48 405.18,178.26 AB05.BK1
  Route15 0.203: v369.42,273.76 v408.84,234.34
  Bottom 0.203: v64.21,269.29 66.65,271.73 108.1,271.73 111.35,274.98 248.72,274.98 251.97,271.73 253.19,271.73 254.81,273.36 v258.88,273.36 | v261.31,266.04 261.72,265.63 283.26,265.63 284.07,264.82 289.36,264.82 290.17,264.01 v290.98,264.01
INPUT_BUS05  (via drill 0.61)
  Top 0.203: v286.92,259.13 289.36,259.13 289.36,261.16 302.77,274.57 308.05,274.57 308.05,272.14 v310.49,269.7
  Route2 0.203: v310.49,269.7 312.12,271.32 323.9,271.32 324.71,272.14 325.53,272.14 327.96,274.57 336.91,274.57 v337.31,274.17 | v378.76,232.72 378.76,229.87 377.95,229.06 377.95,223.77 377.55,223.37 377.55,222.56 375.11,220.12 375.11,215.24 v369.42,209.55
  Route15 0.203: v337.31,274.17 338.12,274.17 340.56,271.73 346.66,271.73 356.41,261.98 356.41,259.94 364.95,251.41 364.95,248.56 365.35,248.16 365.35,246.94 366.17,246.13 367.39,246.13 368.61,244.91 368.61,243.69 377.14,235.15 377.55,235.15 377.95,234.75 377.95,233.53 v378.76,232.72 | v369.42,209.55 369.42,203.86 379.17,194.11 379.17,193.7 382.02,190.86 383.24,190.86 400.71,173.38 403.15,173.38 404.37,172.16 AB05.BM1
  Bottom 0.203: v286.92,259.13 276.35,259.13 273.91,256.69 260.91,256.69 258.88,258.72 108.92,258.72 102.01,251.82 87.78,251.82 87.38,252.22 53.65,252.22 52.83,251.41 A32.J2
INPUT_BUS06  (via drill 0.61)
  Top 0.203: v51.21,277.42 51.21,268.07 56.9,262.38 56.9,246.13 58.12,244.91 A32.L1 | v227.99,278.64 253.19,278.64 253.19,281.89 277.57,281.89 v277.57,281.48 | v372.26,284.33 371.86,283.92 371.86,270.1 377.95,264.01 377.95,258.72 381.2,255.47 381.2,242.06 384.05,239.22 384.05,222.56 v382.42,220.93
  Route2 0.203: v277.57,281.48 282.45,281.48 283.26,282.3 290.58,282.3 292.2,283.92 319.84,283.92 320.65,284.73 369.42,284.73 371.04,283.11 v372.26,284.33
  Route15 0.203: v382.42,220.93 379.98,218.49 385.67,212.8 385.67,211.58 415.75,181.51 415.75,179.48 416.97,178.26 AB04.BK1
  Bottom 0.203: v51.21,277.42 52.02,278.23 124.36,278.23 124.77,278.64 v227.99,278.64
INPUT_BUS07  (via drill 0.61)
  Top 0.203: v356.82,236.37 358.44,234.75 358.44,222.56 v357.63,221.74
  Route2 0.203: v318.62,210.36 318.62,211.58 319.43,212.39 319.43,213.21 323.09,216.86 325.12,216.86 344.22,235.97 v344.22,236.37
  Route15 0.203: v99.16,233.53 105.26,233.53 v116.64,222.15 | v295.05,221.74 295.45,221.74 309.68,207.52 310.49,207.52 311.3,206.7 312.93,206.7 313.74,205.89 315.77,205.89 319.43,209.55 v318.62,210.36 | v357.63,221.74 358.04,221.74 362.92,216.86 363.73,216.86 v365.35,215.24 | v388.52,212.8 388.52,209.55 416.15,181.91 416.15,181.1 419,178.26 419,173.38 417.78,172.16 AB04.BM1
  Bottom 0.203: v99.16,233.53 61.37,233.53 60.96,233.93 56.49,233.93 56.08,234.34 A32.P2 | v116.64,222.15 121.11,226.62 175.16,226.62 177.6,224.18 177.6,221.34 177.19,221.34 174.35,218.49 174.35,217.27 260.5,217.27 267,223.77 293.01,223.77 v295.05,221.74 | v344.22,236.37 344.63,235.97 346.66,235.97 347.07,236.37 v356.82,236.37 | v365.35,215.24 365.76,215.65 385.67,215.65 v388.52,212.8
INPUT_BUS08  (via drill 0.61)
  Top 0.203: v410.87,226.62 412.5,226.62 412.5,227.03 412.9,227.43 416.15,227.43 416.15,219.3 419.4,216.05 419.4,201.42 419,201.02 419,180.7 v420.62,179.07
  Route2 0.203: v112.57,281.89 62.59,231.9 62.59,229.06 A32.S1 | v321.46,244.91 322.27,245.72 323.49,245.72 333.65,255.88 334.06,255.88 334.47,256.29 334.47,257.5 v348.69,271.73
  Route15 0.203: v270.66,279.45 271.88,279.45 272.29,279.04 273.1,279.04 273.91,278.23 283.26,278.23 305.61,255.88 306.02,255.88 308.05,253.85 308.05,253.44 308.86,252.63 309.27,252.63 311.3,250.6 311.3,250.19 312.12,249.38 316.99,249.38 v321.46,244.91 | v348.69,271.73 352.35,275.39 356.01,275.39 359.66,271.73 364.95,271.73 386.49,250.19 387.3,250.19 v410.87,226.62
  Bottom 0.203: v112.57,281.89 112.98,281.48 166.22,281.48 167.03,280.67 254,280.67 254.41,281.08 269.04,281.08 v270.66,279.45 | v420.62,179.07 428.35,179.07 429.16,178.26 429.56,178.26 AB03.BK1
INPUT_BUS09  (via drill 0.61)
  Top 0.203: v366.98,77.47 365.35,79.1 359.66,79.1 359.66,77.88 358.44,76.66 v357.23,76.66
  Route2 0.203: v366.98,77.47 375.11,85.6 375.11,91.29 393.39,109.58 393.39,110.39 393.8,110.79 393.8,114.86 394.61,115.67 395.83,115.67 397.05,116.89 397.05,118.11 414.53,135.59 414.53,142.09 419.4,146.96 419.4,149.81 428.75,159.16 428.75,167.28 429.56,168.1 429.56,170.94 AB03.BM1 | v357.23,76.66 350.32,69.75 337.31,69.75 332.44,74.62 312.12,54.3 v311.71,54.3
  Route15 0.203: v200.35,52.68 200.35,57.96 150.37,107.95 150.37,109.58 123.95,135.99 123.95,137.62 87.78,173.79 87.78,175.41 54.86,208.33 54.86,209.14 54.46,209.55 54.46,216.86 52.83,218.49 A32.V2
  Bottom 0.203: v311.71,54.3 310.08,52.68 v200.35,52.68
INPUT_BUS10  (via drill 0.61)
  Top 0.203: v404.37,173.38 407.21,176.22 v407.21,176.63
  Route15 0.203: v128.42,259.54 v206.04,181.91
  Bottom 0.203: v128.42,259.54 126.39,261.57 105.66,261.57 103.23,259.13 51.21,259.13 49.99,260.35 A33.E1 | v206.04,181.91 211.33,176.63 273.91,176.63 280.42,170.13 401.12,170.13 v404.37,173.38 | v407.21,176.63 441.35,176.63 442.16,177.44 AB02.BK1
INPUT_BUS11  (via drill 0.61)
  Route2 0.203: v340.16,274.17 340.16,273.76 334.87,268.48 332.44,268.48 319.43,255.47 v319.02,255.47
  Route15 0.203: v340.16,274.17 341.78,275.79 359.66,275.79 363.32,272.14 365.35,272.14 382.02,255.47 386.49,255.47 412.09,229.87 413.71,229.87 414.53,229.06 414.53,228.24 423.06,219.71 423.06,214.83 442.98,194.92 446.63,194.92 447.85,193.7 447.85,189.64 451.1,186.38 451.1,174.19 452.73,172.57 450.29,170.13 448.67,170.13 447.85,170.94 443.38,170.94 AB02.BM1 | v293.42,252.63 282.04,252.63 281.63,253.03 279.2,253.03 278.79,253.44 256.44,253.44 234.49,275.39 221.08,275.39 219.86,276.61 124.77,276.61 124.36,277.01 89.81,277.01 88.59,278.23 58.12,278.23 36.17,256.29 37.8,254.66 37.8,253.03 39.42,251.41 A33.J2
  Bottom 0.203: v319.02,255.47 307.24,255.47 304.39,252.63 v293.42,252.63
INT_DELAY  (via drill 0.61)
  Top 0.203: v315.37,149.81 317.81,152.25 317.81,168.91 320.24,171.35 320.24,177.85 319.43,178.66 319.43,180.29 B11.J2
  Route2 0.203: v315.37,149.81 308.05,142.49 307.24,142.49 294.23,129.49 294.23,127.46 C13.D2
INT_ENABLE
  Bottom 0.203: B11.F2 319.84,187.2 324.71,187.2 B11.F1
INT_ENABLE\
  Route15 0.203: C01.S2 448.67,92.51 444.6,92.51 399.08,138.02 396.24,138.02 394.21,140.06 388.93,140.06 385.67,143.31 384.05,143.31 357.63,169.72 353.57,169.72 339.34,183.95 338.12,183.95 336.09,185.98 335.28,185.98 332.44,188.82 331.22,188.82 329.18,190.86 B11.E1
  Bottom 0.203: B11.E2 322.68,190.04 327.96,190.04 B11.E1
INT_INHIBIT\  (via drill 0.61)
  Route15 0.203: v58.12,130.3 40.64,147.78 39.01,147.78 26.01,160.78 19.91,160.78 8.53,172.16 8.53,174.19 B36.L1
  Bottom 0.203: 133.3,125.02 151.99,125.02 154.43,122.58 230.43,122.58 233.68,119.33 291.8,119.33 293.01,120.55 C13.F2 | 133.3,125.02 132.49,124.21 C26.E2 | v58.12,130.3 60.15,128.27 111.35,128.27 114.61,125.02 133.3,125.02
INT_IO_BUS4\
  Top 0.203: A32.D1 58.52,264.01 58.52,269.29 A32.B1
INT_IO_BUS5\
  Top 0.203: A32.H2 55.27,254.66 55.27,259.54 A32.E2
INT_IO_BUS6\
  Top 0.203: A32.K1 61.37,248.16 61.37,253.44 A32.H1
INT_IO_BUS7\
  Top 0.203: A32.N2 52.02,238.81 52.02,243.69 A32.L2
INT_IO_BUS8\
  Top 0.203: A32.R1 58.12,232.31 58.12,237.59 A32.N1
INT_IO_BUS9\
  Top 0.203: A32.U2 55.27,222.96 55.27,227.84 A32.S2
INT_IO_BUS10\
  Top 0.203: A33.D1 45.52,264.01 45.52,269.29 A33.B1
INT_IO_BUS11\
  Top 0.203: A33.H2 42.67,254.66 42.67,259.54 A33.E2
INT_OK  (via drill 0.61)
  Top 0.203: B12.N2 306.02,167.69 306.02,166.88 305.21,166.06 305.21,151.44 v305.61,151.03 305.61,150.62 305.21,150.22 305.21,138.84 306.43,137.62 306.43,135.59 305.21,134.37 305.21,107.14 v305.21,106.73 305.21,70.56 307.64,68.12 307.64,45.77 306.83,44.96 D12.J2
  Bottom 0.203: v305.61,151.03 298.7,151.03 297.49,152.25 B13.U2 | v305.21,106.73 269.85,106.73 269.04,107.54 C15.L2
INT_OK\  (via drill 0.61)
  Top 0.203: v309.68,168.91 309.68,170.94 B12.M2 | v293.83,153.06 292.2,151.44 292.2,116.08 293.42,114.86 C13.J2
  Route2 0.203: v293.83,153.06 v309.68,168.91
  Route15 0.203: v321.87,88.04 297.49,112.42 295.86,112.42 294.23,114.05 C13.J2
  Bottom 0.203: C13.J2 294.23,114.05 299.52,114.05 C13.J1 | v321.87,88.04 322.27,87.63 343,87.63 343.81,88.44 C09.T2
INT_RQST  (via drill 0.61)
  Top 0.203: v95.91,183.95 102.01,177.85 102.01,128.27 102.82,127.46 C28.D2
  Route15 0.203: v95.91,183.95 45.11,234.75 43.48,234.75 A33.P2
INT_SKIP_EN\  (via drill 0.61)
  Top 0.203: v269.44,85.6 269.85,86 269.85,109.17 269.44,109.58 269.44,118.92 273.1,122.58 273.1,155.09 274.32,156.31 274.32,159.16 274.73,159.56 274.73,188.42 274.32,188.82 274.32,189.64 275.54,190.86 275.54,203.86 275.13,204.27 275.13,205.89 276.35,207.11 v276.35,224.59
  Route2 0.203: v341.78,213.21 356.82,228.24 359.66,228.24 A08.S2
  Route15 0.203: v308.86,215.24 304.8,215.24 302.36,217.68 302.36,218.9 297.89,223.37 v297.89,223.77
  Bottom 0.203: v269.44,85.6 273.91,81.13 313.33,81.13 314.15,81.94 318.62,81.94 C11.V2 | A14.T2 280.42,224.99 276.76,224.99 v276.35,224.59 276.35,224.18 297.49,224.18 v297.89,223.77 | v341.78,213.21 321.87,213.21 319.43,215.65 309.27,215.65 v308.86,215.24
INT_STROBE  (via drill 0.61)
  Top 0.203: v285.29,109.98 285.29,99.82 284.48,99.01 C14.P2 | v436.07,69.34 437.69,67.72 437.69,27.48 439.32,25.86 D02.R1 | v329.18,180.29 329.18,183.13 328.78,183.54 B11.H1 | v371.04,172.97 371.45,172.57 v371.45,146.15 371.45,145.75 v371.45,143.31
  Route2 0.203: v331.22,141.28 316.59,126.64 315.37,126.64 300.33,111.61 297.49,111.61 C13.K2
  Route15 0.203: v436.07,69.34 399.9,105.51 399.9,111.61 398.27,113.23 400.71,115.67 402.34,115.67 402.74,116.08 402.74,116.89 401.93,117.7 401.93,120.14 C05.F1 401.12,120.95 399.49,122.58 397.46,122.58 372.67,147.37 v371.45,146.15 | v336.91,172.57 v329.18,180.29
  Bottom 0.203: v285.29,109.98 295.45,109.98 296.27,110.79 C13.K2 | v336.91,172.57 337.31,172.97 v371.04,172.97 | v331.22,141.28 331.62,141.68 356.01,141.68 356.82,142.49 360.88,142.49 361.7,143.31 v371.45,143.31
INT_SYNC  (via drill 0.61)
  Top 0.203: v298.3,138.43 298.3,125.83 297.08,124.61 C13.E2 | v325.53,138.43 326.75,139.65 326.75,170.94 v326.34,171.35
  Bottom 0.203: v298.3,138.43 319.02,138.43 319.43,138.84 325.12,138.84 v325.53,138.43 | v326.34,171.35 327.96,171.35 B11.M1
IO_ENABLE  (via drill 0.61)
  Top 0.203: v285.7,284.33 v285.7,254.66 | v371.04,284.33 371.04,246.94 370.64,246.53 370.64,245.72 371.04,245.31 371.04,228.24 v371.04,227.84 371.04,176.22 370.23,175.41 AB07.BL2 370.23,174.19 370.23,172.57 371.04,171.75 371.04,148.18 370.64,147.78 370.64,139.65 371.45,138.84 v371.45,107.14 | v43.08,283.92 24.38,265.23 24.38,264.01 21.13,264.01 A35.D1 | v340.56,44.55 340.16,44.96 340.16,49.43 340.97,50.24 340.97,52.27 340.16,53.09 340.16,75.84 v341.38,77.06
  Route2 0.203: v341.38,77.06 341.78,77.06 356.41,91.69 356.41,92.1 v371.45,107.14
  Route15 0.203: v309.27,82.75 312.93,79.1 313.74,79.1 314.15,78.69 314.96,78.69 323.49,70.16 323.49,68.12 325.53,66.09 325.93,66.09 344.22,47.8 344.22,44.96 D09.J2
  Bottom 0.203: v309.27,82.75 309.27,85.19 C12.U2 | 419.4,175.82 409.25,175.82 408.43,175.01 AB04.BL2 407.21,175.01 406.81,175.41 402.74,175.41 402.34,175.82 393.8,175.82 | 419.4,175.82 420.22,175.01 AB03.BL2 | 419.4,175.82 432,175.82 432.82,175.01 AB02.BL2 | B13.M1 303.99,171.75 305.21,172.97 308.05,172.97 308.46,173.38 368.61,173.38 369.42,174.19 AB07.BL2 370.64,175.01 371.45,175.82 381.2,175.82 | v371.04,227.84 367.79,227.84 367.39,228.24 A08.S1 | v285.7,254.66 287.73,252.63 291.39,252.63 293.01,251 A13.J2 | v371.04,284.33 370.64,284.73 286.11,284.73 v285.7,284.33 285.7,284.73 210.51,284.73 209.3,283.52 158.09,283.52 157.68,283.92 v43.08,283.92 | 381.2,175.82 382.02,175.01 AB06.BL2 | 393.8,175.82 394.61,175.01 AB05.BL2 | 381.2,175.82 393.8,175.82 | v340.56,44.55 343.81,44.55 D09.J2
IO_END\
  Top 0.203: C05.K1 405.18,111.61 405.99,112.42 405.99,122.58 405.18,123.39 C05.E1
  Route15 0.203: D02.P2 436.88,27.89 436.88,26.26 442.16,20.98 444.19,20.98 449.48,26.26 444.6,31.14 444.6,62.84 441.76,65.68 441.76,68.53 440.94,69.34 440.94,70.56 436.47,75.03 436.47,76.25 414.12,98.6 413.71,98.6 413.31,99.01 413.31,100.63 406.81,107.14 406.81,108.76 405.18,110.39 C05.K1
IO_ON  (via drill 0.61)
  Top 0.203: 406.81,42.93 406.81,33.17 407.62,32.36 D04.N2 | 406.81,42.93 407.62,43.74 D04.J2 | 406.81,42.93 406.81,55.12 408.03,56.34 D04.D2 408.03,57.96 406.4,59.59 406.4,107.54 v404.77,109.17
  Bottom 0.203: v404.77,109.17 390.96,109.17 389.74,107.95 C06.L1
IO_PC_ENABLE\  (via drill 0.61)
  Top 0.203: v110.54,144.53 110.95,144.12 110.95,128.27 110.13,127.46 C28.D1 | v261.72,146.56 264.97,149.81 264.97,207.92 266.19,209.14 266.19,213.21 v262.94,216.46
  Bottom 0.203: v110.54,144.53 110.95,144.93 182.88,144.93 184.1,143.71 251.97,143.71 254.81,146.56 v261.72,146.56 | v262.94,216.46 268.22,221.74 283.67,221.74 A14.U2 284.89,222.15 286.11,220.93 358.44,220.93 359.66,222.15 A08.U2
IO_RECYCLE\  (via drill 0.61)
  Top 0.203: v400.3,98.6 399.9,99.01 399.9,105.51 398.27,107.14 398.27,110.39 C05.K2
  Bottom 0.203: v400.3,98.6 404.37,98.6 C05.P1
IO_ROT\  (via drill 0.61)
  Top 0.203: v381.61,42.93 381.2,43.33 381.2,105.92 | 381.2,105.92 382.42,107.14 C06.L2 | 381.2,105.92 381.2,121.36 381.61,121.77 381.61,125.42 382.42,126.24 C06.D2 | v388.52,128.68 388.52,132.74 C06.B1
  Bottom 0.203: v381.61,42.93 369.42,42.93 368.61,43.74 364.54,43.74 364.13,44.15 D08.J1 | v388.52,128.68 387.3,127.46 383.24,127.46 C06.D2
IO_SKIP  (via drill 0.61)
  Top 0.203: v44.3,257.5 44.3,246.13 45.52,244.91 A33.L1
  Route15 0.203: v44.3,257.5 63.8,277.01 68.68,272.14 105.26,272.14 105.66,271.73 237.34,271.73 256.03,253.03 278.38,253.03 278.79,252.63 281.23,252.63 281.63,252.22 290.17,252.22 293.01,249.38 295.05,249.38 296.27,248.16 A13.K2
IO_START\  (via drill 0.61)
  Top 0.203: v396.65,113.23 396.65,119.33 395.83,120.14 C05.F2 | v403.15,112.83 403.15,96.98 401.93,95.76 C05.R1
  Bottom 0.203: v396.65,113.23 397.05,112.83 v403.15,112.83 415.75,112.83 416.97,111.61 C04.K1
IO_STROBE  (via drill 0.61)
  Top 0.203: v263.75,138.02 264.16,137.62 v264.16,86.82 | v397.87,121.77 397.87,118.52 398.27,118.11 C05.H2 | v373.48,121.77 373.89,121.36 373.89,118.52 374.7,117.7 v374.7,51.87
  Route2 0.203: v263.75,138.02 269.44,143.71 271.07,143.71 299.52,172.16 299.52,174.19 B13.L1
  Route15 0.203: v348.69,51.87 349.5,51.05 349.5,50.24 353.16,46.58 352.35,45.77 351.54,45.77 344.63,52.68 340.56,52.68 326.75,66.5 326.75,67.72 317.81,76.66 317.81,78.28 314.96,81.13 312.12,81.13 306.83,86.41 306.83,88.44 C12.T2
  Bottom 0.203: C06.H1 392.58,117.3 397.87,117.3 C05.H2 399.08,117.3 404.37,117.3 C05.H1 | v348.69,51.87 349.1,52.27 361.7,52.27 | 361.7,52.27 362.92,51.05 D08.F1 | v264.16,86.82 264.57,87.22 276.35,87.22 276.76,87.63 304.39,87.63 305.61,88.85 C12.T2 | v397.87,121.77 390.14,129.49 386.89,129.49 385.67,128.27 380.8,128.27 374.29,121.77 v373.48,121.77 | v374.7,51.87 374.29,52.27 361.7,52.27
IOP1  (via drill 0.61)
  Top 0.203: v70.31,16.51 67.06,19.76 67.06,46.18 67.87,46.99 D31.H2
  Route2 0.203: v382.02,2.29 429.97,50.24 432.82,50.24 D02.F2 | v80.06,6.76 v70.31,16.51
  Route15 0.203: D32.D2 52.83,56.74 56.9,56.74 57.71,55.93 62.18,55.93 66.24,51.87 66.24,49.84 67.87,48.21 D31.H2
  Bottom 0.203: v382.02,2.29 348.69,2.29 347.47,3.5 334.06,3.5 332.84,2.29 298.3,2.29 297.49,3.1 239.78,3.1 238.56,4.32 112.17,4.32 111.35,3.5 102.82,3.5 99.57,6.76 v80.06,6.76
IOP1\  (via drill 0.61)
  Top 0.203: C29.J2 91.03,114.86 93.07,116.89 93.07,117.3 C29.H2 | v381.2,240.84 381.2,122.17 380.8,121.77 380.8,57.96 v380.39,57.56
  Route2 0.203: v381.2,240.84 379.98,239.62 375.51,239.62 371.04,235.15 367.39,235.15 A08.P1 | v314.96,6.35 317.4,6.35 320.65,9.6 325.12,9.6 339.75,24.23 345.85,24.23 374.29,52.68 375.11,52.68 379.98,57.56 v380.39,57.56
  Route15 0.203: v150.37,114.45 182.88,81.94 182.88,80.72 193.04,70.56 193.85,70.56 194.26,70.16 195.88,70.16 v259.28,6.76
  Bottom 0.203: v380.39,57.56 380.39,55.12 418.59,55.12 421.84,51.87 421.84,49.02 414.12,49.02 | 414.12,49.02 412.5,49.02 411.68,48.21 D04.H2 | 414.12,49.02 416.97,46.18 425.5,46.18 433.22,53.9 436.07,53.9 D02.E2 | v150.37,114.45 149.15,115.67 107.29,115.67 106.88,116.08 95.5,116.08 94.28,117.3 C29.H2 | v259.28,6.76 259.69,6.35 v314.96,6.35
IOP2  (via drill 0.61)
  Top 0.203: v2.44,122.17 2.85,122.58 2.85,239.62 4.06,240.84 A36.M2
  Route2 0.203: D32.J2 52.83,44.96 54.86,44.96 63.4,53.49 63.4,54.71 65.02,56.34 D31.D2
  Route15 0.203: v2.44,122.17 2.44,121.77 63.4,60.81 63.4,60 65.43,57.96 D31.D2
  Bottom 0.203: D02.J2 432.82,44.96 432,45.77 393.8,45.77 393.39,45.36 390.14,45.36 389.74,45.77 373.07,45.77 372.67,45.36 371.04,45.36 370.64,45.77 347.47,45.77 347.07,45.36 345.44,45.36 345.03,45.77 320.65,45.77 320.24,46.18 317.81,46.18 317.4,45.77 53.65,45.77 52.83,44.96 D32.J2
IOP2\  (via drill 0.61)
  Top 0.203: C29.P2 93.07,98.6 91.03,100.63 91.03,101.04 C29.N2 | v380.39,233.53 380.8,233.12 380.8,122.99 379.98,122.17 v379.58,122.17 | v426.31,74.62 428.75,72.19 428.75,53.49 432,50.24 | 432,50.24 v433.22,49.02 | v432.41,36.83 432,37.24 432,50.24
  Route2 0.203: v387.3,13.26 407.21,33.17 408.84,33.17 410.46,34.8 D04.M2
  Route15 0.203: v379.58,122.17 379.58,121.77 414.12,87.22 414.12,86.82 v426.31,74.62 | v175.97,13.26 113.79,75.44 113.79,76.66 112.17,78.28 111.76,78.28 93.88,96.16 93.88,97.79 C29.P2
  Bottom 0.203: v380.39,233.53 366.17,233.53 363.73,235.97 361.29,235.97 361.29,237.19 361.7,237.59 362.92,237.59 A08.N1 | v433.22,49.02 434.04,48.21 436.07,48.21 D02.H2 | v432.41,36.83 413.31,36.83 411.68,35.2 D04.M2 | v175.97,13.26 179.22,10.01 332.03,10.01 333.25,11.23 385.27,11.23 v387.3,13.26
IOP4  (via drill 0.61)
  Top 0.203: v81.28,19.76 76,25.04 76,76.25 73.15,79.1 73.15,90.07 74.37,91.29 C31.S1
  Route2 0.203: v99.16,5.94 83.31,21.79 v81.28,19.76
  Route15 0.203: C32.L2 52.83,107.54 56.9,107.54 70.71,93.73 72.75,93.73 73.97,92.51 C31.S1 | v401.52,2.29 401.52,9.6 429.56,37.64 432.82,37.64 D02.L2
  Bottom 0.203: v401.52,2.29 400.3,1.07 104.04,1.07 v99.16,5.94
IOP4\  (via drill 0.61)
  Top 0.203: C29.V2 91.03,83.16 93.07,85.19 C29.U2 94.28,85.19 95.5,83.97 95.5,79.1 98.35,76.25 v98.35,70.97 | v370.23,204.27 370.23,212.39 368.61,214.02 368.61,239.62 367.39,240.84 A08.M1 | v420.62,205.89 422.66,203.86 422.66,119.33 422.25,118.92 422.25,94.13 422.66,93.73 422.66,58.37 v424.28,56.74 | v414.93,40.89 412.9,38.86 412.9,24.64 411.28,23.01 D04.S2 | v320.24,20.98 328.78,12.45 328.78,10.82 336.09,3.5 346.66,3.5 346.66,1.88 347.07,1.47 356.82,1.47 356.82,9.2 v366.57,18.95
  Route15 0.203: v424.28,56.74 424.28,55.52 434.85,44.96 434.85,42.93 436.07,41.71 D02.K2 | v136.55,32.77 v98.35,70.97
  Bottom 0.203: v370.23,204.27 370.64,204.67 373.48,204.67 373.89,204.27 374.7,204.27 375.92,205.49 375.92,206.3 420.22,206.3 v420.62,205.89 | v414.93,40.89 416.56,42.52 435.25,42.52 436.07,41.71 D02.K2 | v136.55,32.77 148.34,20.98 v320.24,20.98 | v366.57,18.95 371.04,23.42 406.81,23.42 407.62,22.61 410.46,22.61 D04.S2
IOP_A  (via drill 0.61)
  Top 0.203: v396.24,111.61 396.65,111.2 396.65,101.04 396.24,100.63 396.24,96.16 396.65,95.76 396.65,84.38 v396.24,83.97
  Route15 0.203: v396.24,111.61 397.46,112.83 397.46,114.05 396.24,115.27 396.24,116.89 392.58,120.55 392.58,123.39 C06.E1 | v396.24,83.97 396.24,83.57 402.34,77.47 402.34,76.66 402.74,76.25 402.74,64.47 409.25,57.96 409.25,56.34 410.87,54.71 D04.E2
IOP_A\  (via drill 0.61)
  Top 0.203: v390.14,105.1 390.14,116.48 389.33,117.3 389.33,120.14 C06.F1
  Bottom 0.203: v390.14,105.1 386.49,105.1 C06.M2
IOP_B
  Route15 0.203: D04.K2 410.46,41.71 410.46,46.18 409.65,46.99 409.65,53.49 397.05,66.09 397.05,69.75 394.21,72.59 394.21,81.53 384.45,91.29 384.45,92.91 382.83,94.54 C06.R2
IOP_B\
  Top 0.203: C06.P2 385.27,99.01 384.45,99.82 384.45,122.58 385.27,123.39 C06.E2
IOP_C  (via drill 0.61)
  Top 0.203: v390.96,115.27 390.96,128.68 391.77,129.49 C06.C1 | v407.62,29.52 405.99,31.14 405.99,71.78 404.37,73.41 v404.37,82.75
  Route15 0.203: v407.62,29.52 408.43,28.7 410.46,28.7 D04.P2 | v404.37,82.75 376.73,110.39 376.73,111.2 381.2,115.67 382.02,114.86 C06.J2
  Bottom 0.203: 390.96,115.67 400.3,115.67 401.12,114.86 C05.J1 | 390.96,115.67 384.45,115.67 383.24,114.45 C06.J2 | 390.96,115.67 v390.96,115.27
IOP_C\  (via drill 0.61)
  Top 0.203: v395.43,116.48 395.43,114.86 C05.J2
  Bottom 0.203: v395.43,116.48 395.02,116.08 387.71,116.08 386.49,117.3 C06.H2
IOT  (via drill 0.61)
  Top 0.203: v378.76,107.14 377.55,105.92 377.55,88.44 377.14,88.04 377.14,83.57 378.36,83.57 378.76,83.97 378.76,84.78 379.17,85.19 C07.U1
  Route2 0.203: v378.76,107.14 382.83,111.2 382.83,111.61 389.74,118.52 390.96,118.52 394.61,122.17 396.65,122.17 397.87,123.39 C05.E2
  Route15 0.203: v326.34,128.68 323.9,131.12 323.9,135.59 323.49,135.99 323.49,137.21 322.68,138.02 322.27,138.02 313.33,146.96 311.3,146.96 297.89,160.38 297.89,161.59 290.98,168.5 290.98,170.94 B14.M1 | v356.82,125.02 356.82,123.8 372.67,107.95 v373.07,107.95
  Bottom 0.203: v326.34,128.68 327.56,127.46 330.4,127.46 331.22,128.27 345.85,128.27 348.69,125.42 356.41,125.42 v356.82,125.02 | v373.07,107.95 374.29,106.73 378.76,106.73 v378.76,107.14
IOT\  (via drill 0.61)
  Top 0.203: v379.98,109.58 375.11,104.7 375.11,83.97 375.92,83.16 C07.V1
  Route2 0.203: v379.98,109.58 401.12,130.71 401.12,132.74 C05.B1
  Route15 0.203: v333.25,83.57 328.78,88.04 328.78,91.29 C11.S1
  Bottom 0.203: v333.25,83.57 333.65,83.97 374.29,83.97 375.51,82.75 C07.V1
IR0  (via drill 0.61)
  Top 0.203: 352.75,106.73 352.75,109.17 353.97,110.39 C09.K1 353.57,111.61 352.75,112.42 v352.75,119.33 | 352.75,106.73 352.75,99.82 353.57,99.01 C09.P1 | v342.19,120.55 342.6,120.95 342.6,127.05 340.16,129.49 340.16,135.18 340.97,135.99 C10.A1 | v305.21,69.34 305.21,59.18 306.43,57.96 D12.D2 | v329.59,69.34 329.59,84.78 330,85.19 330,103.48 329.18,104.29 C11.M1 | v353.16,106.73 352.75,106.73
  Bottom 0.203: 342.19,120.14 343,120.14 343.81,119.33 v352.75,119.33 358.44,119.33 359.26,120.14 362.92,120.14 C08.F1 | 342.19,120.14 339.34,120.14 338.94,120.55 C10.F1 | 342.19,120.14 v342.19,120.55 | v305.21,69.34 v329.59,69.34 | v353.16,106.73 352.75,106.32 330.4,106.32 329.18,105.1 C11.M1
IR0\  (via drill 0.61)
  Top 0.203: C09.A1 353.57,135.99 352.75,135.18 352.75,128.27 353.97,127.05 353.97,124.61 C09.E1 | v345.85,96.16 345.85,109.58 344.63,110.79 344.63,113.64 C09.J2 345.03,114.86 345.03,117.3 345.85,118.11 345.85,125.02 344.63,126.24 C09.D2
  Bottom 0.203: C09.D2 345.03,126.64 346.66,125.02 352.75,125.02 353.57,124.21 C09.E1 354.79,124.21 357.23,124.21 358.04,125.02 365.35,125.02 366.17,124.21 C08.E1 | C15.R1 275.13,95.76 275.95,96.57 345.44,96.57 v345.85,96.16 345.85,96.57 364.13,96.57 364.54,96.16 365.76,96.16 366.17,96.57 423.06,96.57 425.91,93.73 444.19,93.73 445.41,94.94 C01.R2
IR1  (via drill 0.61)
  Top 0.203: v346.25,116.48 347.07,115.67 347.07,111.61 C09.K2 | v338.53,116.89 338.53,118.11 336.91,119.74 336.91,131.93 337.72,132.74 C10.B1 | v350.72,116.48 350.72,120.14 C09.F1 | v320.65,53.49 321.46,52.68 323.49,52.68 323.49,96.16 325.12,97.79 325.12,101.04 C11.N1
  Route2 0.203: C10.H1 340.97,116.89 340.97,115.27 329.18,103.48 327.15,103.48 325.93,102.26 C11.N1
  Bottom 0.203: 350.72,116.08 358.44,116.08 359.66,117.3 C08.H2 | 346.25,116.08 350.72,116.08 | 346.25,116.08 342.6,116.08 341.78,116.89 C10.H1 340.56,117.3 338.94,117.3 v338.53,116.89 | 346.25,116.08 v346.25,116.48 | 350.72,116.08 v350.72,116.48 | v320.65,53.49 319.84,53.49 319.02,52.68 315.37,52.68 312.93,55.12 310.9,55.12 310.08,54.3 D12.E2
IR1\  (via drill 0.61)
  Top 0.203: C09.B1 350.32,132.74 349.5,131.93 349.5,126.24 347.88,124.61 C09.E2 348.29,123.39 349.5,122.17 349.5,105.92 | 349.5,105.92 349.5,96.57 350.32,95.76 C09.R1 351.13,94.54 352.75,92.91 352.75,79.5 v353.16,79.1 | 349.5,105.92 350.72,107.14 C09.L1 | v357.23,112.01 357.23,113.64 C08.J2
  Route2 0.203: v357.23,112.01 356.82,112.01 354.79,109.98 353.16,109.98 351.54,108.36 C09.L1
  Bottom 0.203: v353.16,79.1 353.57,79.5 414.93,79.5 415.75,78.69 441.76,78.69 445.41,82.35 C01.V2
IR2  (via drill 0.61)
  Top 0.203: v338.12,109.58 338.12,113.64 C10.J1 | 355.19,109.17 355.19,127.05 353.97,128.27 353.97,129.49 C09.C1 | 355.19,109.17 355.19,97.38 353.97,96.16 353.97,92.51 C09.S1 | 355.19,109.17 v354.79,109.17
  Bottom 0.203: v338.12,109.58 339.34,108.36 343.81,108.36 C09.L2 345.03,108.36 345.85,109.17 v354.79,109.17 357.63,109.17 358.04,108.76 362.51,108.76 362.92,108.36 C08.L1 | C10.C1 341.78,129.49 342.19,129.08 346.66,129.08 347.07,128.68 352.75,128.68 353.57,129.49 C09.C1
IR2\  (via drill 0.61)
  Top 0.203: v351.94,104.7 352.35,105.1 352.35,118.52 351.94,118.92 351.94,119.74 352.35,120.14 353.57,120.14 353.57,118.11 C09.H1
  Route2 0.203: v351.94,104.7 353.57,104.7 C09.M1
  Route15 0.203: C08.M1 366.57,105.51 366.57,107.14 364.54,109.17 363.73,109.17 361.7,111.2 361.7,111.61 357.63,115.67 356.41,115.67 354.79,117.3 C09.H1 | v345.03,118.52 345.03,120.14 C09.F2
  Bottom 0.203: C11.P1 329.18,99.01 329.59,99.42 333.25,99.42 337.31,103.48 352.75,103.48 353.57,104.29 C09.M1 | D01.D2 446.63,57.56 448.26,59.18 450.29,59.18 451.1,60 451.1,70.56 451.51,70.56 453.54,72.59 453.54,81.94 453.95,81.94 453.95,96.98 382.83,96.98 376.33,103.48 369.01,103.48 368.2,104.29 367.39,104.29 C08.M1 | v345.03,118.52 345.44,118.92 351.94,118.92 352.75,118.11 353.57,118.11 C09.H1
ISZ  (via drill 0.61)
  Top 0.203: v372.26,149 372.26,145.75 374.29,143.71 374.29,119.74 375.11,118.92 375.11,109.98 377.95,109.98 378.76,110.79 C07.K1 | v288.14,212.8 288.54,213.21 288.54,240.84 v287.73,241.66
  Route2 0.203: v287.73,241.66 288.14,241.66 299.11,252.63 299.92,252.63 302.77,255.47 303.99,255.47 305.61,257.1 A12.F2
  Route15 0.203: v372.26,149 370.64,150.62 366.57,150.62 358.85,158.34 358.85,162.41 v344.22,177.04 | v331.62,176.63 327.15,176.63 325.53,178.26 323.49,178.26 320.24,181.51 320.24,181.91 316.59,185.57 314.96,185.57 314.55,185.98 314.55,187.6 310.49,191.67 308.86,191.67 308.46,192.07 308.46,193.7 297.49,204.67 296.27,204.67 v288.14,212.8
  Bottom 0.203: A13.H2 297.49,254.25 299.11,255.88 304.39,255.88 305.61,257.1 A12.F2 | v344.22,177.04 342.19,179.07 334.06,179.07 v331.62,176.63
ISZ\
  Bottom 0.203: C09.J1 351.54,114.05 352.75,112.83 374.29,112.83 375.51,114.05 C07.J1
JMP  (via drill 0.61)
  Top 0.203: v299.52,142.9 299.52,133.96 C13.B1 | v277.98,142.9 277.98,232.72 v277.17,233.53
  Route2 0.203: A10.D1 337.72,262.79 335.28,262.79 316.59,244.09 316.59,243.69 316.18,243.28 314.96,243.28 310.08,238.4 308.46,238.4 306.83,236.78 305.61,236.78 303.99,235.15 A13.P1
  Route15 0.203: v379.58,94.13 379.58,92.51 C07.S1 | v373.48,94.54 361.7,106.32 361.7,107.14 357.63,111.2 356.82,111.2 351.54,116.48 351.54,116.89 351.13,117.3 349.91,117.3 v335.28,131.93
  Bottom 0.203: v299.52,142.9 299.11,142.49 278.38,142.49 v277.98,142.9 | v277.17,233.53 301.95,233.53 302.77,234.34 A13.P1 | v379.58,94.13 379.17,93.73 374.29,93.73 v373.48,94.54 | v335.28,131.93 330.4,131.93 328.78,133.55 327.56,133.55 325.93,131.93 317.4,131.93 316.99,132.33 313.74,132.33 313.33,131.93 305.61,131.93 303.99,133.55 300.74,133.55 C13.B1
JMP\  (via drill 0.61)
  Top 0.203: v354.79,93.73 355.19,93.32 355.19,91.29 354.79,90.88 354.79,86.82 354.38,86.41 C09.U1 | v320.65,54.71 321.06,55.12 v321.06,94.13 321.06,94.54 324.31,97.79 324.31,112.83 | 324.31,112.83 325.12,113.64 C11.J1 | v336.91,195.33 336.91,220.93 339.34,223.37 339.34,228.65 340.56,229.87 340.56,233.93 340.97,234.34 A10.P1 | v328.37,194.92 327.15,193.7 327.15,125.83 324.31,122.99 324.31,112.83
  Bottom 0.203: C07.R1 375.51,95.35 373.07,95.35 371.45,93.73 v354.79,93.73 354.38,93.73 321.06,93.73 v321.06,94.13 320.65,93.73 270.26,93.73 269.04,94.94 C15.R2 | v320.65,54.71 316.99,54.71 316.59,54.3 D12.E1 | v336.91,195.33 336.5,194.92 v328.37,194.92
JMP_DIRECT\  (via drill 0.61)
  Top 0.203: 345.85,245.72 347.07,246.94 347.07,247.34 A09.K2 | 345.85,245.72 345.03,244.91 A09.L2 | v304.8,166.88 304.8,125.83 303.58,124.61 C13.E1 | 345.85,245.72 347.88,243.69 347.88,243.28 349.5,241.66 v349.5,218.08 | v313.74,171.35 312.93,170.54 312.93,168.91 B12.N1