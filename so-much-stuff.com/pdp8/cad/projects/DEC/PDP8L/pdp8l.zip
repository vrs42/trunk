# EAGLE board pdp8l (EAGLE 4.11), part 2 of 8
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
B_MEM_ENABLE  (via drill 0.61) (continued)
  Bottom 0.203: 216.21,226.62 206.04,226.62 205.23,225.81 A20.T2 | 216.21,226.62 217.02,225.81 A19.T2 | 228.8,226.62 229.62,225.81 A18.T2 | 216.21,226.62 228.8,226.62 | 228.8,226.62 241.4,226.62 242.21,225.81 A17.T2 | C18.D2 229.62,126.64 228.8,125.83 219.05,125.83 218.24,126.64 C19.D2 217.02,127.46 216.21,128.27 165.41,128.27 | 216.21,156.72 206.04,156.72 205.23,155.91 B20.T2 | 216.21,156.72 217.02,155.91 B19.T2 | 216.21,156.72 228.8,156.72 229.62,155.91 B18.T2 | 151.99,55.93 153.21,57.15 D24.D2 | 151.99,55.93 146.71,55.93 145.09,54.3 D25.E2 | 151.99,55.93 165.41,55.93 166.22,56.74 D23.D2 167.44,57.56 167.84,57.96 171.91,57.96 172.31,58.37 216.21,58.37 217.02,57.56 D19.D2 218.24,56.74 219.05,55.93 228.8,55.93 229.62,56.74 D18.D2 230.84,56.74 232.46,55.12 251.16,55.12 251.97,54.3 D17.E1 | v253.19,38.46 249.94,38.46 D17.L1 | A24.E2 157.68,259.94 158.5,259.13 167.84,259.13 169.06,260.35 A23.E2 | B24.E2 157.68,190.86 158.5,191.67 168.25,191.67 169.06,190.86 B23.E2 | 165.41,128.27 155.25,128.27 154.43,127.46 C24.D2 | 165.41,128.27 166.22,127.46 C23.D2 | B24.N2 154.43,167.69 155.25,166.88 164.19,166.88 165,167.69 166.22,167.69 B23.N2 | v153.21,122.58 145.9,122.58 145.09,123.39 C25.E2
B_SET  (via drill 0.61)
  Top 0.203: v314.15,57.96 314.55,57.56 314.55,24.23 315.77,23.01 D12.S1
  Route15 0.203: v107.7,258.72 122.73,258.72 231.65,149.81 231.65,148.18 241,138.84 241,137.21 295.05,83.16 295.05,82.35 299.11,78.28 299.52,78.28 301.14,76.66 301.14,70.97 v314.15,57.96
  Bottom 0.203: v107.7,258.72 36.17,258.72 33.33,261.57 23.98,261.57 23.98,266.04 A35.C1 | D10.T2 331.22,19.36 330,20.57 321.87,20.57 320.65,21.79 316.59,21.79 D12.S1
B_WC  (via drill 0.61)
  Top 0.203: v433.63,53.09 433.63,52.68 434.85,51.46 434.85,20.98 433.63,19.76 D02.T2
  Route15 0.203: v433.63,53.09 436.88,56.34 435.25,57.96 435.25,58.78 426.72,67.31 426.72,71.78 415.75,82.75 415.75,83.16 402.34,96.57 398.27,96.57 393.8,101.04 393.8,106.73 377.55,122.99 375.92,122.99 360.88,138.02 359.66,138.02 351.13,146.56 349.91,146.56 348.69,147.78 348.69,148.59 344.63,152.65 344.63,153.47 336.91,161.19 336.91,162.81 335.28,164.44 B10.P2
BEMA  (via drill 0.61)
  Route15 0.203: v319.43,105.51 331.62,93.32 331.62,89.66 C10.T2 | v81.69,151.03 81.69,150.62 117.04,115.27 117.04,111.2 128.02,100.23 130.05,100.23 131.27,99.01 C26.P2
  Bottom 0.203: v319.43,105.51 315.77,109.17 286.51,109.17 285.7,108.36 282.45,108.36 281.63,109.17 273.91,109.17 271.88,107.14 271.07,107.14 269.04,109.17 258.06,109.17 254.81,105.92 236.53,105.92 227.58,96.98 133.71,96.98 132.49,98.2 C26.P2 | v81.69,151.03 42.27,151.03 39.42,153.87 16.66,153.87 15.04,155.5 B35.T2
BREAK
  Top 0.203: D10.V2 331.22,13.26 330,14.48 330,18.95 323.9,25.04 323.9,37.64 320.65,40.89 320.65,45.77 321.87,46.99 D11.H2
BREAK\  (via drill 0.61)
  Top 0.203: 338.94,13.66 339.34,14.07 v339.34,81.13 | 338.94,13.66 338.53,13.26 D10.V1 | v372.67,81.13 372.67,85.19 C07.U2 | v431.6,2.69 444.6,15.7 444.6,36.83 445.41,37.64 D01.L2 | 338.94,13.66 v349.5,3.1
  Route15 0.203: v136.14,113.23 138.58,113.23 245.87,5.94 247.09,5.94 v249.12,3.91
  Bottom 0.203: C27.L2 116.23,108.76 116.23,111.61 117.45,111.61 118.67,112.83 126.8,112.83 128.02,114.05 C26.J2 129.24,114.05 130.45,112.83 135.74,112.83 v136.14,113.23 | v339.34,81.13 339.75,80.72 372.26,80.72 v372.67,81.13 | v431.6,2.69 431.19,3.1 v349.5,3.1 349.1,3.1 348.29,3.91 v249.12,3.91
BREAK_OK
  Top 0.203: 305.21,36.83 305.21,26.67 306.02,25.86 D12.R2 | 305.21,36.83 306.02,37.64 D12.L2 | 305.21,36.83 305.21,42.11 304.39,42.93 304.39,52.68 303.58,53.49 D13.E1
  Bottom 0.203: D11.M1 327.96,35.2 326.34,36.83 312.12,36.83 311.3,37.64 306.83,37.64 D12.L2
BREAK_OK\  (via drill 0.61)
  Top 0.203: v320.65,133.55 320.65,116.08 319.43,114.86 C11.J2 | v340.97,55.52 340.97,59.59 D10.C1 | v311.71,112.42 311.3,112.01 311.3,79.5 308.46,76.66 308.46,69.75 310.9,67.31 v310.9,57.96
  Bottom 0.203: v320.65,133.55 324.71,133.55 C11.B1 | 310.9,55.52 v340.97,55.52 | 310.9,55.52 301.95,55.52 300.74,56.74 D13.D1 | v311.71,112.42 317.4,112.42 318.62,113.64 C11.J2 | 310.9,55.52 v310.9,57.96
BRK_RQST\  (via drill 0.61)
  Route2 0.203: v287.32,129.08 304.8,146.56 307.24,146.56 315.77,155.09 318.62,155.09 B11.T2 | v206.86,125.83 206.45,125.83 195.48,114.86 194.67,114.86 160.93,81.13 157.28,81.13 146.71,70.56 145.9,70.56 145.49,70.16 144.68,70.16 104.44,29.92 103.23,29.92 94.28,20.98 92.66,20.98 91.03,19.36 D29.T2
  Route15 0.203: D29.T2 89.81,19.36 86.97,19.36 49.99,56.34 49.99,57.56 22.35,85.19 22.35,91.29 6.5,107.14 6.5,108.76 4.88,110.39 C36.K2
  Bottom 0.203: v287.32,129.08 286.92,128.68 280.82,128.68 277.57,125.42 214.99,125.42 214.17,126.24 212.55,126.24 212.14,125.83 v206.86,125.83
BTP2  (via drill 0.61)
  Top 0.203: v407.21,9.6 403.15,13.66 403.15,42.52 401.93,43.74 D05.J1
  Route15 0.203: v110.13,67.31 28.45,149 28.45,149.81 27.64,150.62 27.64,155.09 B34.T2 | v214.17,63.65 223.11,54.71 224.33,54.71 254.81,24.23 260.1,24.23 270.26,14.07 303.17,14.07 306.02,11.23 312.52,11.23 v316.59,7.16
  Bottom 0.203: v110.13,67.31 110.95,68.12 138.99,68.12 141.83,65.28 212.55,65.28 v214.17,63.65 | v316.59,7.16 317.4,6.35 403.96,6.35 v407.21,9.6
BTP3  (via drill 0.61)
  Route2 0.203: v299.11,5.54 315.37,5.54 315.77,5.94 317.81,5.94 321.06,9.2 325.53,9.2 337.31,20.98 341.78,20.98 344.63,23.83 346.25,23.83 362.51,40.08 367.39,40.08 371.45,44.15 375.51,44.15 D07.J1
  Route15 0.203: v299.11,5.54 265.79,5.54 205.64,65.68 205.64,70.97 192.63,83.97 188.57,83.97 136.96,135.59 136.96,136.4 122.73,150.62 118.26,150.62 v92.25,176.63
  Bottom 0.203: v92.25,176.63 26.82,176.63 21.13,182.32 13.41,182.32 11.79,183.95 B36.H1
C01V1  (via drill 0.61)
  Top 0.203: v104.04,207.52 102.01,209.55 102.01,230.28 102.82,231.09 A28.R2
  Route2 0.203: v413.71,70.16 412.09,70.16 v364.54,22.61
  Route15 0.203: v293.83,23.42 293.42,23.42 293.01,23.83 291.8,23.83 282.04,33.58 281.23,33.58 246.69,68.12 243.43,68.12 230.43,81.13 228.4,81.13 191.41,118.11 191.41,119.33 169.06,141.68 169.06,142.49 v104.04,207.52
  Bottom 0.203: v413.71,70.16 416.15,70.16 424.28,78.28 442.98,78.28 445.01,80.31 450.29,80.31 451.92,81.94 C01.V1 | v364.54,22.61 362.92,20.98 325.53,20.98 323.09,23.42 319.02,23.42 318.62,23.01 316.99,23.01 316.59,23.42 v293.83,23.42
CA_INCREMENT  (via drill 0.61)
  Top 0.203: v45.11,100.23 44.7,100.63 44.7,147.78 44.3,148.18 44.3,170.13 43.48,170.94 B33.M2
  Route2 0.203: v169.47,251.41 145.49,227.43 141.43,227.43 v89.41,175.41
  Route15 0.203: v277.57,250.19 278.79,248.97 284.89,248.97 286.51,247.34 288.14,247.34 289.76,245.72 300.74,245.72 301.95,244.5 305.61,244.5 A12.L2
  Bottom 0.203: v45.11,100.23 42.27,103.07 19.1,103.07 17.88,104.29 C35.M2 | v277.57,250.19 275.95,251.82 250.34,251.82 249.94,252.22 170.69,252.22 169.88,251.41 v169.47,251.41 | v89.41,175.41 86.97,172.97 44.7,172.97 43.48,171.75 B33.M2
CARRY_INSERT  (via drill 0.61)
  Top 0.203: v293.83,172.57 293.83,168.91 B13.N2
  Route2 0.203: v302.77,181.51 v293.83,172.57
  Bottom 0.203: v302.77,181.51 303.58,182.32 321.46,182.32 322.27,181.51 323.09,181.51 324.31,182.73 333.25,182.73 336.5,179.48 351.54,179.48 357.63,185.57 369.42,185.57 372.26,182.73 438.1,182.73 439.32,181.51 AB02.BJ1
CARRYOUT0  (via drill 0.61)
  Top 0.203: v305.61,248.16 305.21,247.75 305.21,208.33 307.64,205.89 307.64,194.92 306.83,194.11 B12.D2 306.43,192.89 v306.43,189.23 | v333.25,54.71 333.65,55.12 333.65,82.75 334.06,83.16 334.06,84.78 333.65,85.19 333.65,116.08 333.25,116.48 333.25,124.21 v332.84,124.61 | v340.97,132.74 342.6,134.37 342.6,148.59 341.38,149.81 341.38,151.84 B10.U1
  Route2 0.203: v340.97,132.74 v332.84,124.61
  Route15 0.203: v305.61,248.16 297.08,256.69 294.23,256.69 A13.F2 | v306.43,189.23 323.49,172.16 323.49,171.35 324.31,170.54 325.12,170.54 333.65,162 333.65,161.59 335.28,159.97 335.69,159.97 339.34,156.31 339.34,154.69 340.97,153.06 B10.U1
  Bottom 0.203: v333.25,54.71 332.84,55.12 323.09,55.12 322.68,54.71 D11.E2
CARRYOUT0\  (via drill 0.61)
  Top 0.203: v316.18,193.29 316.18,196.14 B12.C1 | v318.21,191.26 317.81,190.86 317.81,172.97 318.62,172.16 v318.62,170.94
  Route2 0.203: v370.23,177.85 v345.44,153.06 | v316.18,193.29 316.18,192.89 314.55,191.26 314.55,189.64 315.77,188.42 318.21,190.86 v318.21,191.26
  Route15 0.203: v318.62,170.94 333.25,156.31 333.25,154.28 334.47,153.06 B10.U2
  Bottom 0.203: v345.44,153.06 343.81,153.06 343,153.87 336.91,153.87 335.69,152.65 B10.U2 | v370.23,177.85 372.26,177.85 AB07.BK2
CARRYOUT6\
  Bottom 0.203: AB05.BJ1 402.34,180.7 403.96,179.07 409.65,179.07 410.46,178.26 AB04.BK2
CLOCK_SCALE2
  Top 0.203: D32.T2 52.83,19.76 54.05,20.98 54.05,26.67 55.27,27.89 D32.P2
CONTROL_IOT  (via drill 0.61)
  Route2 0.203: v277.57,133.55 277.57,134.37 286.92,143.71 286.92,144.93 299.92,157.94 299.92,158.34 303.17,161.59 v303.58,161.59
  Route15 0.203: v277.57,133.55 282.85,128.27 282.85,122.99 291.8,114.05 291.8,113.23 296.67,108.36 296.67,105.51 C13.M2
  Bottom 0.203: v303.58,161.59 305.61,161.59 B12.R2
CURRENT_ADDR\  (via drill 0.61)
  Top 0.203: v440.94,36.42 440.94,16.1 437.29,16.1 D02.U2 | 314.15,34.8 314.15,36.83 313.33,37.64 D12.L1 | 314.15,34.8 314.15,26.67 313.33,25.86 D12.R1 | v132.89,83.57 132.89,116.08 132.08,116.89 C26.H2 | v306.43,42.52 314.15,34.8 | v340.16,23.42 340.16,17.32 340.97,16.51 D10.U1
  Route15 0.203: v230.43,79.91 v268.22,42.11
  Bottom 0.203: v440.94,36.42 445.41,40.89 448.67,40.89 D01.K2 | v132.89,83.57 132.89,80.31 163.78,80.31 164.19,80.72 170.28,80.72 171.5,79.5 230.02,79.5 v230.43,79.91 | v268.22,42.11 268.63,42.52 v306.43,42.52 | v340.16,23.42 339.75,23.83 318.62,23.83 318.21,23.42 317.4,23.42 315.77,25.04 313.33,25.04 D12.R1 | D02.U2 436.07,15.29 435.25,14.48 346.25,14.48 345.44,15.29 341.78,15.29 D10.U1
CYC_DONE  (via drill 0.61)
  Top 0.203: D16.L2 256.03,37.64 256.85,36.83 256.85,31.95 261.31,31.95 D16.N1 262.13,32.36 262.53,32.77 262.53,36.42 263.75,37.64 263.75,45.77 264.97,46.99 D16.H1 | 276.35,103.48 275.95,103.07 275.95,52.27 275.13,51.46 D15.F1 | 276.35,103.48 277.17,104.29 C15.M1 | v275.54,112.01 276.35,111.2 276.35,103.48
  Bottom 0.203: D16.H1 265.79,47.8 267.41,49.43 272.69,49.43 273.91,50.65 D15.F1 | v275.54,112.01 274.73,112.01 272.69,114.05 269.04,114.05 C15.J2
CYCLE  (via drill 0.61)
  Top 0.203: v257.66,122.99 257.66,109.58 257.25,109.17 257.25,49.43 258.47,48.21 D16.H2
  Bottom 0.203: v257.66,122.99 258.47,123.8 270.66,123.8 C15.E2
D01V1  (via drill 0.61)
  Route15 0.203: v352.35,3.91 345.44,10.82 334.87,10.82 334.47,11.23 331.22,11.23 327.96,14.48 308.86,14.48 291.39,31.95 290.58,31.95 250.34,72.19 250.34,76.66 244.25,82.75 244.25,83.57 180.03,147.78 178.82,147.78 146.71,179.88 145.49,179.88 113.79,211.58 113.79,213.21 110.95,216.05 110.95,219.71 106.48,224.18 106.48,227.84 A28.S2
  Bottom 0.203: v352.35,3.91 352.75,3.5 434.44,3.5 442.16,11.23 450.7,11.23 451.92,12.45 D01.V1
D_SET
  Top 0.203: C07.R2 369.42,95.76 366.98,95.76 366.98,97.79 C08.P1
D_SET\  (via drill 0.61)
  Top 0.203: v346.66,99.82 346.25,99.42 346.25,97.79 346.66,97.38 346.66,92.91 347.07,92.51 C09.S2 | 323.9,119.33 322.68,118.11 C11.H2 | 323.9,119.33 323.9,125.02 325.12,126.24 C11.D1 | v323.09,179.88 323.49,179.48 323.49,145.75 322.68,144.93 322.68,138.02 323.9,136.8 323.9,129.9 322.27,128.27 v321.87,128.27 | v323.49,106.73 323.9,107.14 323.9,119.33
  Route15 0.203: v323.09,179.88 303.58,199.39 303.58,202.64 B13.A1 | v323.49,106.73 v338.94,91.29
  Bottom 0.203: v346.66,99.82 369.01,99.82 370.23,98.6 372.26,98.6 C07.P2 | v321.87,128.27 318.62,128.27 317.81,127.46 317.81,125.83 323.9,125.83 324.71,126.64 C11.D1 | v338.94,91.29 339.34,90.88 342.19,90.88 342.6,91.29 346.66,91.29 347.07,91.69 C09.S2
DATA00  (via drill 0.61)
  Top 0.203: v91.03,255.88 102.01,266.85 v102.01,275.79 | v326.34,222.56 326.75,222.15 326.75,207.11 v328.78,205.08
  Route15 0.203: v266.19,274.57 284.89,274.57 308.46,251 309.68,251 311.71,248.97 312.52,248.97 325.53,235.97 325.53,233.53 330,229.06 330,224.99 334.87,220.12 334.87,219.3 334.06,218.49 333.25,219.3 333.25,219.71 332.44,220.52 328.37,220.52 v326.34,222.56 | v328.78,205.08 348.69,185.17 349.91,185.17 354.38,180.7 355.6,180.7 362.92,173.38 367.79,173.38 v369.42,171.75
  Bottom 0.203: v91.03,255.88 38.2,255.88 36.98,254.66 A34.H1 | v102.01,275.79 263.75,275.79 264.97,274.57 v266.19,274.57 | v369.42,171.75 372.26,171.75 AB07.BM2
DATA01  (via drill 0.61)
  Route2 0.203: v388.93,179.07 375.51,165.66 373.48,165.66 AB07.BP2 | v334.47,243.69 333.65,243.69 328.78,238.81 327.96,238.81 v324.71,235.56
  Route15 0.203: v388.93,179.07 364.54,203.45 364.54,203.86 362.92,205.49 361.7,205.49 358.85,208.33 358.85,212.39 360.07,213.61 360.07,218.08 351.54,226.62 351.13,226.62 349.1,228.65 349.1,229.06 348.29,229.87 347.47,229.87 346.66,230.68 346.66,231.5 v334.47,243.69 | v324.71,235.56 323.9,235.56 323.09,236.37 319.02,236.37 316.99,238.4 314.55,238.4 313.33,239.62 310.49,239.62 310.08,240.03 300.33,240.03 297.89,242.47 271.88,242.47 271.07,243.28 242.21,243.28 217.42,268.07 115.42,268.07 113.39,270.1 111.35,270.1 110.13,271.32 99.97,271.32 v76,247.34
  Bottom 0.203: v76,247.34 75.18,248.16 63.4,248.16 62.59,248.97 37.8,248.97 36.98,248.16 A34.K1
DATA02  (via drill 0.61)
  Top 0.203: v333.25,273.76 339.75,280.26 365.35,280.26 365.35,274.98 364.95,274.57 363.73,274.57 363.73,277.42 364.13,277.83 364.13,278.64 363.73,279.04 362.1,279.04 362.1,269.29 v364.13,267.26
  Route2 0.203: v73.15,279.86 36.58,243.28 36.58,242.06 A34.M1 | v364.13,267.26 365.35,267.26 366.17,268.07 370.23,268.07 374.29,272.14 376.33,272.14 378.76,274.57 399.49,274.57 403.96,279.04 406.81,279.04 411.68,274.17 416.97,274.17 417.37,274.57 443.38,274.57 455.57,262.38 447.85,254.66 447.85,243.69 425.91,221.74 425.91,214.83 407.62,196.54 407.62,195.33 387.71,175.41 387.71,173.79 386.08,172.16 AB06.BM2
  Route15 0.203: v312.52,282.3 314.96,284.73 319.02,284.73 329.59,274.17 330.4,274.17 331.62,272.95 332.44,272.95 v333.25,273.76
  Bottom 0.203: v73.15,279.86 76,282.7 151.59,282.7 152.4,281.89 167.44,281.89 168.25,281.08 182.88,281.08 184.1,282.3 238.15,282.3 238.56,282.7 278.38,282.7 279.2,281.89 282.85,281.89 283.26,282.3 291.39,282.3 291.8,281.89 312.12,281.89 v312.52,282.3
DATA03  (via drill 0.61)
  Top 0.203: v386.89,191.67 386.89,166.47 386.08,165.66 AB06.BP2
  Route2 0.203: v325.93,205.08 326.75,205.08 327.56,205.89 336.5,205.89 337.72,207.11 346.25,207.11 347.47,205.89 347.88,206.3 350.32,206.3 359.66,215.65 359.66,217.27 369.01,226.62 371.04,226.62 371.86,227.43 371.86,229.06 372.67,229.87 373.89,229.87 376.33,227.43 375.11,226.21 375.11,220.93 374.7,220.52 374.7,219.3 v370.23,214.83
  Route15 0.203: v41.45,231.5 41.45,231.9 39.01,234.34 36.98,234.34 A34.P1 | v273.51,226.21 273.51,224.59 280.42,217.68 284.07,217.68 287.32,214.43 288.95,214.43 290.17,213.21 290.98,213.21 297.08,219.3 309.27,207.11 310.08,207.11 315.37,201.83 316.99,201.83 319.02,203.86 v318.62,204.27 | v370.23,214.83 370.23,214.43 380.8,203.86 380.8,198.17 381.61,197.36 381.61,196.95 v386.89,191.67
  Bottom 0.203: v41.45,231.5 43.08,229.87 128.42,229.87 130.86,227.43 204.01,227.43 206.86,230.28 269.44,230.28 v273.51,226.21 | v318.62,204.27 319.43,205.08 v325.93,205.08
DATA04  (via drill 0.61)
  Top 0.203: v426.72,202.64 426.72,217.27 425.09,218.9 425.09,273.76 v416.97,281.89 | v324.71,273.76 322.68,271.73 318.62,271.73 v318.62,273.36 | v31.7,259.13 32.11,258.72 32.11,241.25 34.95,238.4 34.95,230.68 36.17,229.46 36.17,229.06 A34.S1
  Route2 0.203: v426.72,202.64 398.68,174.6 398.68,172.16 AB05.BM2 | v416.97,281.89 414.12,284.73 375.51,284.73 369.01,278.23 366.17,278.23 363.32,275.39 360.88,275.39 359.66,274.17 358.85,274.17 358.44,273.76 355.19,273.76 353.57,275.39 326.34,275.39 v324.71,273.76
  Route15 0.203: v318.62,273.36 317.81,273.36 316.59,274.57 313.33,274.57 310.9,277.01 290.58,277.01 285.29,282.3 281.23,282.3 280.01,283.52 228.4,283.52 221.08,276.2 220.27,277.01 133.3,277.01 132.08,278.23 89.41,278.23 89,278.64 51.21,278.64 v31.7,259.13
DATA05  (via drill 0.61)
  Top 0.203: v397.46,135.18 397.05,135.59 397.05,137.21 397.87,138.02 397.87,148.18 399.9,150.22 399.9,159.56 399.49,159.97 399.49,163.63 398.68,164.44 AB05.BP2 | v366.98,88.04 368.2,86.82 368.2,71.78 362.1,65.68 362.1,55.52 363.73,53.9 363.73,53.09 362.1,51.46 v362.1,22.61
  Route2 0.203: v397.46,135.18 402.34,135.18 407.62,129.9 393.39,115.67 393.39,114.45 390.96,112.01 390.96,107.95 376.73,93.73 372.67,93.73 v366.98,88.04
  Route15 0.203: v362.1,22.61 361.29,23.42 341.38,23.42 340.56,24.23 330,24.23 321.46,32.77 320.24,32.77 269.04,83.97 265.38,83.97 261.72,87.63 258.88,87.63 208.48,138.02 206.45,138.02 v128.42,216.05
  Bottom 0.203: v128.42,216.05 127.61,216.86 80.47,216.86 76.4,220.93 37.8,220.93 36.98,221.74 A34.U1
DATA06  (via drill 0.61)
  Route15 0.203: v289.36,31.95 251.16,70.16 245.06,70.16 244.65,70.56 243.84,70.56 242.21,72.19 242.21,72.59 167.03,147.78 166.22,147.78 133.71,180.29 132.49,180.29 52.83,259.94 42.27,249.38 39.01,249.38 31.7,256.69 27.64,256.69 A34.F2
  Bottom 0.203: v289.36,31.95 291.39,29.92 310.08,29.92 312.93,27.08 327.15,27.08 327.56,26.67 403.15,26.67 403.56,26.26 406.81,26.26 407.21,26.67 423.88,26.67 426.31,24.23 442.98,24.23 445.82,27.08 451.1,27.08 456.39,32.36 456.39,33.58 455.17,33.58 453.95,34.8 453.95,81.53 454.36,81.53 454.36,122.17 453.54,122.17 451.1,124.61 451.1,153.47 452.32,153.47 453.95,155.09 453.95,170.13 412.5,170.13 411.68,170.94 AB04.BM2
DATA07  (via drill 0.61)
  Top 0.203: v39.01,277.42 25.6,264.01 25.6,252.22 26.42,251.41 A34.J2 | v409.25,214.02 409.65,213.61 409.65,194.11 412.5,191.26 412.5,166.47 411.68,165.66 AB04.BP2
  Route2 0.203: v322.68,244.91 323.49,244.91 328.78,250.19 329.18,250.19 331.22,252.22 335.28,252.22 353.57,270.51 v353.97,270.51 | v412.09,218.08 412.09,216.86 v409.25,214.02
  Route15 0.203: v269.04,279.45 272.69,283.11 277.98,283.11 279.2,281.89 282.04,281.89 283.26,280.67 284.89,280.67 291.8,273.76 291.8,272.95 292.61,272.14 295.05,272.14 301.95,265.23 301.95,263.6 314.15,251.41 316.18,251.41 v322.68,244.91 | v353.97,270.51 356.41,272.95 383.24,246.13 383.64,246.13 411.68,218.08 v412.09,218.08
  Bottom 0.203: v39.01,277.42 40.23,278.64 95.5,278.64 96.32,279.45 v269.04,279.45
DATA08  (via drill 0.61)
  Top 0.203: v138.18,262.79 142.65,258.32 142.65,255.47 v142.24,255.07 | v270.26,254.25 271.07,253.44 271.07,242.88 v270.66,242.47 | v425.91,228.65 428.35,226.21 428.35,174.19 v427.13,172.97
  Route2 0.203: v41.45,262.79 27.23,248.56 27.23,244.91 A34.L2 | v334.06,219.71 334.47,219.71 336.09,221.34 336.09,225.4 343.81,233.12 348.29,233.12 363.73,248.56 365.35,248.56 v384.05,267.26
  Route15 0.203: v270.66,242.47 271.07,242.47 271.48,242.06 281.63,242.06 283.67,240.03 299.52,240.03 299.92,239.62 308.05,239.62 309.27,238.4 310.49,238.4 312.12,236.78 316.59,236.78 332.44,220.93 332.84,220.93 v334.06,219.71 | v384.05,267.26 385.67,268.88 v425.91,228.65
  Bottom 0.203: v41.45,262.79 41.86,262.38 137.77,262.38 v138.18,262.79 | v142.24,255.07 142.65,255.47 269.04,255.47 v270.26,254.25 | v427.13,172.97 426.31,172.16 424.28,172.16 AB03.BM2
DATA09  (via drill 0.61)
  Top 0.203: v339.75,88.44 339.75,95.76 337.72,97.79 v337.72,99.82
  Route2 0.203: v332.84,85.6 334.47,87.22 337.31,87.22 337.72,87.63 338.94,87.63 v339.75,88.44 | v359.66,103.07 358.04,104.7 363.32,109.98 363.73,109.98 371.86,118.11 371.86,118.52 391.36,138.02 394.21,138.02 420.62,164.44 422.66,164.44 423.06,164.85 AB03.BP2
  Route15 0.203: v132.08,230.28 147.93,214.43 147.93,213.61 148.74,212.8 148.74,207.92 178,178.66 179.63,178.66 210.51,147.78 211.33,147.78 251.97,107.14 252.78,107.14 v273.91,86
  Bottom 0.203: v132.08,230.28 108.92,230.28 102.41,236.78 49.99,236.78 47.14,239.62 28.85,239.62 27.64,238.4 A34.N2 | v273.91,86 274.73,86.82 276.76,86.82 277.17,87.22 331.22,87.22 v332.84,85.6 | v337.72,99.82 338.12,100.23 340.97,100.23 343.81,103.07 v359.66,103.07
DATA10  (via drill 0.61)
  Top 0.203: v304.8,171.35 305.21,171.75 v305.21,179.88 | v34.54,268.07 29.67,263.2 28.45,263.2 28.45,248.97 25.6,246.13 25.6,233.12 26.42,232.31 A34.R2
  Route2 0.203: v357.23,166.47 353.16,166.47 v348.69,162
  Route15 0.203: v429.56,166.88 429.16,167.28 432.82,170.94 436.07,170.94 AB02.BM2 | v348.69,162 347.47,162 344.63,164.85 344.22,164.85 339.34,169.72 338.53,169.72 332.44,175.82 330.4,175.82 329.18,174.6 v331.62,172.16 | v305.21,179.88 305.21,184.35 297.89,191.67 293.01,191.67 217.42,267.26 v217.02,267.26
  Bottom 0.203: v429.56,166.88 357.63,166.88 v357.23,166.47 | v331.62,172.16 330.81,172.97 308.86,172.97 307.24,171.35 v304.8,171.35 | v217.02,267.26 216.21,268.07 v34.54,268.07
DATA11  (via drill 0.61)
  Top 0.203: v351.54,140.87 350.72,140.06 346.66,140.06 v346.66,144.12
  Route2 0.203: v415.34,141.68 436.07,162.41 436.07,164.44 AB02.BP2 | v346.66,144.12 335.28,132.74 334.87,132.74 334.47,132.33 334.47,131.52 330.4,127.46 330.4,126.24 330,125.83 330,122.99 323.09,116.08 319.02,116.08 317.81,114.86 317.81,110.79 310.49,103.48 306.02,103.48 295.45,92.91 295.45,89.66 299.11,86 294.23,81.13 290.98,81.13 v280.82,70.97
  Route15 0.203: v280.82,70.97 280.82,71.37 275.13,77.06 271.48,77.06 261.31,87.22 256.44,87.22 254,89.66 250.75,89.66 202.39,138.02 199.14,138.02 152.4,184.76 152.4,185.57 v121.92,216.05
  Bottom 0.203: v415.34,141.68 375.51,141.68 374.29,140.46 372.26,140.46 371.86,140.87 v351.54,140.87 | v121.92,216.05 121.51,216.46 80.06,216.46 76,220.52 33.73,220.52 29.26,224.99 27.64,224.99 A34.T2
DATA_ADD00  (via drill 0.61)
  Top 0.203: v382.02,77.47 384.05,79.5 384.05,94.94 v384.86,95.76 | v376.73,137.21 377.55,138.02 377.55,156.31 379.17,157.94 AB07.BS1
  Route2 0.203: v382.02,77.47 381.61,77.47 328.78,24.64 328.78,23.01 D11.S1 | v384.86,95.76 385.27,95.76 393.39,103.89 393.39,108.76 393.8,109.17 393.8,109.98 v395.02,111.2
  Route15 0.203: v395.02,111.2 395.43,111.61 393.8,113.23 393.8,118.52 390.96,121.36 390.96,122.99 v376.73,137.21
DATA_ADD01  (via drill 0.61)
  Top 0.203: v377.95,132.74 377.95,150.62 379.17,151.84 AB07.BU1
  Route2 0.203: v384.86,81.53 325.93,22.61 322.68,22.61 D11.S2 | v377.95,132.74 v369.01,123.8
  Route15 0.203: v384.86,81.53 384.86,82.75 384.45,83.16 384.45,90.07 382.42,92.1 382.42,93.32 381.2,94.54 381.2,101.04 375.11,107.14 375.11,117.7 v369.01,123.8
DATA_ADD02  (via drill 0.61)
  Top 0.203: v332.44,3.1 329.18,3.1 319.84,12.45 D11.V2 | v397.46,133.96 394.61,136.8 394.61,147.78 393.39,149 393.39,156.72 392.18,157.94 AB06.BS1
  Route2 0.203: v332.44,3.1 336.5,3.1 337.72,4.32 345.44,4.32 355.6,14.48 360.88,14.48 386.89,40.49 388.52,40.49 393.8,45.77 393.8,47.4 418.19,71.78 418.19,72.59 418.59,73 418.59,83.97 432.41,97.79 432.41,98.2 v433.22,99.01
  Route15 0.203: v433.22,99.01 432.82,99.01 428.75,103.07 428.75,103.48 428.35,103.89 427.53,103.89 v397.46,133.96
DATA_ADD03  (via drill 0.61)
  Top 0.203: v390.96,160.78 390.96,153.87 391.77,153.06 AB06.BU1
  Route15 0.203: v340.97,160.78 340.97,161.19 325.93,176.22 325.93,176.63 v325.12,177.44
  Bottom 0.203: v390.96,160.78 390.55,160.38 362.92,160.38 362.51,160.78 v340.97,160.78 | v325.12,177.44 324.31,176.63 317.4,176.63 316.59,177.44 B12.K1
DATA_ADD04  (via drill 0.61)
  Top 0.203: v346.25,114.05 345.85,114.45 345.85,115.67 345.44,116.08 345.44,116.89 346.25,117.7 346.25,118.92 v348.69,121.36
  Route2 0.203: v346.25,114.05 338.12,105.92 334.06,105.92 302.77,74.62 302.77,72.19 300.33,69.75 300.33,64.06 D13.B1 | v348.69,121.36 350.72,123.39 352.35,123.39 352.75,123.8 352.75,124.61 360.07,131.93 360.48,131.93 362.1,133.55 362.1,133.96 366.17,138.02 373.48,138.02 384.05,148.59 384.05,154.28 v389.33,159.56
  Bottom 0.203: v389.33,159.56 389.74,159.97 403.56,159.97 404.37,159.16 AB05.BS1
DATA_ADD05  (via drill 0.61)
  Top 0.203: v399.08,107.54 400.3,108.76 400.3,116.08 403.56,119.33 403.56,133.15 405.99,135.59 405.99,151.03 405.18,151.84 AB05.BU1
  Route2 0.203: v341.38,39.68 341.78,39.68 352.35,50.24 352.35,54.3 370.64,72.59 370.64,74.22 384.45,88.04 384.45,88.85 396.65,101.04 396.65,105.1 v399.08,107.54
  Bottom 0.203: v341.38,39.68 321.87,39.68 319.02,42.52 308.86,42.52 308.05,41.71 304.39,41.71 303.99,41.3 D13.K1
DATA_ADD06  (via drill 0.61)
  Top 0.203: v314.15,22.61 314.15,17.73 305.61,17.73 298.7,24.64 298.7,25.04 294.23,25.04 D13.R2 | v415.34,109.98 415.75,110.39 415.75,124.21 416.15,124.61 416.15,156.72 417.37,157.94 AB04.BS1
  Route2 0.203: v314.15,22.61 357.23,65.68 357.23,68.53 357.63,68.94 357.63,75.84 358.04,76.25 358.04,80.31 v386.08,108.36
  Bottom 0.203: v386.08,108.36 387.71,109.98 v415.34,109.98
DATA_ADD07  (via drill 0.61)
  Top 0.203: v295.45,9.2 295.45,17.32 294.23,18.54 D13.T2 | v364.95,8.79 435.25,8.79 435.25,51.87 435.66,52.27 435.66,53.09 435.25,53.49 435.25,76.66 434.85,77.06 434.85,110.79 432,113.64 432,127.46 431.6,127.86 431.6,141.28 v429.56,143.31 | v421.84,143.31 417.78,147.37 417.78,151.84 AB04.BU1
  Bottom 0.203: v295.45,9.2 295.86,8.79 v364.95,8.79 | v429.56,143.31 v421.84,143.31
DATA_ADD08  (via drill 0.61)
  Top 0.203: v344.63,2.69 344.63,2.29 320.24,2.29 301.95,20.57 293.01,20.57 292.2,19.76 292.2,14.48 293.42,13.26 D13.V2 | v432.82,66.9 432.82,80.31 431.6,81.53 431.6,118.11 430.78,118.92 429.16,118.92 429.16,121.77 428.35,122.58 428.35,156.31 429.97,157.94 AB03.BS1
  Route2 0.203: v344.63,2.69 356.01,14.07 379.58,14.07 432.41,66.9 v432.82,66.9
DATA_ADD09  (via drill 0.61)
  Top 0.203: v319.84,134.77 318.62,135.99 v318.62,137.21
  Route2 0.203: v318.62,137.21 323.49,142.09 323.9,142.09 324.31,142.49 324.31,143.31 325.12,144.12 325.12,145.75 v332.44,153.06 | v416.97,138.43 416.97,140.06 419.81,142.9 419.81,144.12 426.31,150.62 427.94,150.62 429.56,152.25 AB03.BU1
  Route15 0.203: v112.98,269.29 232.05,150.22 232.05,148.59 v245.87,134.77 | v332.44,153.06 337.72,147.78 341.38,147.78 v351.54,137.62
  Bottom 0.203: v112.98,269.29 110.95,271.32 102.41,271.32 99.57,268.48 35.36,268.48 34.14,269.7 A34.B1 | v245.87,134.77 248.72,131.93 251.16,131.93 251.56,132.33 267.41,132.33 267.82,131.93 283.67,131.93 286.51,134.77 289.36,134.77 289.76,134.37 292.61,134.37 293.01,134.77 301.95,134.77 302.36,134.37 305.21,134.37 305.61,134.77 313.74,134.77 314.15,134.37 318.21,134.37 318.62,134.77 v319.84,134.77 | v351.54,137.62 351.94,138.02 400.71,138.02 401.12,137.62 403.96,137.62 404.77,138.43 v416.97,138.43
DATA_ADD10  (via drill 0.61)
  Route2 0.203: v351.94,124.21 351.94,124.61 355.6,128.27 355.6,129.49 371.45,145.34 371.86,145.34 372.26,145.75 372.26,147.37 v382.02,157.12
  Route15 0.203: v154.43,259.54 171.5,242.47 172.72,242.47 209.3,205.89 215.8,205.89 238.96,182.73 240.18,182.73 285.29,137.62 286.11,137.62 v300.74,122.99
  Bottom 0.203: v154.43,259.54 154.03,259.13 142.65,259.13 139.8,261.98 28.85,261.98 27.64,263.2 A34.D2 | v300.74,122.99 301.14,122.58 349.91,122.58 351.54,124.21 v351.94,124.21 | v382.02,157.12 440.94,157.12 442.16,158.34 AB02.BS1
DATA_ADD11  (via drill 0.61)
  Top 0.203: v317.4,172.16 317.4,162 v316.99,161.59 | v438.51,135.18 441.35,138.02 441.35,150.62 442.57,151.84 AB02.BU1
  Route15 0.203: v121.92,235.97 v97.13,260.76 | v242.62,235.97 245.06,238.4 277.17,206.3 277.57,206.3 301.55,182.32 303.17,182.32 303.58,181.91 303.58,180.29 304.8,179.07 310.49,179.07 v317.4,172.16 | v316.99,161.59 316.99,161.19 318.62,159.56 319.43,159.56 331.22,147.78 335.69,147.78 345.03,138.43 347.88,138.43 351.94,134.37 353.97,134.37 356.41,131.93 360.88,131.93 v361.29,131.52
  Bottom 0.203: v97.13,260.76 96.32,261.57 37.8,261.57 36.98,260.76 A34.E1 | v121.92,235.97 124.36,233.53 179.22,233.53 182.07,236.37 242.21,236.37 v242.62,235.97 | v361.29,131.52 361.7,131.93 390.96,131.93 391.36,132.33 394.21,132.33 394.61,131.93 410.87,131.93 413.71,134.77 416.15,134.77 416.56,134.37 419.81,134.37 420.62,135.18 v438.51,135.18
DATA_ADD_EN  (via drill 0.61)
  Route15 0.203: v348.29,218.08 348.29,217.68 361.29,204.67 361.29,204.27 405.99,159.56 405.99,157.94 407.62,156.31 AB04.BT2
  Bottom 0.203: AB07.BT2 370.64,155.91 371.45,156.72 381.2,156.72 382.02,155.91 AB06.BT2 383.24,155.91 384.05,156.72 393.8,156.72 394.61,155.91 AB05.BT2 395.83,155.91 396.65,156.72 409.25,156.72 | AB02.BT2 432.82,155.91 432,156.72 422.25,156.72 421.44,155.91 AB03.BT2 420.22,155.91 419.4,156.72 409.25,156.72 | v348.29,218.08 345.44,218.08 345.03,218.49 A09.V2 | 409.25,156.72 408.43,155.91 AB04.BT2
DATA_ENABLE  (via drill 0.61)
  Top 0.203: v371.86,220.93 371.45,220.52 v371.45,174.19
  Route15 0.203: v371.86,220.93 v365.35,227.43
  Bottom 0.203: AB02.BL1 439.32,174.19 438.51,173.38 428.35,173.38 427.53,174.19 AB03.BL1 426.31,174.19 425.5,173.38 415.75,173.38 414.93,174.19 AB04.BL1 413.71,174.19 412.9,173.38 405.59,173.38 404.77,174.19 402.34,174.19 AB05.BL1 401.12,174.19 400.3,173.38 387.71,173.38 | 387.71,173.38 377.55,173.38 376.73,174.19 AB07.BL1 375.51,174.19 v371.45,174.19 | 387.71,173.38 388.52,174.19 AB06.BL1 | v365.35,227.43 359.66,227.43 359.26,227.84 355.19,227.84 354.79,228.24 A09.S1
DATA_IN  (via drill 0.61)
  Top 0.203: v268.63,99.82 266.6,99.82 266.6,123.39 269.44,126.24 269.44,138.02 267,140.46 267,165.25 269.44,167.69 269.44,184.35 267.82,185.98 267.82,238 268.22,238.4 v268.22,248.56
  Route2 0.203: C36.M2 4.88,105.51 4.88,109.17 6.1,110.39 6.1,122.99 18.69,135.59 18.69,136.8 51.61,169.72 53.24,169.72 54.86,171.35 B32.M2
  Route15 0.203: v329.18,249.38 330,249.38 331.62,247.75 331.62,246.53 333.25,244.91 333.25,243.69 334.87,242.06 A10.M2 | v153.21,170.94 174.35,149.81 174.35,149 v230.43,92.91
  Bottom 0.203: v268.22,248.56 269.04,249.38 v329.18,249.38 | C11.N2 318.62,101.04 318.21,100.63 313.74,100.63 312.93,99.82 v268.63,99.82 268.22,99.82 267,99.82 258.06,90.88 232.46,90.88 v230.43,92.91 | v153.21,170.94 152.4,170.13 142.24,170.13 136.55,175.82 131.67,175.82 129.24,173.38 105.66,173.38 102.41,170.13 61.37,170.13 60.96,170.54 56.49,170.54 56.08,170.94 B32.M2
DCA  (via drill 0.61)
  Top 0.203: v332.84,233.12 333.25,233.53 333.25,248.97 332.03,250.19 A10.J2 | v372.67,188.42 374.7,186.38 374.7,144.93 375.11,144.53 375.11,124.21 v377.14,122.17 | v368.61,23.42 368.61,70.56 369.42,71.37 v369.42,77.47
  Route2 0.203: v369.42,77.47 369.42,79.1 375.51,85.19 375.51,86 380.8,91.29 380.8,95.35 388.52,103.07 v388.52,103.48
  Route15 0.203: v332.84,233.12 332.84,232.72 347.47,218.08 347.47,217.68 351.94,213.21 351.94,210.36 357.63,204.67 357.63,203.45 v372.67,188.42 | v377.14,122.17 377.14,121.77 384.05,114.86 384.05,112.01 384.45,111.61 384.45,107.95 388.52,103.89 v388.52,103.48
  Bottom 0.203: v388.52,103.48 380.8,103.48 379.98,104.29 C07.M1 | v368.61,23.42 349.1,23.42 348.29,22.61 D09.S2
DCA\  (via drill 0.61)
  Route2 0.203: v332.84,92.51 332.84,92.91 338.53,98.6 339.34,98.6 340.56,99.82 344.63,99.82 345.85,101.04 345.85,103.07 347.07,104.29 C09.M2 348.29,105.1 349.91,106.73 351.54,106.73 353.16,108.36 355.19,108.36 v357.23,110.39
  Route15 0.203: v307.24,92.91 306.83,93.32 306.83,94.54 C12.R2
  Bottom 0.203: v307.24,92.91 307.64,93.32 332.03,93.32 v332.84,92.51 | v357.23,110.39 358.04,110.39 358.85,109.58 374.29,109.58 375.51,108.36 C07.L1
DEFER  (via drill 0.61)
  Top 0.203: v339.75,248.56 339.75,264.82 340.97,266.04 A10.C1 | v337.31,248.56 336.91,248.16 336.91,239.62 337.72,238.81 A10.N1 | v264.16,201.83 260.5,198.17 260.5,142.09 260.1,141.68 260.1,137.62 261.72,135.99 v261.72,93.32
  Route2 0.203: v351.54,79.1 362.51,90.07 364.54,90.07 366.17,91.69 C08.S1 | v264.16,201.83 279.6,217.27 279.6,219.71 297.49,237.59 299.52,237.59 A13.N1
  Route15 0.203: v293.01,79.5 277.98,94.54 277.98,97.79 C15.P1
  Bottom 0.203: A12.C1 316.59,266.85 317.81,268.07 339.34,268.07 340.56,266.85 A10.C1 | A13.N1 300.74,238 301.95,236.78 332.84,236.78 333.65,237.59 337.72,237.59 A10.N1 | v337.31,248.56 v339.75,248.56 | v293.01,79.5 293.42,79.91 312.93,79.91 314.15,78.69 337.31,78.69 338.12,79.5 351.13,79.5 v351.54,79.1 | v261.72,93.32 265.38,96.98 275.95,96.98 277.17,98.2 C15.P1
DEFER\  (via drill 0.61)
  Top 0.203: v316.59,70.97 314.55,68.94 314.55,59.59 312.93,57.96 D12.D1 | v359.26,68.12 363.73,68.12 363.73,68.53 367.79,72.59 367.79,84.38 366.98,85.19 C08.U1
  Route15 0.203: v345.85,70.56 346.25,70.56 346.66,70.16 349.1,70.16 349.5,69.75 355.19,69.75 356.41,68.53 358.85,68.53 v359.26,68.12 | v396.24,59.18 373.89,81.53 373.89,81.94 373.48,82.35 372.26,82.35 370.64,83.97 369.01,83.97 367.39,85.6 C08.U1
  Bottom 0.203: v316.59,70.97 317.81,72.19 342.6,72.19 344.22,70.56 v345.85,70.56 | v396.24,59.18 420.62,59.18 423.88,55.93 447.04,55.93 448.67,54.3 D01.E2
DOUBLE_LEFT_ROTATE  (via drill 0.61)
  Top 0.203: v338.53,151.03 336.91,152.65 336.91,166.88 337.72,167.69 B10.N1
  Route2 0.203: v347.88,169.32 428.35,249.78 428.35,251.82 429.97,253.44 AB03.AH1
  Bottom 0.203: v338.53,151.03 340.16,149.4 343.81,149.4 B09.V2 | AB07.AH1 379.98,253.44 380.8,252.63 387.3,252.63 388.52,253.85 391.36,253.85 AB06.AH1 392.58,253.44 393.39,252.63 406.81,252.63 | 406.81,252.63 405.59,253.85 AB05.AH1 | 416.15,252.63 406.81,252.63 | 416.15,252.63 416.97,253.44 AB04.AH1 | 428.35,252.63 429.56,253.85 AB03.AH1 | 428.35,252.63 416.15,252.63 | 428.35,252.63 440.94,252.63 442.16,253.85 AB02.AH1 | v347.88,169.32 347.47,169.72 340.16,169.72 338.94,168.5 B10.N1
DOUBLE_RIGHT_ROTATE  (via drill 0.61)
  Top 0.203: v351.13,208.33 351.13,204.67 346.25,199.8 346.25,182.73 345.03,181.51 B09.J2 | v377.55,235.97 377.95,236.37 377.95,257.91 376.33,259.54 376.33,262.79 AB07.AD1
  Route2 0.203: v351.13,208.33 351.94,209.14 351.94,210.36 v377.55,235.97
  Route15 0.203: B09.J2 344.22,181.51 344.22,183.13 341.78,185.57 340.56,185.57 338.94,187.2 B10.F1
  Bottom 0.203: 425.5,262.38 415.75,262.38 414.93,263.2 AB04.AD1 413.71,263.2 413.31,262.79 409.25,262.79 408.84,262.38 400.3,262.38 | 425.5,262.38 426.31,263.2 AB03.AD1 | 425.5,262.38 438.91,262.38 439.32,262.79 AB02.AD1 | 388.11,262.38 377.55,262.38 376.73,263.2 AB07.AD1 | 388.11,262.38 388.52,262.79 AB06.AD1 | 400.3,262.38 401.12,263.2 AB05.AD1 | 388.11,262.38 400.3,262.38
E_SET  (via drill 0.61)
  Top 0.203: v357.23,91.69 357.23,89.66 C08.T2
  Route2 0.203: C09.V1 351.13,83.16 351.13,84.78 353.57,87.22 354.79,87.22 356.41,88.85 C08.T2
  Bottom 0.203: v357.23,91.69 358.04,90.88 367.39,90.88 367.79,91.29 371.45,91.29 372.26,92.1 C07.S2
E_SET\  (via drill 0.61)
  Top 0.203: 244.65,17.32 245.47,16.51 245.47,16.1 D17.U2 | 244.65,17.32 243.43,18.54 D17.T2 | 244.65,17.32 241.4,14.07 241.4,9.2 238.15,5.94 232.05,5.94 232.05,122.58 228.8,125.83 228.8,175.41 v230.84,177.44
  Route2 0.203: v280.01,172.97 279.6,173.38 279.6,175.41 287.32,183.13 287.32,184.35 299.52,196.54 299.52,199.39 B13.B1
  Route15 0.203: C07.T2 369.42,89.26 366.98,89.26 361.29,94.94 360.48,94.94 345.03,110.39 345.03,111.61 340.16,116.48 340.16,120.55 332.44,128.27 330.81,128.27 329.18,129.9 C11.C1 | v280.01,172.97 281.63,171.35 281.63,169.72 282.45,168.91 282.45,158.34 293.83,146.96 293.83,146.15 295.45,144.53 295.45,142.49 302.77,135.18 308.05,135.18 309.27,133.96 310.08,133.96 315.37,128.68 317.4,128.68 318.62,127.46 C11.D2
  Bottom 0.203: C11.D2 319.84,127.05 320.24,127.46 323.9,127.46 326.34,129.9 327.96,129.9 C11.C1 | v230.84,177.44 232.46,179.07 273.51,179.07 279.6,172.97 v280.01,172.97
EA\  (via drill 0.61)
  Top 0.203: v291.39,84.38 292.2,85.19 292.2,93.32 293.42,94.54 C13.R2 | v219.05,60 202.79,76.25 202.79,88.04 186.94,103.89 186.94,129.08 v185.72,130.3
  Route2 0.203: v291.39,84.38 267.82,60.81 265.79,60.81 D16.C1
  Route15 0.203: v55.68,198.98 104.44,150.22 104.44,149 124.77,128.68 126.8,128.68 128.02,127.46 C26.D2
  Bottom 0.203: v55.68,198.98 55.27,198.58 35.36,198.58 34.14,199.8 B34.B1 | v219.05,60 219.86,59.18 263.75,59.18 264.57,60 D16.C1 | v185.72,130.3 184.1,128.68 130.45,128.68 129.24,127.46 C26.D2
EMA\  (via drill 0.61)
  Top 0.203: v373.48,279.04 382.42,279.04 387.3,283.92 451.1,283.92 451.1,259.13 452.32,257.91 A01.F1
  Route2 0.203: v148.74,154.28 149.15,154.28 155.65,160.78 161.75,160.78 177.6,176.63 178.41,176.63 200.35,198.58 201.17,198.58 204.01,201.42 208.08,201.42 241.81,235.15 243.03,235.15 v258.88,251 | v321.46,238.81 321.87,238.81 330,246.94 330,247.75 330.4,248.16 332.03,248.16 342.19,258.32 v342.6,258.32 | v349.5,258.32 353.97,258.32 368.2,272.54 368.2,273.76 v373.48,279.04
  Route15 0.203: v258.88,251 271.48,251 275.54,246.94 276.35,246.94 280.01,243.28 303.17,243.28 303.99,244.09 304.8,244.09 305.61,243.28 315.77,243.28 318.21,240.84 319.43,240.84 v321.46,238.81
  Bottom 0.203: v148.74,154.28 106.07,154.28 102.01,150.22 81.28,150.22 80.87,150.62 51.61,150.62 48.77,147.78 16.26,147.78 15.04,149 B35.V2 | v342.6,258.32 v349.5,258.32
EXECUTE  (via drill 0.61)
  Top 0.203: B09.H1 353.57,183.54 353.57,178.26 B09.K1 354.38,177.04 355.19,176.22 355.19,129.08 v354.79,128.68 | v358.85,128.68 358.85,98.6 358.44,98.2 358.44,83.97 357.63,83.16 C08.V2 | B09.F1 350.32,186.79 350.32,181.51 B09.J1
  Route15 0.203: v354.79,128.68 v358.85,128.68
  Bottom 0.203: B09.J1 351.13,181.51 353.16,183.54 353.57,183.54 B09.H1
EXECUTE\  (via drill 0.61)
  Top 0.203: v368.2,94.54 368.2,91.69 365.35,88.85 365.35,84.78 363.73,83.16 C08.V1
  Route15 0.203: v368.2,94.54 368.61,94.54 372.26,90.88 v375.92,90.88
  Bottom 0.203: v375.92,90.88 381.61,90.88 382.02,91.29 384.45,91.29 384.86,90.88 394.21,90.88 394.61,91.29 397.05,91.29 398.27,90.07 404.37,90.07 404.77,89.66 406.81,89.66 407.21,90.07 417.37,90.07 423.06,84.38 447.85,84.38 448.67,85.19 C01.U2
F_SET  (via drill 0.61)
  Top 0.203: v356.41,103.89 356.01,103.48 356.01,90.47 355.6,90.07 355.6,51.05 351.54,51.05 D09.F1 | v104.85,144.53 104.85,122.58 103.63,121.36 C28.F2 | v261.72,147.78 264.16,150.22 v264.16,183.54
  Route15 0.203: v316.59,144.93 327.96,133.55 328.78,133.55 341.38,120.95 341.38,120.14 345.85,115.67 346.25,115.67 350.72,111.2 350.72,110.39 356.41,104.7 356.41,104.29 v356.41,103.89
  Bottom 0.203: v356.41,103.89 357.23,104.7 359.66,104.7 C08.M2 360.88,104.29 361.7,103.48 368.2,103.48 369.42,102.26 C07.N2 | v104.85,144.53 105.66,145.34 187.76,145.34 188.98,144.12 251.56,144.12 255.22,147.78 v261.72,147.78 262.13,147.78 262.94,146.96 293.42,146.96 295.05,145.34 308.46,145.34 308.86,145.75 315.77,145.75 v316.59,144.93 | v264.16,183.54 269.04,188.42 280.01,188.42 280.42,188.82 301.55,188.82 302.77,190.04 B13.E1
F_SET\  (via drill 0.61)
  Top 0.203: D17.S2 245.47,22.61 245.47,23.01 243.43,25.04 D17.R2 243.43,25.86 244.65,27.08 244.65,43.33 v245.47,44.15 | v329.18,128.27 329.18,125.02 328.78,124.61 C11.E1
  Route2 0.203: v245.47,44.15 295.86,94.54 295.86,95.35 305.61,105.1 305.61,105.51 310.08,109.98 310.49,109.98 320.24,119.74 320.24,120.14 325.93,125.83 326.34,125.83 328.78,128.27 v329.18,128.27
  Route15 0.203: v352.75,127.05 372.26,107.54 372.26,105.92 372.67,105.51 C07.M2
  Bottom 0.203: v329.18,128.27 329.59,128.68 346.25,128.68 346.66,128.27 351.54,128.27 v352.75,127.05
FETCH  (via drill 0.61)
  Top 0.203: B09.D1 350.32,194.11 350.32,199.39 B09.B1 | B09.C1 353.57,197.36 353.57,202.64 B09.A1 353.97,203.86 v353.97,218.9 | v358.04,99.01 358.44,99.42 358.44,127.86 358.04,128.27 358.04,131.93 358.44,132.33 358.44,156.72 356.01,159.16 356.01,195.73 v356.41,196.14
  Route2 0.203: B09.D1 351.54,194.11 353.57,196.14 B09.C1
  Route15 0.203: v353.97,218.9 316.18,256.69 313.33,256.69 A12.F1 | v358.04,99.01 358.44,98.6 359.66,98.6 C08.P2
  Bottom 0.203: v356.41,196.14 356.01,196.54 354.79,196.54 B09.C1
FETCH\  (via drill 0.61)
  Top 0.203: v448.26,79.1 447.85,79.5 447.85,96.57 449.07,97.79 C01.P2
  Route15 0.203: v393.39,63.25 367.79,88.85 366.57,88.85 360.88,94.54 357.63,94.54 C08.R2
  Bottom 0.203: v393.39,63.25 393.39,64.87 410.87,64.87 413.71,62.03 416.15,62.03 416.56,62.43 419.81,62.43 420.22,62.03 427.94,62.03 431.19,65.28 449.88,65.28 450.7,66.09 450.7,70.16 447.45,70.16 445.01,72.59 445.01,79.1 v448.26,79.1
GND  (via drill 0.61)
  Top 0.508: A28.E2 105.66,260.76 103.63,262.79 103.63,263.2 A28.D2 | A32.T1 58.93,226.21 60.15,227.43 60.15,259.94 55.68,264.41 55.68,266.04 A32.C2 | v149.15,64.47 149.15,66.9 149.56,67.31 149.56,83.16 148.74,83.97 148.74,88.04 148.34,88.44 C25.T1 | D27.F2 116.23,51.46 117.45,52.68 117.45,58.37 118.67,59.59 D27.C2 | D29.A1 99.57,66.09 99.57,60.81 D29.C1 | 89,60 87.78,60 D30.C1 86.97,60.81 86.97,66.09 D30.A1 | 89,60 93.07,60 D29.C2 | D31.C2 68.68,60.81 69.9,62.03 69.9,64.47 70.71,65.28 70.71,81.13 69.9,81.94 69.9,85.19 71.12,86.41 71.12,88.44 C31.T1 | D32.C2 56.08,60 58.12,57.96 58.12,57.56 D32.D1 58.93,56.34 59.74,55.52 | 60.15,18.54 63.8,18.54 63.8,18.14 67.46,14.48 71.53,14.48 | 60.15,18.54 59.33,18.54 D32.T1 | 71.53,14.48 71.53,18.54 D31.T1 | 59.74,55.52 60.15,55.12 60.15,18.54 | v62.99,59.18 59.74,55.93 59.74,55.52 | 101.6,50.65 102.41,50.65 D28.F2 | 101.6,50.65 97.54,50.65 D29.F1 | D30.L2 77.62,38.86 77.62,43.74 D30.J2 77.22,44.96 77.22,50.24 D30.F2 | 101.6,50.65 101.6,42.93 100.38,41.71 D29.K1 | D30.N2 77.62,31.14 77.62,25.86 D30.R2 | D30.T1 84.12,19.76 84.12,24.64 D30.R1 83.72,25.86 83.72,31.14 D30.N1 | D29.T1 96.72,19.76 96.72,24.64 D29.R1 96.32,25.86 96.32,31.14 D29.N1 | D29.N2 90.22,32.36 90.22,37.64 D29.L2 89.81,38.46 89.81,38.86 87.78,40.89 D30.K1 87.78,41.71 87.78,42.11 89.81,44.15 D29.J2 90.22,44.96 90.22,50.24 D29.F2 90.22,51.46 89,52.68 89,60 | D28.V1 110.13,13.26 112.17,15.29 D28.U1 | 110.95,17.73 112.17,16.51 112.17,16.1 D28.U1 | 110.95,17.73 110.13,18.54 D28.T1 | D28.U1 113.39,16.1 113.39,16.51 115.42,18.54 D27.T2 116.64,18.95 121.51,18.95 D27.T1 122.73,18.54 123.55,17.73
  Top 0.508: 110.95,17.73 110.95,26.26 112.57,27.89 D28.P1 | D27.V1 122.73,13.26 124.77,15.29 124.77,15.7 D27.U1 124.77,16.1 124.77,16.51 123.55,17.73 | 123.95,26.67 123.55,26.26 123.55,17.73 | 123.95,26.67 125.17,27.89 D27.P1 | 120.7,34.39 123.95,34.39 123.95,26.67 | 120.7,34.39 119.48,34.39 D27.M2 | 120.7,34.39 120.7,42.52 121.92,43.74 D27.J1 | 71.53,14.48 80.47,14.48 80.47,15.29 D30.U2 | B33.A1 48.77,202.64 48.77,197.36 B33.C1 | B32.A1 61.37,202.64 61.37,197.36 B32.C1 | B36.A1 10.57,202.64 10.57,197.36 B36.C1 | B35.A1 23.57,202.64 23.57,197.36 B35.C1 | B34.A1 36.17,202.64 36.17,197.36 B34.C1 | B36.F2 1.22,186.79 1.22,181.51 B36.J2 1.22,180.29 1.22,175.41 B36.L2 1.22,174.19 1.22,168.91 B36.N2 1.22,167.69 1.22,162.41 B36.R2 | B35.L2 13.82,175.01 11.79,177.04 11.79,177.44 B36.K1 11.79,178.26 13.82,180.29 B35.J2 13.82,181.51 13.82,186.79 B35.F2 | B36.N1 7.72,167.69 7.72,162.41 B36.R1 7.72,161.19 7.72,156.31 B36.T1 | B35.R1 20.32,161.19 20.32,156.31 B35.T1 19.91,155.5 19.91,155.09 17.88,153.06 B35.U2 17.88,151.84 19.1,150.62 19.1,131.93 17.88,130.71 C35.C2 | B35.N2 13.82,167.69 13.82,162.41 B35.R2 | B34.T1 32.92,156.31 32.92,161.19 B34.R1 32.92,162.41 32.92,167.69 B34.N1 | B34.R2 26.42,162.41 26.42,167.69 B34.N2 26.82,168.91 26.82,174.19 B34.L2 26.42,175.01 24.38,177.04 24.38,177.44 B35.K1 24.38,178.26 24.38,178.66 26.42,180.7 B34.J2 26.42,181.51 26.42,186.79 B34.F2 | B32.U2 56.08,152.65 58.12,154.69 58.12,155.09 B32.T1 58.52,156.31 58.52,161.19 B32.R1 58.52,162.41 58.52,167.69 B32.N1 | B32.J2 52.02,180.29 52.02,175.41 B32.L2 52.02,174.19 52.02,168.91 B32.N2
  Top 0.508: B33.T1 45.92,156.31 45.92,161.19 B33.R1 45.52,162.41 45.52,167.69 B33.N1 | B28.H2 105.66,184.35 103.63,186.38 103.63,186.79 B28.F2 103.63,188.01 105.66,190.04 B28.E2 105.66,190.86 105.66,191.26 103.63,193.29 B28.D2 103.63,194.11 103.63,194.51 105.66,196.54 B28.C2 | B33.L2 39.01,175.01 36.98,177.04 36.98,177.44 B34.K1 | B33.J2 39.42,181.51 39.42,186.79 B33.F2 | D34.A1 36.17,66.09 36.17,60.81 D34.C1 | D36.A1 10.57,66.09 10.57,60.81 D36.C1 11.38,59.59 11.79,59.18 11.79,55.52 13.82,53.49 13.82,51.46 D35.F2 13.82,50.24 13.82,44.96 D35.J2 13.82,44.15 11.79,42.11 11.79,41.71 D36.K1 11.79,40.89 11.79,40.49 13.82,38.46 D35.L2 | D35.C1 23.57,60.81 23.57,66.09 D35.A1 23.57,67.31 17.88,73 17.88,85.19 C35.U2 17.88,86.41 19.91,88.44 19.91,88.85 C35.T1 20.32,89.66 20.32,94.54 C35.R1 | D34.F2 26.42,50.24 26.42,44.96 D34.J2 26.42,44.15 24.38,42.11 24.38,41.71 D35.K1 24.38,40.89 24.38,40.49 26.42,38.46 D34.L2 26.82,37.64 26.82,32.36 D34.N2 26.82,31.14 26.82,25.86 D34.R2 | D36.L2 1.22,38.86 1.22,43.74 D36.J2 1.22,44.96 1.22,50.24 D36.F2 | D34.U2 30.89,16.1 32.92,18.14 32.92,18.54 D34.T1 33.33,19.76 33.33,24.64 D34.R1 32.92,25.86 32.92,31.14 D34.N1 33.73,32.36 34.95,33.58 34.95,39.27 36.17,40.49 D34.K1 | D36.U2 5.28,16.51 7.32,18.54 D36.T1 7.72,19.76 7.72,24.64 D36.R1 7.72,25.86 7.72,31.14 D36.N1 8.53,31.55 13.82,31.55 D35.N2 13.82,31.14 13.82,25.86 D35.R2 | D36.N2 1.22,31.14 1.22,25.86 D36.R2 | D35.U2 17.88,16.51 19.91,18.54 19.91,18.95 D35.T1 20.32,19.76 20.32,24.64 D35.R1 | C36.N1 7.72,101.04 7.72,95.76 C36.R1 7.72,94.54 7.72,89.66 C36.T1
  Top 0.508: C36.A1 10.57,135.99 10.57,130.71 C36.C1 | C35.A1 23.57,135.99 23.57,130.71 C35.C1 | C36.N2 1.63,102.26 1.63,107.14 C36.L2 1.63,108.76 1.63,113.64 C36.J2 1.22,114.86 1.22,120.14 C36.F2 | C35.K1 23.16,111.61 21.95,112.83 21.95,118.92 21.13,119.74 21.13,120.14 C35.F1 | C35.F2 13.82,120.14 13.82,114.86 C35.J2 13.82,113.64 11.79,111.61 C36.K1 11.79,110.79 11.79,110.39 13.82,108.36 C35.L2 14.22,107.14 14.22,102.26 C35.N2 13.82,101.04 13.82,95.76 C35.R2 | 120.7,109.58 120.7,111.2 121.92,112.42 121.92,113.64 C27.J1 | 120.7,109.58 120.7,106.73 119.48,105.51 C27.M2 118.67,104.29 117.45,103.07 117.45,94.13 116.23,92.91 116.23,89.66 C27.T2 | C27.P1 125.17,97.79 123.55,96.16 123.55,93.32 122.33,92.1 122.33,89.66 C27.T1 | C27.C2 118.67,129.49 117.45,128.27 117.45,122.58 116.23,121.36 C27.F2 115.42,120.14 114.61,119.33 114.61,109.58 120.7,109.58 | B24.T1 159.72,155.09 158.5,153.87 158.5,131.52 157.68,130.71 C24.C2 | D27.C1 124.77,60.81 124.36,61.21 124.36,64.87 123.14,66.09 123.14,81.53 122.73,81.94 C27.V1 | B24.C2 156.87,197.36 155.65,198.58 155.65,205.08 154.84,205.89 154.84,217.68 159.72,222.56 159.72,224.99 A24.T1 | B20.C2 207.67,197.36 206.45,198.58 206.45,218.49 210.51,222.56 210.51,224.99 A20.T1 | B19.C2 221.08,197.36 221.49,197.76 221.49,201.83 225.15,205.49 225.15,224.18 224.33,224.99 A19.T1 | A10.C2 335.28,266.04 336.5,264.82 336.5,252.63 337.72,251.41 A10.J1 338.53,250.19 338.53,248.16 339.75,246.94 339.75,231.09 338.53,229.87 338.53,226.62 338.12,226.21 A10.T1 | A17.T1 249.12,226.21 247.5,227.84 247.5,264.82 246.28,266.04 A17.C2
  Top 0.508: 260.5,18.54 256.03,18.54 D16.T2 | 260.5,18.54 261.31,18.54 D16.T1 | 260.5,18.54 260.5,28.3 264.57,28.3 D16.P1 264.57,29.11 263.35,30.33 v263.35,34.8 | D16.M2 258.88,35.61 259.69,36.42 259.69,40.08 262.13,42.52 262.13,43.74 D16.J1 261.31,44.96 260.1,46.18 260.1,52.68 259.28,53.49 D16.E2 258.47,54.71 258.47,59.59 D16.C2 | v441.35,62.03 441.35,83.16 440.54,83.97 440.54,88.04 440.13,88.44 C02.T1 | AB07.BF1 375.51,187.6 375.51,188.01 373.48,190.04 AB07.BE2 373.48,190.86 375.51,192.89 375.51,193.29 AB07.BD1 375.51,194.11 373.48,196.14 AB07.BC2 | AB04.BF1 414.93,186.79 416.97,184.76 AB04.BH1 416.97,183.54 416.15,182.73 416.15,168.1 | AB06.BF2 383.24,187.6 385.27,189.64 385.27,190.04 AB06.BE2 385.67,191.26 385.67,196.14 AB06.BC2 385.67,197.36 385.67,200.2 388.11,202.64 388.11,205.89 387.3,206.7 387.3,219.71 388.11,220.52 388.11,224.59 388.52,224.99 AB06.AT1 | AB06.BD1 388.93,192.89 388.93,188.01 AB06.BF1 | AB05.BH1 404.37,184.76 402.34,186.79 402.34,187.2 AB05.BF1 | AB05.BC2 398.27,196.14 398.27,191.26 AB05.BE2 | 416.15,168.1 420.22,168.1 AB03.BN2 | 416.15,168.1 414.93,168.1 AB04.BN1 | AB07.BH1 379.17,183.54 378.76,183.13 378.76,179.48 377.55,178.26 377.55,169.72 376.73,168.91 AB07.BN1 | AB03.BN1 427.53,167.69 428.35,166.88 428.35,157.53 427.13,156.31 AB03.BT1 | B19.T1 223.52,155.09 222.3,153.87 222.3,131.93 221.08,130.71 C19.C2 | C06.J1 388.52,114.86 387.3,116.08 387.3,127.05 386.08,128.27 386.08,129.49 C06.C2 | 412.5,106.73 412.9,107.14 412.9,109.58 414.12,110.79 414.12,113.64 C04.J1 414.12,114.86 412.9,116.08 412.9,122.17 411.68,123.39 C04.E2
  Top 0.508: 412.5,106.73 411.28,105.51 C04.M2 | 412.9,98.2 412.5,98.2 412.5,106.73 | 412.9,98.2 416.97,98.2 C04.P1 | 412.9,98.2 412.9,90.88 414.12,89.66 C04.T1 | B01.T1 451.92,155.09 450.7,153.87 450.7,131.52 449.88,130.71 C01.C2 | D14.C2 284.48,60.81 285.7,62.03 285.7,87.22 286.92,88.44 C14.T1
  Route15 0.508: AB03.BH1 429.56,184.35 429.56,184.76 427.53,186.79 AB03.BF1 | AB06.BH1 391.36,184.35 391.36,184.76 389.33,186.79 AB06.BF1
  Bottom 0.508: 144.68,265.23 144.68,261.16 A25.E2 | 144.68,265.23 155.25,265.23 | 155.25,265.23 156.46,266.45 A24.C2 | 155.25,265.23 167.84,265.23 169.06,266.45 A23.C2 | 144.68,265.23 108.1,265.23 106.88,266.45 A28.C2 106.07,266.04 104.04,264.01 103.63,264.01 A28.D2 102.41,263.2 61.37,263.2 58.12,266.45 56.08,266.45 A32.C2 54.86,266.45 53.65,265.23 41.05,265.23 | 44.3,227.03 35.76,227.03 34.14,225.4 A34.T1 32.92,225.81 28.85,225.81 27.64,227.03 22.35,227.03 21.13,225.81 A35.T1 19.91,225.81 18.69,227.03 13.82,227.03 13.41,226.62 9.35,226.62 8.53,225.81 A36.T1 7.32,224.99 7.32,220.52 6.91,220.52 2.85,216.46 2.85,200.61 6.91,196.54 | 44.3,227.03 45.52,225.81 A33.T1 | 44.3,227.03 52.83,227.03 53.24,226.62 57.3,226.62 58.12,225.81 A32.T1 | 15.44,268.07 6.1,268.07 5.28,267.26 A36.C2 | 15.44,268.07 16.66,266.85 A35.C2 | 15.44,268.07 28.85,268.07 29.67,267.26 A34.C2 30.89,266.45 32.11,265.23 41.05,265.23 | 41.05,265.23 42.27,266.45 A33.C2 | 149.15,61.62 155.25,61.62 | 149.15,61.62 145.9,61.62 145.09,60.81 D25.C2 143.87,60.81 143.05,61.62 126.8,61.62 125.98,60.81 D27.C1 124.77,60 119.48,60 D27.C2 118.26,60 113.39,60 D28.C1 112.17,60 106.88,60 D28.C2 105.66,60 100.79,60 D29.C1 99.57,60 94.28,60 D29.C2 | 155.25,61.62 156.46,60.4 D24.C2 | 155.25,61.62 167.84,61.62 169.06,60.4 D23.C2 | 149.15,61.62 v149.15,64.47 | D30.C2 81.69,60 86.56,60 D30.C1 | C32.T1 59.33,89.26 60.15,90.07 64.21,90.07 64.62,90.47 67.06,90.47 68.28,89.26 70.71,89.26 C31.T1 | v62.99,59.18 66.65,59.18 67.46,60 D31.C2 | D29.K1 100.79,41.3 102.41,42.93 107.7,42.93 108.92,44.15 D28.J1 | D30.F2 78.44,50.65 83.72,50.65 D30.F1 84.94,50.65 89.81,50.65 D29.F2 91.03,50.24 96.32,50.24 D29.F1