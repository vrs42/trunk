# EAGLE board pdp8l (EAGLE 4.11), part 6 of 8
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
N$49  (via drill 0.61) (continued)
  Bottom 0.203: v355.6,216.05 355.19,216.46 348.29,216.46 v347.88,216.05
N$50  (via drill 0.61)
  Top 0.203: A09.R1 350.32,232.31 350.32,237.59 A09.N1 | v339.34,102.67 339.75,103.07 339.75,122.99 340.16,123.39 340.16,128.68 339.75,129.08 339.75,137.21 340.56,138.02 340.56,151.03 340.16,151.44 340.16,166.88 v340.56,167.28 | v354.79,181.51 355.19,181.91 355.19,215.24 354.79,215.65 354.79,220.93 355.19,221.34 355.19,233.53 354.38,234.34 A09.P1 353.57,235.56 353.57,240.84 A09.M1
  Route2 0.203: v354.79,181.51 v340.56,167.28 | A09.R1 351.54,231.9 351.54,232.31 353.57,234.34 A09.P1
  Bottom 0.203: v339.34,102.67 338.94,103.07 337.72,103.07 331.62,96.98 323.49,96.98 322.68,97.79 C11.P2
N$51  (via drill 0.61)
  Top 0.203: v317.81,146.15 317.81,91.29 317.4,90.88 317.4,87.63 316.18,86.41 C12.U1 | v352.75,146.15 352.75,175.01 352.35,175.41 352.35,215.24 v352.75,215.65 | v355.6,218.9 v355.6,261.16 | A08.A1 366.17,272.54 364.95,271.32 364.95,264.82 364.13,264.01 A08.D1
  Route2 0.203: v352.75,215.65 352.75,216.05 v355.6,218.9
  Bottom 0.203: v317.81,146.15 318.21,146.56 352.35,146.56 v352.75,146.15 | v355.6,261.16 356.82,262.38 362.1,262.38 362.92,263.2 A08.D1
N$52  (via drill 0.61)
  Top 0.203: v305.61,185.17 304.39,183.95 304.39,179.07 303.58,178.26 B13.K1
  Bottom 0.203: v305.61,185.17 306.43,185.98 311.3,185.98 312.12,186.79 B12.F1
N$53  (via drill 0.61)
  Top 0.203: v275.13,189.23 275.54,188.82 275.54,159.97 275.13,159.56 275.13,159.16 274.73,158.75 274.73,148.18 275.95,146.96 275.95,122.58 274.73,121.36 C15.F1
  Bottom 0.203: v275.13,189.23 295.45,189.23 296.27,190.04 B13.E2
N$54
  Bottom 0.203: B14.J2 281.23,180.29 281.23,176.22 303.17,176.22 305.21,174.19 305.21,173.38 307.64,173.38 308.46,174.19 312.12,174.19 B12.L1
N$55  (via drill 0.61)
  Top 0.203: v311.3,220.12 v311.3,228.24
  Bottom 0.203: v311.3,220.12 310.9,220.52 295.45,220.52 294.23,219.3 A13.V2 | v311.3,228.24 315.37,228.24 A12.S1
N$56
  Top 0.203: A08.J1 363.32,251.41 363.32,256.69 A08.F1 | A08.H1 366.17,253.44 366.17,248.16 A08.K1
  Route2 0.203: B13.K2 297.49,178.26 297.49,181.91 346.66,231.09 346.66,231.5 347.07,231.9 347.88,231.9 358.85,242.88 360.07,242.88 362.92,245.72 364.54,245.72 366.17,247.34 A08.K1
  Bottom 0.203: A08.J1 364.13,250.6 364.54,250.19 367.79,250.19 368.2,249.78 368.2,248.16 366.98,248.16 A08.K1
N$57  (via drill 0.61)
  Top 0.203: B09.H2 347.47,184.76 347.47,190.04 B09.E2 | B09.F2 344.22,188.01 344.22,192.89 B09.D2 | v323.49,216.05 323.49,252.63 322.68,253.44 A11.H2 | v340.56,216.05 340.16,215.65 340.16,195.73 v340.56,195.33
  Route15 0.203: B09.H2 347.07,184.35 347.07,184.76 345.03,186.79 B09.F2
  Bottom 0.203: v340.56,216.05 v323.49,216.05 | v340.56,195.33 341.78,194.11 343.81,194.11 B09.D2
N$58
  Top 0.203: B12.M1 316.18,172.16 317.4,173.38 317.4,271.32 316.18,272.54 A12.A1
N$59  (via drill 0.61)
  Top 0.203: B09.N2 344.22,168.91 344.22,174.19 B09.L2 | B09.M2 347.47,172.16 347.47,177.04 B09.K2 | v324.31,243.28 323.9,242.88 323.9,216.86 325.12,215.65 325.12,203.45 v325.53,203.05
  Route2 0.203: v324.31,243.28 322.68,241.66 A11.M2 | B09.N2 345.03,168.5 345.03,168.91 347.07,170.94 B09.M2
  Route15 0.203: v325.53,203.05 347.07,181.51 347.07,178.26 B09.K2
N$60  (via drill 0.61)
  Top 0.203: B09.R1 350.32,162.41 350.32,167.69 B09.N1 | v352.35,221.74 353.16,220.93 353.16,216.46 353.57,216.05 353.57,204.67 352.75,203.86 352.75,175.82 353.57,175.01 353.57,172.16 B09.M1 353.57,170.94 353.57,165.66 B09.P1
  Route15 0.203: v352.35,221.74 351.94,221.74 325.93,247.75 325.93,250.19 A11.J1
  Bottom 0.203: B09.P1 353.57,165.66 351.54,167.69 351.13,167.69 B09.N1
N$61  (via drill 0.61)
  Top 0.203: B09.U2 347.07,152.65 345.03,154.69 345.03,155.09 B09.T2 345.03,155.91 345.03,156.31 345.85,157.12 | 345.85,157.12 347.07,158.34 B09.S2 | v330,263.6 330,216.86 331.22,215.65 331.22,202.23 330,201.02 330,190.04 330.4,189.64 330.4,164.03 v330.81,163.63 | 345.85,157.12 344.63,158.34 344.63,161.19 B09.R2
  Bottom 0.203: v330,263.6 325.93,263.6 A11.D1 | v330.81,163.63 331.22,163.22 343,163.22 343.81,162.41 B09.R2
N$62
  Top 0.203: A09.A1 353.57,272.54 351.54,270.51 351.54,270.1 A09.B1
  Route2 0.203: A11.N1 325.93,238.4 326.75,238.4 327.56,239.22 328.37,239.22 333.65,244.5 335.28,244.5 336.91,246.13 336.91,246.94 349.1,259.13 349.1,264.41 354.79,270.1 354.79,270.92 354.38,271.32 352.75,271.32 351.54,270.1 A09.B1
N$63  (via drill 0.61)
  Top 0.203: v257.25,138.02 256.85,138.43 v256.85,257.91 | v363.32,278.23 363.32,270.51 A08.B1
  Route15 0.203: v283.67,114.86 268.63,129.9 265.38,129.9 v257.25,138.02 | v256.85,257.91 271.07,272.14 v270.66,272.54
  Bottom 0.203: v283.67,114.86 284.07,114.86 286.11,112.83 287.73,112.83 290.98,116.08 307.64,116.08 308.86,117.3 C12.H2 | v270.66,272.54 274.73,276.61 276.35,276.61 277.57,277.83 307.24,277.83 308.05,277.01 317.81,277.01 319.02,278.23 334.87,278.23 335.69,279.04 354.79,279.04 355.6,278.23 v363.32,278.23
N$64
  Route2 0.203: B13.F2 293.83,188.01 293.83,188.42 295.45,190.04 295.45,191.26 299.11,194.92 300.33,194.92 301.14,195.73 301.14,198.98 304.39,202.23 304.39,203.45 305.61,204.67 305.61,210.36 312.93,217.68 313.33,217.68 334.87,239.22 334.87,239.62 335.28,240.03 336.91,240.03 358.04,261.16 359.26,261.16 362.92,264.82 364.54,264.82 366.17,266.45 A08.C1
N$65  (via drill 0.61)
  Top 0.203: v321.06,210.77 321.06,222.96 321.87,223.77 321.87,227.84 A11.S2
  Route2 0.203: v321.06,210.77 298.3,188.01 298.3,183.54 293.83,179.07 293.83,175.41 B13.L2
N$66
  Route2 0.203: A12.R1 313.33,232.31 313.33,234.34 315.37,236.37 317.4,236.37 318.62,237.59 A11.N2
N$67
  Top 0.203: C12.S2 310.08,92.51 310.9,93.32 310.9,109.17 309.68,110.39 C12.K2
N$68  (via drill 0.61)
  Top 0.203: v359.26,146.96 362.1,149.81 362.1,158.75 363.32,159.97 363.32,161.19 B08.R1
  Route2 0.203: B08.P1 366.57,164.44 366.17,164.44 364.13,162.41 B08.R1
  Bottom 0.203: v359.26,146.96 308.46,146.96 306.83,148.59 B12.V2
N$69  (via drill 0.61)
  Top 0.203: v377.55,110.79 377.55,117.3 374.7,120.14 374.7,144.12 374.29,144.53 374.29,167.28 v372.26,169.32
  Route2 0.203: B08.N1 364.13,168.5 364.13,168.91 366.17,170.94 B08.M1
  Route15 0.203: v377.55,110.79 395.83,92.51 397.87,92.51 C05.S2
  Bottom 0.203: v372.26,169.32 371.86,169.72 365.35,169.72 364.13,168.5 B08.N1
N$70
  Route2 0.203: C12.M2 308.86,104.7 308.05,104.7 307.64,104.29 306.83,104.29 306.02,105.1 310.49,109.58 310.9,109.58 320.65,119.33 320.65,119.74 326.34,125.42 327.56,125.42 330,127.86 330,129.49 336.09,135.59 336.09,138.02 354.38,156.31 354.38,157.12 355.19,157.94 355.19,159.56 356.82,161.19 B08.R2
N$71
  Bottom 0.203: B08.S2 359.66,159.16 358.85,159.97 336.5,159.97 335.69,160.78 323.09,160.78 320.24,163.63 308.86,163.63 306.43,166.06 304.39,166.06 303.99,166.47 299.92,166.47 299.52,166.06 298.7,166.06 298.3,166.47 298.3,167.69 299.52,167.69 B13.N1
N$72  (via drill 0.61)
  Top 0.203: v287.73,246.53 285.29,244.09 285.29,231.5 282.85,229.06 v282.85,194.92
  Route15 0.203: v299.92,247.34 299.92,250.19 A13.J1 | v282.85,194.92 282.85,194.11 302.36,174.6 304.39,174.6 308.86,170.13 309.68,170.13 310.49,169.32 310.49,168.5 313.33,165.66 315.37,165.66 B12.P1
  Bottom 0.203: v299.92,247.34 298.7,246.13 288.14,246.13 v287.73,246.53
N$73
  Route2 0.203: A14.V1 287.73,219.71 287.73,221.74 311.71,245.72 313.74,245.72 315.37,247.34 A12.K1
N$74  (via drill 0.61)
  Top 0.203: B08.F2 356.82,188.01 356.82,192.89 B08.D2 357.23,194.11 357.23,196.54 356.01,197.76 356.01,211.99 356.41,212.39 v356.41,217.68 | v301.55,216.86 301.55,229.87 300.33,231.09 A13.R1
  Route2 0.203: B08.E2 359.66,190.04 357.63,188.01 B08.F2
  Bottom 0.203: v301.55,216.86 327.56,216.86 327.96,216.46 337.31,216.46 338.53,217.68 347.47,217.68 347.88,217.27 356.01,217.27 v356.41,217.68
N$75
  Bottom 0.203: B14.P2 284.89,164.85 286.11,163.63 308.05,163.63 309.68,162 312.12,162 B12.R1
N$76  (via drill 0.61)
  Top 0.203: v299.11,91.69 295.45,95.35 295.45,122.17 295.05,122.58 295.05,139.24 294.64,139.65 v294.64,144.12 | v311.71,144.93 312.52,145.75 312.52,148.59 B12.V1
  Route2 0.203: v299.11,91.69 302.77,91.69 C13.S1
  Bottom 0.203: v294.64,144.12 295.45,144.93 v311.71,144.93
N$77  (via drill 0.61)
  Top 0.203: v276.76,258.32 274.73,256.29 274.73,244.09 274.32,243.69 274.32,207.52 273.1,206.3 273.1,197.36 v273.91,196.54
  Route15 0.203: v273.91,196.54 288.54,181.91 288.54,181.1 289.36,180.29 290.17,180.29 304.39,166.06 305.21,166.06 311.71,159.56 314.96,159.56 315.37,159.16 B12.S1
  Bottom 0.203: v276.76,258.32 288.14,258.32 289.76,259.94 A14.E1
N$78  (via drill 0.61)
  Top 0.203: v273.91,255.07 272.69,253.85 272.69,192.48 v273.51,191.67
  Route15 0.203: v273.51,191.67 273.91,191.67 275.95,189.64 275.95,188.82 299.92,164.85 300.74,164.85 302.36,163.22 303.17,163.22 304.39,162 304.39,160.78 306.02,159.16 307.24,159.16 312.12,154.28 313.74,154.28 315.37,152.65 B12.U1
  Bottom 0.203: v273.91,255.07 274.32,255.47 288.54,255.47 289.76,254.25 A14.H1
N$79
  Top 0.203: A14.J1 286.92,251.41 286.51,251.82 286.51,256.29 286.11,256.69 286.11,268.48 286.92,269.29 A14.B1
N$80  (via drill 0.61)
  Top 0.203: v258.88,95.35 258.88,123.8 258.47,124.21 258.47,208.33 257.66,209.14 257.66,227.43 263.35,233.12 v263.35,257.5 | v288.54,261.57 290.17,263.2 290.17,266.04 A14.C1
  Route2 0.203: v258.88,95.35 260.5,96.98 271.88,96.98 273.51,98.6 274.32,98.6 276.76,101.04 280.42,101.04 C14.N2
  Bottom 0.203: v263.35,257.5 267.41,261.57 v288.54,261.57
N$81  (via drill 0.61)
  Top 0.203: v249.94,136.4 250.34,136.8 250.34,202.64 254.81,207.11 v254.81,272.14
  Route15 0.203: v249.94,136.4 284.48,101.85 286.92,101.85 C14.N1
  Bottom 0.203: v254.81,272.14 255.22,271.73 279.6,271.73 282.45,274.57 288.54,274.57 289.76,273.36 A14.A1
N$82  (via drill 0.61)
  Top 0.203: v266.19,133.55 266.6,133.96 266.6,199.8 267,200.2 267,220.52 265.79,221.74 v265.79,264.41
  Route15 0.203: v266.19,133.55 281.63,118.11 283.67,118.11 C14.H2
  Bottom 0.203: v265.79,264.41 266.19,264.82 283.26,264.82 284.07,264.01 286.92,264.01 A14.D1
N$83  (via drill 0.61)
  Top 0.203: v295.86,238.4 295.45,238 295.45,229.87 296.27,229.06 A13.S2 | v285.29,149 285.29,112.42 284.48,111.61 C14.K2 | v276.76,226.62 277.17,226.21 277.17,207.11 275.54,205.49 275.54,204.67 275.95,204.27 275.95,159.56 275.54,159.16 v275.54,157.12
  Route2 0.203: v285.29,149 285.29,149.4 v292.61,156.72
  Bottom 0.203: v295.86,238.4 294.23,238.4 A13.N2 | B12.S2 308.86,158.34 307.64,157.12 293.01,157.12 v292.61,156.72 292.2,156.72 275.95,156.72 v275.54,157.12 | v276.76,226.62 290.58,226.62 291.8,227.84 295.86,227.84 296.27,228.24 A13.S2
N$84  (via drill 0.61)
  Top 0.203: v278.79,246.53 275.54,246.53 275.54,244.09 275.95,243.69 275.95,225.81 275.54,225.4 275.54,207.11 274.73,206.3 274.73,203.05 275.13,202.64 275.13,191.26 273.91,190.04 273.91,162 274.32,161.59 274.32,160.38 v273.91,159.97 | v306.43,159.97 306.43,156.31 B12.T2
  Route15 0.203: v278.79,246.53 279.6,245.72 287.73,245.72 288.54,244.91 293.01,244.91 A13.L2
  Bottom 0.203: v273.91,159.97 v306.43,159.97
N$85  (via drill 0.61)
  Top 0.203: v324.31,144.53 324.31,160.38 325.12,161.19 B11.R1
  Route2 0.203: v324.31,144.53 323.9,144.53 317.4,138.02 317.4,135.99 293.01,111.61 290.98,111.61 C14.K1
N$86
  Top 0.203: B11.N1 325.53,168.91 325.53,172.97 326.75,174.19 326.75,206.3 325.93,207.11 325.93,218.49 A11.V1
N$87  (via drill 0.61)
  Top 0.203: v300.33,196.14 292.61,203.86 292.61,214.43 295.05,216.86 295.05,219.71 294.23,220.52 294.23,224.99 A13.T2
  Route15 0.203: v300.33,196.14 300.74,196.14 311.71,185.17 311.71,184.76 312.12,184.35 312.93,184.35 318.21,179.07 319.02,179.07 324.71,173.38 325.53,173.38 327.15,171.75 327.15,170.54 v331.62,166.06
  Bottom 0.203: v331.62,166.06 331.22,165.66 329.18,165.66 B11.P1
N$88
  Route2 0.203: C14.D1 288.14,127.05 288.54,127.05 290.98,129.49 C14.C1
N$89  (via drill 0.61)
  Top 0.203: v286.51,164.44 286.11,164.03 286.11,156.31 282.45,152.65 282.45,122.58 281.23,121.36 C14.F2 | v321.87,200.61 321.06,201.42 321.06,209.55 321.87,210.36 321.87,219.3 321.46,219.71 321.46,222.15 A11.U2
  Route2 0.203: v286.51,164.44 286.92,164.44 303.58,181.1 303.58,181.91 317.4,195.73 317.4,196.14 v321.87,200.61
N$90  (via drill 0.61)
  Top 0.203: v269.44,122.58 269.85,122.99 269.85,184.76 268.63,185.98 268.63,197.76 269.04,198.17 269.04,233.12 v268.63,233.53
  Route15 0.203: v269.44,122.58 301.95,90.07 307.24,90.07 312.52,84.78 312.52,83.16 C12.V1 | v268.63,233.53 268.63,236.37 266.6,238.4 266.6,239.62 268.63,241.66 270.26,240.03 282.85,240.03 283.26,239.62 296.27,239.62 302.36,233.53 303.17,233.53 305.21,231.5 305.21,231.09 315.37,220.93 317.4,220.93 318.62,219.71 A11.V2
N$91  (via drill 0.61)
  Top 0.203: v295.45,140.06 295.45,122.99 295.86,122.58 295.86,118.92 296.67,118.11 C13.H2 | v281.23,140.46 281.23,148.59 B14.V2 | v308.86,141.68 308.86,146.56 308.05,147.37 308.05,163.22 309.27,164.44 B12.P2
  Bottom 0.203: v281.23,140.46 295.05,140.46 v295.45,140.06 295.86,140.06 307.24,140.06 v308.86,141.68
N$92
  Top 0.203: C13.L2 293.42,107.14 293.42,102.26 C13.N2
  Route2 0.203: C14.V2 281.23,83.16 281.23,87.22 291.8,97.79 291.8,99.42 293.42,101.04 C13.N2
N$93  (via drill 0.61)
  Top 0.203: v296.27,101.85 296.27,99.42 296.67,99.01 C13.P2
  Route2 0.203: v268.22,129.08 268.22,131.12 272.69,135.59 272.69,138.84 282.45,148.59 282.45,152.65 305.61,175.82 307.24,175.82 308.86,177.44 B12.K2
  Route15 0.203: v296.27,101.85 285.29,112.83 284.48,112.83 v268.22,129.08
N$94
  Top 0.203: B13.V2 294.23,149.81 295.45,151.03 295.45,160.78 296.67,162 296.67,164.44 B13.P2
N$95  (via drill 0.61)
  Top 0.203: v297.89,169.32 298.3,168.91 298.3,160.78 297.08,159.56 B13.S2 | v308.46,179.88 309.27,180.7 309.27,183.54 B12.H2
  Route2 0.203: v297.89,169.32 v308.46,179.88
N$96  (via drill 0.61)
  Top 0.203: v321.06,175.82 321.06,193.7 325.12,197.76 325.12,199.39 B11.B1
  Bottom 0.203: v321.06,175.82 307.64,175.82 306.83,175.01 B12.L2
N$97
  Route2 0.203: B12.J2 306.83,181.51 306.83,183.54 312.12,188.82 314.55,188.82 315.77,187.6 318.21,190.04 319.84,190.04 321.46,191.67 323.09,191.67 324.71,193.29 B11.D1
N$98  (via drill 0.61)
  Route2 0.203: v256.44,112.01 256.44,113.23 272.69,129.49 272.69,134.77 273.1,135.18 273.1,136.8 278.79,142.49 278.79,143.71 291.39,156.31 291.39,157.53 299.52,165.66 299.52,166.06 299.92,166.47 301.55,166.47 305.61,170.54 306.43,170.54 311.71,175.82 315.77,175.82 322.27,182.32 v322.68,182.32
  Route15 0.203: v322.68,182.32 323.49,182.32 324.71,181.1 B11.J1
  Bottom 0.203: v256.44,112.01 256.03,112.42 175.97,112.42 175.56,112.83 159.72,112.83 156.46,116.08 107.7,116.08 106.88,116.89 C28.H2
N$99
  Top 0.203: D11.K2 322.68,41.71 324.71,43.74 324.71,44.15 D11.J1
N$100  (via drill 0.61)
  Top 0.203: v318.62,189.23 319.02,189.64 319.02,192.89 B11.D2
  Bottom 0.203: v318.62,189.23 308.05,189.23 306.83,188.01 B12.F2
N$101  (via drill 0.61)
  Top 0.203: v265.79,90.88 264.57,92.1 v264.57,140.87
  Route2 0.203: v264.57,140.87 264.57,142.49 278.38,156.31 279.6,156.31 296.27,172.97 297.89,172.97 298.7,173.79 298.7,175.41 304.39,181.1 304.39,181.91 311.71,189.23 312.52,189.23 v313.74,190.45
  Bottom 0.203: v265.79,90.88 278.79,90.88 279.2,91.29 283.26,91.29 283.67,91.69 C14.S2 | v313.74,190.45 310.08,190.45 B12.E2
N$102
  Bottom 0.203: D11.F2 319.84,51.05 321.46,52.68 331.22,52.68 332.03,53.49 334.47,53.49 D10.E2
N$103  (via drill 0.61)
  Top 0.203: v316.99,44.96 317.81,45.77 317.81,55.12 319.02,56.34 D11.D2
  Bottom 0.203: v316.99,44.96 317.4,44.96 318.21,45.77 319.84,45.77 322.68,42.93 326.75,42.93 327.96,41.71 D11.K1
N$104
  Top 0.203: D11.F1 325.93,51.46 326.75,52.27 326.75,62.03 325.93,62.84 D11.B1
N$105
  Bottom 0.203: D11.C1 329.18,60 330.4,58.78 336.5,58.78 337.72,57.56 D10.D1
N$106  (via drill 0.61)
  Route15 0.203: v324.71,171.35 325.12,171.35 v334.47,162
  Bottom 0.203: v324.71,171.35 322.68,171.35 B11.M2 | v334.47,162 337.72,162 B10.R1
N$108  (via drill 0.61)
  Top 0.203: v235.31,10.82 237.74,10.82 237.74,68.53 235.31,70.97 235.31,190.45 238.56,193.7 v238.56,220.52
  Bottom 0.203: v235.31,10.82 235.71,10.41 297.49,10.41 299.52,12.45 D13.V1 | v238.56,220.52 238.96,220.93 255.63,220.93 260.1,225.4 274.32,225.4 277.17,228.24 283.67,228.24 A14.S2
N$109
  Bottom 0.203: AB07.BJ1 376.73,180.7 377.14,180.29 381.2,180.29 383.24,178.26 385.27,178.26 AB06.BK2
N$110
  Bottom 0.203: AB06.BJ1 389.74,180.7 391.36,179.07 397.05,179.07 397.87,178.26 AB05.BK2
N$111
  Bottom 0.203: AB04.BJ1 414.93,180.7 416.56,179.07 419.4,179.07 420.62,177.85 423.06,177.85 AB03.BK2
N$112
  Bottom 0.203: AB03.BJ1 427.53,180.7 429.16,179.07 435.25,179.07 436.07,178.26 AB02.BK2
N$113  (via drill 0.61)
  Top 0.203: v2.44,90.88 2.85,90.47 2.85,14.07 2.03,13.26 D36.V2
  Bottom 0.203: v2.44,90.88 2.44,93.32 52.43,93.32 54.86,90.88 64.21,90.88 64.62,91.29 67.06,91.29 68.28,90.07 78.84,90.07 80.47,91.69 C30.S2
N$114  (via drill 0.61)
  Top 0.203: v41.45,25.04 41.45,63.25 50.8,72.59 v50.8,78.69
  Route2 0.203: v50.8,78.69 79.25,107.14 79.25,108.76 80.87,110.39 C30.K2
  Bottom 0.203: v41.45,25.04 40.64,24.23 2.03,24.23 2.03,19.76 D36.T2
N$115  (via drill 0.61)
  Top 0.203: v5.28,112.83 6.1,112.01 6.1,107.54 9.35,104.29 9.35,84.78 11.79,82.35 11.79,76.66 12.19,76.25 12.19,72.59 9.75,70.16 9.75,37.64 6.5,34.39 6.5,24.64 4.88,23.01 D36.S2
  Bottom 0.203: v5.28,112.83 5.28,116.08 13.82,116.08 17.07,119.33 21.13,119.33 22.35,120.55 22.35,125.83 48.36,125.83 50.8,128.27 54.05,128.27 56.49,125.83 76.4,125.83 77.22,126.64 C30.D2
N$116  (via drill 0.61)
  Top 0.203: v315.77,175.01 314.55,176.22 314.55,201.83 315.37,202.64 B12.A1
  Route2 0.203: B12.A1 316.59,203.45 316.59,203.86 331.22,218.49 A10.V2
  Route15 0.203: v330.81,159.97 330.4,159.97 319.43,170.94 319.43,171.35 v315.77,175.01
  Bottom 0.203: v330.81,159.97 335.69,159.97 336.09,159.56 340.16,159.56 340.56,159.16 B10.S1
N$117  (via drill 0.61)
  Top 0.203: v6.5,65.28 6.5,36.42 6.1,36.02 6.1,29.92 5.28,29.11 D36.P2 | v86.56,81.13 93.47,88.04 93.47,91.29 C29.S2
  Bottom 0.203: v6.5,65.28 21.13,79.91 68.68,79.91 69.9,81.13 v86.56,81.13
N$118  (via drill 0.61)
  Top 0.203: v6.5,102.67 6.5,85.6 3.66,82.75 3.66,72.59 6.1,70.16 6.1,66.09 5.69,65.68 5.69,64.87 6.1,64.47 6.1,36.83 4.88,35.61 D36.M2
  Bottom 0.203: v6.5,102.67 6.5,112.83 57.3,112.83 60.15,109.98 91.44,109.98 92.25,110.79 93.07,110.79 C29.K2
N$119  (via drill 0.61)
  Route2 0.203: v27.64,48.62 27.64,49.43 31.29,53.09 31.29,58.78 31.7,59.18 31.7,71.37 47.55,87.22 48.77,87.22 86.56,125.02 88.19,125.02 89.81,126.64 C29.D2
  Bottom 0.203: v27.64,48.62 27.23,49.02 10.57,49.02 7.72,46.18 5.28,46.18 5.28,41.71 D36.K2
N$120  (via drill 0.61)
  Top 0.203: v101.19,58.78 97.13,58.78 97.13,62.84 D29.B1
  Bottom 0.203: D36.B1 8.53,64.06 8.94,64.47 13.41,64.47 13.82,64.87 95.5,64.87 96.32,64.06 D29.B1 | v101.19,58.78 120.29,58.78 121.51,57.56 D27.D1
N$121
  Bottom 0.203: D36.D1 8.53,57.56 9.75,58.78 59.74,58.78 60.15,58.37 88.59,58.37 89,58.78 95.1,58.78 96.32,57.56 D29.D1 97.54,56.74 98.35,55.93 123.14,55.93 124.77,54.3 D27.E1
N$122  (via drill 0.61)
  Top 0.203: v126.8,49.84 126.8,42.52 125.98,41.71 D27.K1
  Bottom 0.203: D36.E1 11.79,53.49 13.01,52.27 98.35,52.27 99.57,53.49 D29.E1 100.79,53.9 102.01,53.9 106.48,49.43 126.39,49.43 v126.8,49.84
N$123  (via drill 0.61)
  Top 0.203: v312.12,170.94 311.3,171.75 311.3,198.17 312.52,199.39 B12.B1
  Route15 0.203: v312.12,170.94 v333.65,149.4
  Bottom 0.203: v333.65,149.4 337.72,149.4 B10.V1
N$124  (via drill 0.61)
  Top 0.203: v98.75,40.08 98.75,46.18 99.57,46.99 D29.H1
  Bottom 0.203: 98.75,39.68 120.29,39.68 121.51,38.46 D27.L1 | 98.75,39.68 6.5,39.68 6.5,44.96 7.32,45.77 8.94,45.77 10.57,47.4 D36.H1 | 98.75,39.68 v98.75,40.08
N$125
  Route15 0.203: D27.R1 121.51,25.45 117.86,25.45 100.79,42.52 99.16,42.52 97.54,44.15 D29.J1
  Bottom 0.203: D36.J1 8.53,44.15 9.75,42.93 95.1,42.93 96.32,44.15 D29.J1
N$126
  Bottom 0.203: 95.5,39.27 9.35,39.27 8.53,38.46 D36.L1 | 95.5,39.27 96.32,38.46 D29.L1 | 95.5,39.27 112.98,39.27 115.42,36.83 117.04,36.83 117.04,22.61 118.67,20.98 123.95,20.98 124.77,21.79 D27.S1
N$127
  Route2 0.203: D27.H2 118.26,47.4 114.61,47.4 104.04,36.83 102.41,36.83 100.79,35.2 D29.M1
  Bottom 0.203: D36.M1 11.79,34.8 13.41,33.17 98.35,33.17 99.57,34.39 D29.M1
N$128
  Route2 0.203: D27.J2 115.82,43.74 115.82,42.11 104.04,30.33 102.41,30.33 100.79,28.7 D29.P1
  Bottom 0.203: D36.P1 11.79,28.7 13.41,30.33 98.35,30.33 99.57,29.11 D29.P1
N$129  (via drill 0.61)
  Top 0.203: v112.17,25.86 114.2,27.89 114.2,29.92 115.42,31.14 D27.N2
  Bottom 0.203: 98.75,23.42 99.57,22.61 D29.S1 | 98.75,23.42 98.35,23.83 13.01,23.83 11.79,22.61 D36.S1 | v112.17,25.86 109.73,23.42 98.75,23.42
N$130
  Route15 0.203: D27.P2 118.67,29.11 118.67,33.17 117.86,33.98 117.86,38.05 113.39,42.52 107.7,42.52 95.1,55.12 92.66,55.12 91.03,56.74 D29.D2
  Bottom 0.203: D36.D2 2.03,56.74 3.25,55.52 88.59,55.52 89.81,56.74 D29.D2
N$131  (via drill 0.61)
  Top 0.203: v91.44,10.41 91.85,10.82 91.85,52.27 93.07,53.49 D29.E2
  Bottom 0.203: D36.E2 5.28,54.3 6.1,55.12 92.25,55.12 93.07,54.3 D29.E2 | v91.44,10.41 118.67,10.41 118.67,15.29 D27.U2
N$132  (via drill 0.61)
  Top 0.203: v101.19,11.23 95.5,16.92 95.5,45.36 93.88,46.99 D29.H2
  Bottom 0.203: D36.H2 5.28,48.21 6.5,49.43 52.83,49.43 53.24,49.02 63.4,49.02 63.8,48.62 67.06,48.62 67.46,49.02 91.85,49.02 93.07,47.8 D29.H2 | v101.19,11.23 114.61,11.23 115.42,12.04 D27.V2
N$133
  Bottom 0.203: D35.B1 21.13,62.84 21.95,62.03 82.91,62.03 83.72,62.84 D30.B1 84.94,63.25 86.16,63.25 90.22,59.18 96.72,59.18 97.94,57.96 101.6,57.96 102.01,58.37 108.1,58.37 108.92,57.56 D28.D1
N$134
  Bottom 0.203: D35.D1 21.13,56.74 21.95,55.93 82.91,55.93 83.72,56.74 D30.D1 84.94,57.15 88.19,57.15 89.41,58.37 91.44,58.37 94.69,55.12 111.35,55.12 112.17,54.3 D28.E1
N$135
  Route15 0.203: D28.K1 112.17,41.71 107.7,41.71 103.63,45.77 98.35,45.77 97.94,46.18 97.13,46.18 91.03,52.27 89,52.27 87.78,53.49 D30.E1
  Bottom 0.203: D35.E1 24.38,53.49 25.2,52.68 85.34,52.68 86.56,53.9 D30.E1
N$136
  Route15 0.203: D28.L1 108.92,38.46 105.66,38.46 101.19,42.93 100.38,42.93 97.54,45.77 89,45.77 87.78,46.99 D30.H1
  Bottom 0.203: D35.H1 24.38,47.4 25.6,46.18 85.34,46.18 86.56,47.4 D30.H1
N$137  (via drill 0.61)
  Route15 0.203: v42.27,26.26 24.38,44.15 21.13,44.15 D35.J1 | D30.J1 84.94,44.15 87.38,44.15 103.23,28.3 104.44,28.3 105.66,27.08 107.7,27.08 108.92,25.86 D28.R1
  Bottom 0.203: v42.27,26.26 44.3,24.23 108.1,24.23 108.92,25.04 D28.R1
N$138
  Bottom 0.203: 82.91,36.83 21.95,36.83 21.13,37.64 D35.L1 | 82.91,36.83 83.72,37.64 D30.L1 | 82.91,36.83 114.61,36.83 114.61,24.64 112.98,23.01 D28.S1
N$139
  Route2 0.203: D28.H2 105.66,47.4 102.01,47.4 91.44,36.83 89,36.83 87.78,35.61 D30.M1
  Bottom 0.203: D35.M1 24.38,35.2 25.6,36.42 85.34,36.42 86.56,35.2 D30.M1
N$140
  Route2 0.203: D28.J2 102.82,43.74 102.82,42.11 91.03,30.33 89,30.33 87.78,29.11 D30.P1
  Bottom 0.203: D35.P1 24.38,28.3 25.6,27.08 84.12,27.08 85.34,28.3 86.56,28.3 D30.P1
N$141  (via drill 0.61)
  Top 0.203: v88.19,27.08 87.38,26.26 87.38,23.01 D30.S1
  Bottom 0.203: D35.S1 24.38,21.79 25.2,20.98 85.34,20.98 86.56,22.2 D30.S1 | v88.19,27.08 102.82,27.08 102.82,31.14 D28.N2
N$142  (via drill 0.61)
  Route15 0.203: v60.55,59.18 61.37,59.18 64.62,55.93 76.4,55.93 | 76.4,55.93 77.22,56.74 D30.D2 | 76.4,55.93 103.63,28.7 105.66,28.7 D28.P2
  Bottom 0.203: v60.55,59.18 6.5,59.18 6.5,56.34 6.91,55.93 13.01,55.93 13.82,56.74 D35.D2
N$143  (via drill 0.61)
  Top 0.203: v19.51,61.21 19.51,56.34 17.88,54.71 D35.E2 | v79.25,59.59 80.87,57.96 80.87,54.71 D30.E2 81.28,53.49 82.5,52.27 82.5,17.32 v85.34,14.48
  Bottom 0.203: v19.51,61.21 19.91,61.62 77.22,61.62 v79.25,59.59 | v85.34,14.48 100.79,14.48 101.19,14.88 104.85,14.88 105.66,15.7 D28.U2
N$144  (via drill 0.61)
  Top 0.203: v48.77,43.74 50.8,41.71 50.8,12.45 52.02,11.23 v80.47,11.23 82.09,11.23 82.09,46.18 81.28,46.99 D30.H2
  Route15 0.203: v80.47,11.23 89,2.69 98.75,12.45 102.41,12.45 D28.V2
  Bottom 0.203: v48.77,43.74 46.74,45.77 19.1,45.77 17.88,46.99 D35.H2
N$145  (via drill 0.61)
  Top 0.203: v117.86,90.07 117.86,92.91 123.55,98.6 123.55,125.02 122.33,126.24 C27.D1
  Route2 0.203: v117.86,90.07 117.86,88.85 107.29,78.28 106.88,78.28 105.26,76.66 105.26,67.72 82.91,45.36 82.91,42.93 81.69,41.71 D30.K2
  Bottom 0.203: D35.K2 17.88,41.71 18.69,42.52 79.65,42.52 80.47,41.71 D30.K2
N$146
  Route2 0.203: C27.E1 124.77,123.39 124.77,118.92 123.95,118.11 123.95,112.42 89.41,77.88 89.41,77.06 89,76.66 89,70.56 63.8,45.36 63.8,43.33 75.59,31.55 77.22,33.17 79.25,33.17 80.47,34.39 D30.M2
  Bottom 0.203: D35.M2 17.88,34.39 18.69,33.58 79.65,33.58 80.47,34.39 D30.M2
N$147  (via drill 0.61)
  Top 0.203: v80.06,57.56 79.65,57.15 79.65,29.92 80.47,29.11 D30.P2
  Route2 0.203: v80.06,57.56 89.41,66.9 89.41,76.25 89.81,76.66 89.81,77.47 123.14,110.79 124.77,110.79 C27.K1
  Bottom 0.203: D35.P2 17.88,29.11 18.69,29.92 79.65,29.92 80.47,29.11 D30.P2
N$148  (via drill 0.61)
  Top 0.203: v116.64,66.5 117.04,66.9 117.04,92.91 120.29,96.16 120.29,105.51 121.92,107.14 C27.L1
  Route2 0.203: v116.64,66.5 86.16,36.02 86.16,29.11 82.91,25.86 82.91,24.64 81.28,23.01 D30.S2
  Bottom 0.203: D35.S2 17.88,22.61 18.69,23.42 79.65,23.42 80.47,22.61 D30.S2
N$149  (via drill 0.61)
  Top 0.203: v107.7,20.17 107.7,25.45 117.04,34.8 117.04,43.33 120.29,46.58 120.29,92.91 121.92,94.54 C27.R1
  Bottom 0.203: D35.T2 15.04,18.95 16.26,17.73 76.4,17.73 77.22,18.54 D30.T2 78.44,19.36 79.65,20.57 107.29,20.57 v107.7,20.17
N$150
  Route2 0.203: C27.S1 125.17,91.29 125.17,87.63 121.11,83.57 121.11,79.5 109.32,67.72 109.32,65.28 108.1,64.06 108.1,58.78 85.75,36.42 85.75,29.52 79.65,23.42 79.65,14.88 78.03,13.26 D30.V2
  Bottom 0.203: D35.V2 15.04,12.85 16.26,14.07 76.4,14.07 77.22,13.26 D30.V2
N$151  (via drill 0.61)
  Top 0.203: 92.25,42.52 93.07,41.71 D29.K2 | 92.25,42.52 92.25,50.65 95.5,53.9 95.5,64.47 v100.79,69.75 | v34.54,68.94 33.73,68.12 33.73,64.06 D34.B1 | v107.29,5.13 92.25,5.13 92.25,42.52
  Route2 0.203: v246.28,6.76 293.01,53.49 296.27,53.49 D13.E2
  Bottom 0.203: v100.79,69.75 99.97,68.94 v34.54,68.94 | v246.28,6.76 245.87,7.16 240.18,7.16 238.15,5.13 v107.29,5.13
N$152  (via drill 0.61)
  Top 0.203: v298.3,39.27 298.3,45.77 297.08,46.99 D13.H2 | v235.31,40.08 234.49,39.27 v234.49,6.76 | v105.66,6.76 95.1,6.76 95.1,33.58 94.28,34.39 D29.M2
  Route15 0.203: v50.8,56.74 68.28,39.27 74.78,45.77 78.44,45.77 82.09,42.11 83.72,42.11 90.63,35.2 93.07,35.2 D29.M2
  Bottom 0.203: v50.8,56.74 49.17,58.37 38.61,58.37 37.39,57.15 34.14,57.15 D34.D1 | v298.3,39.27 297.89,39.68 235.71,39.68 v235.31,40.08 | v234.49,6.76 v105.66,6.76
N$153  (via drill 0.61)
  Route2 0.203: v286.11,9.2 295.45,18.54 295.45,35.61 296.67,36.83 296.67,40.49 D13.K2
  Route15 0.203: D29.P2 93.88,27.89 93.88,24.23 95.1,23.01 95.1,21.39 93.47,19.76 93.47,19.36 v83.72,9.6 81.28,12.04 80.47,12.04 78.44,14.07 67.87,14.07 35.36,46.58 35.36,52.68 36.17,53.49 D34.E1
  Bottom 0.203: v286.11,9.2 285.7,8.79 243.84,8.79 243.03,9.6 180.85,9.6 180.03,8.79 84.53,8.79 v83.72,9.6
N$154  (via drill 0.61)
  Route2 0.203: v222.3,15.29 222.71,15.7 227.18,11.23 230.84,11.23 232.05,12.45 241.4,3.1 243.84,3.1 264.97,24.23 269.04,24.23 287.73,42.93 294.23,42.93 295.86,44.55 298.3,42.11 298.3,40.49 297.08,39.27 297.08,35.61 D13.M2
  Route15 0.203: D29.S2 93.07,21.79 93.07,19.76 89.41,16.1 88.19,17.32 69.09,17.32 40.64,45.77 38.2,45.77 36.98,46.99 D34.H1
  Bottom 0.203: v222.3,15.29 221.49,14.48 123.14,14.48 116.64,20.98 95.1,20.98 94.28,21.79 D29.S2
N$155  (via drill 0.61)
  Top 0.203: v83.72,90.47 85.34,92.1 85.34,123.8 85.75,124.21 85.75,273.76 83.31,276.2 62.18,276.2 62.18,273.76 A32.A1
  Route2 0.203: v83.72,90.47 83.31,90.47 37.39,44.55 34.14,44.55 D34.J1
N$156  (via drill 0.61)
  Top 0.203: v39.42,172.57 35.36,168.5 35.36,151.44 35.76,151.03 35.76,126.64 35.36,126.24 35.36,40.49 33.73,38.86 D34.L1 | v62.59,199.39 63.4,200.2 63.4,218.9 56.9,225.4 56.9,244.5 53.65,247.75 53.65,261.57 52.43,262.79 A32.D2
  Route2 0.203: v39.42,172.57 39.83,172.57 50.39,183.13 50.39,187.2 v62.59,199.39
N$157  (via drill 0.61)
  Top 0.203: D11.R1 325.93,25.86 327.96,27.89 327.96,28.3 D11.P1 | v67.46,144.12 67.87,144.53 v67.87,196.54
  Route15 0.203: v274.32,28.3 260.1,42.52 260.1,44.15 v160.12,144.12
  Bottom 0.203: v67.87,196.54 67.87,200.2 59.33,200.2 B32.B1 | C36.B1 8.13,133.96 8.13,144.12 v67.46,144.12 67.87,144.12 100.79,144.12 101.19,143.71 159.72,143.71 v160.12,144.12 | v274.32,28.3 275.95,26.67 323.49,26.67 324.71,25.45 D11.R1
N$158  (via drill 0.61)
  Top 0.203: D11.R2 319.84,25.45 321.87,27.48 321.87,27.89 D11.P2 | v54.86,128.68 57.3,128.68 57.3,152.25 60.15,155.09 60.15,191.67 58.93,192.89 B32.D1
  Route15 0.203: v138.99,192.48 193.45,138.02 195.88,138.02 254,79.91 262.13,79.91 263.35,78.69 264.16,78.69 267.82,75.03 267.82,73.41 315.37,25.86 318.62,25.86 D11.R2
  Bottom 0.203: v54.86,128.68 9.75,128.68 8.53,127.46 C36.D1 | v138.99,192.48 106.07,192.48 103.63,194.92 100.79,194.92 99.97,194.11 59.33,194.11 B32.D1
N$159  (via drill 0.61)
  Top 0.203: v76.4,78.28 82.09,83.97 82.09,146.15 77.62,150.62 v77.62,256.69
  Route2 0.203: v76.4,78.28 36.98,38.86 36.98,35.61 D34.M1
  Bottom 0.203: v77.62,256.69 59.33,256.69 A32.F1
N$160  (via drill 0.61)
  Top 0.203: D11.U2 321.46,16.1 319.43,18.14 319.43,18.54 D11.T2 | v15.04,141.28 15.04,139.65 13.01,137.62 13.01,126.24 11.38,124.61 C36.E1 10.57,123.39 9.75,122.58 9.75,85.19 12.19,82.75 12.19,77.06 12.6,76.66 12.6,57.15 15.44,54.3 15.44,13.26 v21.13,7.57
  Route2 0.203: v15.04,141.28 16.26,141.28 26.01,151.03 26.82,151.03 32.51,156.72 36.17,156.72 37.8,158.34 37.8,164.44 60.15,186.79 60.15,188.82 61.37,190.04 B32.E1 | v236.53,6.76 240.59,2.69 244.25,2.69 244.65,3.1 246.28,3.1 249.12,5.94 259.69,5.94 260.1,6.35 286.11,6.35 290.98,11.23 294.23,11.23 300.74,17.73 313.33,17.73 314.15,18.54 318.62,18.54 D11.T2
  Bottom 0.203: v236.53,6.76 235.71,7.57 v21.13,7.57
N$161  (via drill 0.61)
  Top 0.203: v11.79,90.07 15.85,94.13 v15.85,203.45
  Route2 0.203: v15.85,203.45 24.79,212.39 24.79,214.83 37.8,227.84 37.8,229.46 39.42,231.09 A33.R2
  Bottom 0.203: v11.79,90.07 2.85,90.07 2.03,89.26 C36.T2
N$162  (via drill 0.61)
  Top 0.203: v77.22,65.68 82.91,71.37 82.91,122.17 85.34,124.61 85.34,245.72 v84.94,246.13
  Route2 0.203: v77.22,65.68 40.64,29.11 36.98,29.11 D34.P1
  Bottom 0.203: v84.94,246.13 57.3,246.13 56.08,247.34 A32.K2
N$163
  Top 0.203: A33.U2 42.27,222.56 42.27,222.96 40.23,224.99 A33.T2 40.23,225.81 40.23,226.21 42.27,228.24 A33.S2
N$164  (via drill 0.61)
  Top 0.203: v268.22,68.12 269.04,68.94 269.04,79.91 267,81.94 267,92.1 269.44,94.54 269.44,108.76 267,111.2 267,117.3 270.26,120.55 270.26,144.12 v270.66,144.53 | v100.38,143.31 96.72,146.96 v96.72,177.44 | v9.35,131.12 9.35,115.67 8.53,114.86 C36.J1
  Bottom 0.203: v268.22,68.12 301.95,68.12 302.77,67.31 D13.A1 | v270.66,144.53 270.26,144.12 253.19,144.12 252.37,143.31 v100.38,143.31 99.97,143.31 99.16,142.49 39.01,142.49 28.45,131.93 10.16,131.93 v9.35,131.12 | v96.72,177.44 93.47,180.7 59.33,180.7 B32.J1
N$165  (via drill 0.61)
  Top 0.203: v68.68,240.03 v68.68,149.81
  Route2 0.203: v68.68,149.81 56.9,138.02 56.9,135.59 25.2,103.89 25.2,40.08 23.57,38.46 36.17,25.86 36.17,23.01 D34.S1
  Bottom 0.203: v68.68,240.03 67.87,240.84 62.59,240.84 A32.M1
N$166  (via drill 0.61)
  Top 0.203: 86.16,10.41 89.81,10.41 89.81,12.45 D29.V2 | 86.16,10.41 33.73,10.41 28.85,15.29 28.85,20.98 29.67,21.79 D34.S2 | v103.63,118.11 101.19,118.11 101.19,71.37 95.1,65.28 88.59,65.28 88.59,67.31 87.78,68.12 86.16,68.12 86.16,10.41
  Bottom 0.203: v103.63,118.11 104.44,118.92 117.04,118.92 118.26,117.7 C27.H2
N$167  (via drill 0.61)
  Top 0.203: v62.99,195.33 63.4,194.92 63.4,185.98 62.18,184.76 B32.H1
  Route2 0.203: C36.H1 11.38,118.11 11.38,119.74 23.16,131.52 23.98,131.52 50.39,157.94 50.39,164.03 56.9,170.54 56.9,175.41 60.15,178.66 60.15,182.32 61.37,183.54 B32.H1
  Route15 0.203: v293.01,178.66 292.61,178.66 291.39,179.88 291.39,180.7 v273.91,198.17
  Bottom 0.203: v293.01,178.66 293.42,179.07 310.49,179.07 312.12,180.7 B12.J1 | v273.91,198.17 203.61,198.17 200.35,201.42 188.16,201.42 187.76,201.02 186.94,201.02 186.54,201.42 136.55,201.42 135.74,202.23 132.89,202.23 132.08,201.42 87.38,201.42 81.28,195.33 v62.99,195.33
N$168  (via drill 0.61)
  Top 0.203: v59.33,179.07 58.93,178.66 58.93,175.41 B32.L1
  Route2 0.203: C36.L1 8.13,108.76 8.13,111.61 41.05,144.53 41.05,147.78 50.8,157.53 50.8,163.63 57.3,170.13 57.3,173.38 58.12,174.19 B32.L1
  Route15 0.203: v149.15,183.54 194.26,138.43 196.29,138.43 253.19,81.53 262.13,81.53 262.53,81.13 263.35,81.13 276.35,68.12 278.38,68.12 299.52,46.99 299.52,44.96 D13.J1
  Bottom 0.203: v149.15,183.54 147.12,185.57 136.96,185.57 134.52,183.13 132.89,183.13 132.08,182.32 125.58,182.32 122.73,179.48 116.23,179.48 113.39,176.63 93.47,176.63 91.03,179.07 v59.33,179.07
N$169  (via drill 0.61)
  Top 0.203: v277.17,57.96 277.17,58.37 281.63,58.37 282.45,57.56 282.45,56.74 279.6,53.9 279.6,30.33 290.58,30.33 291.8,29.11 296.27,29.11 D13.P2 | v222.3,57.96 221.89,58.37 221.89,63.25 215.39,69.75 215.39,80.31 208.08,87.63 203.2,87.63 203.2,92.51 v197.92,97.79 | v95.91,170.94 95.5,170.54 v95.5,106.73
  Bottom 0.203: v277.17,57.96 276.76,58.37 222.71,58.37 v222.3,57.96 | v197.92,97.79 188.98,106.73 176.38,106.73 173.94,109.17 156.87,109.17 154.43,106.73 150.77,106.73 147.52,109.98 130.05,109.98 129.64,110.39 126.8,110.39 123.14,106.73 v95.5,106.73 13.41,106.73 11.79,105.1 C36.M1 | v95.91,170.94 62.99,170.94 62.59,171.35 B32.M1
N$170  (via drill 0.61)
  Top 0.203: v25.6,188.42 25.6,181.51 22.35,178.26 22.35,177.04 25.2,174.19 25.2,149 27.64,146.56 27.64,137.21 27.23,136.8 27.23,109.98 25.6,108.36 25.6,59.18 26.82,57.96 D34.D2
  Route2 0.203: v25.6,188.42 25.6,188.82 41.86,205.08 43.08,205.08 47.14,209.14 47.14,218.08 47.55,218.49 47.55,224.99 50.39,227.84 50.39,229.46 52.02,231.09 A32.R2
N$171  (via drill 0.61)
  Route2 0.203: C36.P1 11.38,99.01 11.38,99.82 11.79,100.23 11.79,101.85 13.01,103.07 13.01,109.98 27.64,124.61 27.64,126.24 28.85,127.46 28.85,129.08 55.68,155.91 55.68,156.72 60.15,161.19 60.15,162.81 61.77,164.44 B32.P1
  Route15 0.203: v141.83,164.85 143.46,163.22 144.68,163.22 145.09,162.81 145.09,162.41 169.47,138.02 170.69,138.02 227.99,80.72 228.4,80.72 279.2,29.92 284.89,29.92 292.2,22.61 296.27,22.61 D13.S2
  Bottom 0.203: v141.83,164.85 140.21,166.47 63.8,166.47 62.59,165.25 B32.P1
N$172  (via drill 0.61)
  Top 0.203: v83.31,123.8 82.91,124.21 82.91,234.75 83.31,235.15 v83.31,274.17
  Route2 0.203: v83.31,123.8 31.29,71.78 31.29,59.59 30.48,58.78 30.48,54.71 D34.E2
  Bottom 0.203: v83.31,274.17 82.91,274.57 51.21,274.57 49.99,273.36 A33.A1
N$173  (via drill 0.61)
  Top 0.203: v296.67,1.88 296.67,15.29 D13.U2 | v110.13,2.29 21.95,2.29 21.95,68.12 12.6,77.47 12.6,88.04 10.97,89.66 10.97,91.29 C36.S1
  Route2 0.203: B32.S1 62.18,157.94 62.18,154.28 66.65,149.81 13.01,96.16 13.01,93.73 11.79,92.51 C36.S1
  Bottom 0.203: v296.67,1.88 296.27,1.47 277.57,1.47 276.76,2.29 275.95,2.29 275.13,1.47 133.3,1.47 132.08,2.69 125.58,2.69 125.17,2.29 v110.13,2.29
N$174  (via drill 0.61)
  Top 0.203: v49.99,192.89 50.39,193.29 50.39,203.86 49.58,204.67 49.58,220.12 47.95,221.74 47.95,238 47.14,238.81 47.14,240.44 41.45,246.13 41.45,257.5 35.36,263.6 35.36,271.73 36.17,272.54 A34.A1
  Route2 0.203: v27.64,166.06 28.04,166.06 34.54,172.57 34.54,173.79 50.39,189.64 50.39,191.26 52.02,192.89 B32.D2
  Bottom 0.203: v27.64,166.06 22.35,160.78 3.25,160.78 3.25,132.74 2.44,131.93 2.03,131.93 2.03,127.46 C36.D2 | v49.99,192.89 50.39,193.29 51.61,193.29 B32.D2
N$175  (via drill 0.61)
  Top 0.203: v31.29,107.54 31.29,49.02 30.48,48.21 D34.H2 | v8.94,109.98 6.5,112.42 6.5,152.25 9.75,155.5 9.75,205.89 12.6,208.74 12.6,237.59 v12.19,238
  Route2 0.203: v12.19,238 35.76,261.57 37.39,261.57 39.01,263.2 A33.D2
  Bottom 0.203: v31.29,107.54 28.85,109.98 v8.94,109.98
N$176  (via drill 0.61)
  Top 0.203: v52.02,143.31 53.65,144.93 53.65,188.82 | 53.65,188.82 54.86,190.04 B32.E2 | v50.39,207.52 50.39,229.46 49.58,230.28 49.58,231.09 50.39,231.9 50.39,255.07 41.86,263.6 41.86,266.04 36.98,266.04 A34.C1 | v52.83,205.89 53.65,205.08 53.65,188.82
  Route2 0.203: v50.39,207.52 52.43,205.49 v52.83,205.89
  Bottom 0.203: v52.02,143.31 30.48,143.31 29.67,142.49 13.01,142.49 13.01,136.4 8.53,131.93 3.25,131.93 3.25,129.49 4.06,128.68 4.47,128.68 4.47,124.61 C36.E2
N$177  (via drill 0.61)
  Top 0.203: v6.1,162.81 6.1,118.92 5.28,118.11 C36.H2 | v54.46,175.41 54.05,175.82 54.05,182.32 55.27,183.54 B32.H2 | v28.85,206.3 28.85,262.79 32.92,262.79 A34.D1
  Route15 0.203: v28.85,206.3 28.85,207.92 30.07,209.14 31.29,207.92 31.29,206.3 51.61,185.98 53.24,185.98 54.86,184.35 B32.H2
  Bottom 0.203: v6.1,162.81 6.1,175.82 54.05,175.82 v54.46,175.41
N$178  (via drill 0.61)
  Top 0.203: v54.46,96.98 54.05,97.38 54.05,163.22 55.27,164.44 B32.P2
  Bottom 0.203: C36.P2 5.28,99.01 6.1,99.82 44.3,99.82 47.14,96.98 v54.46,96.98 117.04,96.98 118.26,98.2 C27.P2
N$179
  Route2 0.203: B32.S2 55.27,157.94 55.27,156.31 27.23,128.27 27.23,125.02 12.6,110.39 12.6,103.48 11.38,102.26 11.38,100.63 6.5,95.76 6.5,93.73 5.28,92.51 C36.S2
  Bottom 0.203: C36.S2 5.28,91.69 6.1,90.88 35.76,90.88 39.01,87.63 116.64,87.63 118.26,86 C27.U2
N$180  (via drill 0.61)
  Top 0.203: v29.26,168.5 28.85,168.1 28.85,127.46 28.45,127.05 28.45,33.58 30.89,33.58 31.29,33.98 31.29,39.68 30.48,40.49 D34.K2
  Route2 0.203: v29.26,168.5 27.64,166.88 27.23,166.88 25.2,164.85 25.2,164.44 24.38,163.63 22.35,163.63 20.73,165.25 19.51,165.25 6.91,177.85 9.35,180.29 9.35,206.3 12.19,209.14 12.19,221.34 44.3,253.44 44.3,255.47 45.52,256.69 A33.F1
N$181  (via drill 0.61)
  Top 0.203: v34.14,87.63 v34.14,146.96
  Bottom 0.203: 34.14,83.97 114.61,83.97 115.42,83.16 C27.V2 | 34.14,83.97 2.85,83.97 2.03,83.16 C36.V2 | v34.14,146.96 49.58,146.96 51.61,149 B32.V2 | 34.14,83.97 v34.14,87.63
N$182  (via drill 0.61)
  Top 0.203: v13.82,139.65 14.22,140.06 14.22,146.96 15.44,148.18 15.44,197.76 v15.04,198.17 | v39.01,204.27 38.61,204.67 38.61,212.8 39.01,213.21 39.01,217.68 38.2,218.49 38.2,247.75 34.95,251 34.95,255.47 33.73,256.69 A34.F1
  Bottom 0.203: v13.82,139.65 20.32,139.65 20.32,133.96 C35.B1 | v15.04,198.17 18.29,201.42 39.01,201.42 | 39.01,201.42 44.7,201.42 45.52,200.61 B33.B1 | v39.01,204.27 39.01,201.42
N$183  (via drill 0.61)
  Top 0.203: v28.04,127.86 28.45,128.27 v28.45,178.26 | v37.39,205.89 37.39,217.68 37.8,218.08 37.8,229.06 35.36,231.5 35.36,248.56 33.73,250.19 A34.J1 | v42.27,205.89 44.7,203.45 44.7,194.92 45.52,194.11 B33.D1
  Route2 0.203: v28.45,178.26 41.86,191.67 43.89,191.67 45.52,193.29 B33.D1 | v37.39,205.89 v42.27,205.89
  Bottom 0.203: v28.04,127.86 21.54,127.86 21.13,127.46 C35.D1
N$184  (via drill 0.61)
  Top 0.203: v33.33,131.12 33.33,120.55 32.11,119.33 32.11,30.73 30.48,29.11 D34.P2 | v68.68,138.84 71.12,141.28 v71.12,239.22
  Bottom 0.203: v33.33,131.12 41.05,138.84 v68.68,138.84 | v71.12,239.22 60.55,239.22 59.74,240.03 51.21,240.03 49.99,241.25 A33.M1
N$185  (via drill 0.61)
  Top 0.203: v49.17,125.42 50.8,127.05 50.8,188.82 | 50.8,188.82 49.58,190.04 B33.E1 | v50.39,230.68 50.8,230.28 50.8,215.24 51.21,214.83 51.21,201.83 50.8,201.42 50.8,188.82
  Route15 0.203: v50.39,230.68 36.58,244.5 34.14,244.5 A34.L1
  Bottom 0.203: v49.17,125.42 25.6,125.42 24.38,124.21 C35.E1
N$186  (via drill 0.61)
  Top 0.203: v31.29,182.73 31.7,182.32 31.7,129.49 28.85,126.64 28.85,36.83 30.07,35.61 D34.M2 | v52.43,203.86 52.02,204.27 52.02,216.46 53.65,218.08 53.65,244.91 v52.02,246.53
  Route2 0.203: v52.43,203.86 v31.29,182.73
  Bottom 0.203: v52.02,246.53 51.61,246.13 44.7,246.13 43.48,247.34 A33.K2
N$187  (via drill 0.61)
  Top 0.203: v21.54,163.22 21.95,162.81 21.95,119.74 23.57,118.11 C35.H1 | v45.52,223.37 47.95,220.93 47.95,185.57 48.77,184.76 B33.H1
  Route2 0.203: v21.54,163.22 26.01,163.22 45.11,182.32 47.55,182.32 48.77,183.54 B33.H1
  Route15 0.203: v45.52,223.37 33.73,235.15 33.73,237.59 A34.N1
N$188  (via drill 0.61)
  Top 0.203: v46.33,116.08 47.55,117.3 47.55,134.77 45.11,137.21 45.11,148.18 44.7,148.59 44.7,179.07 45.92,180.29 B33.J1 | v36.98,192.89 35.36,194.51 35.36,229.46 33.73,231.09 A34.R1
  Route15 0.203: v36.98,192.89 36.98,192.07 44.3,184.76 44.3,182.73 45.52,181.51 B33.J1
  Bottom 0.203: v46.33,116.08 22.35,116.08 21.13,114.86 C35.J1
N$189  (via drill 0.61)
  Top 0.203: v47.14,136.4 47.55,136.8 47.55,173.38 | 47.55,173.38 46.74,174.19 B33.L1 | v39.42,208.33 41.45,206.3 41.45,187.6 47.55,181.51 47.55,173.38
  Route2 0.203: v47.14,136.4 20.73,109.98 20.73,108.76 C35.L1 | v39.42,208.33 33.73,214.02 33.73,218.49 A34.V1
N$190  (via drill 0.61)
  Top 0.203: v45.52,105.92 47.95,105.92 47.95,170.13 | 47.95,170.13 48.77,170.94 B33.M1 | 47.95,170.13 47.95,181.91 47.55,182.32 47.55,212.8 44.7,215.65 44.7,242.06 35.36,251.41 35.36,259.94 30.89,259.94 A34.E2
  Bottom 0.203: v45.52,105.92 25.2,105.92 24.38,105.1 C35.M1
N$191  (via drill 0.61)
  Top 0.203: 22.35,159.56 22.35,151.03 27.23,146.15 27.23,137.62 26.82,137.21 26.82,110.39 25.2,108.76 25.2,99.82 24.38,99.01 C35.P1 | 22.35,159.56 v24.38,161.59 | v22.35,253.03 21.95,252.63 21.95,231.09 19.51,228.65 19.51,171.35 22.35,168.5 22.35,159.56
  Bottom 0.203: v24.38,161.59 29.26,166.47 32.92,166.47 35.76,163.63 47.95,163.63 48.77,164.44 B33.P1 | v22.35,253.03 22.76,252.63 28.85,252.63 29.67,253.44 A34.H2
N$192  (via drill 0.61)
  Top 0.203: v26.42,138.02 26.42,110.79 22.35,106.73 22.35,93.32 23.16,92.51 C35.S1 | v28.04,247.34 28.45,246.94 28.45,207.11 28.04,206.7 28.04,201.02 28.45,200.61 28.45,188.82 28.85,188.42 28.85,181.1 31.29,178.66 31.29,142.9 v30.89,142.49
  Route2 0.203: v26.42,138.02 v30.89,142.49 45.11,156.72 47.14,156.72 48.77,158.34 B33.S1 | v28.04,247.34 29.67,247.34 A34.K2
N$193  (via drill 0.61)
  Top 0.203: v34.95,127.05 34.95,179.88 38.2,183.13 38.2,186.79 | 38.2,186.79 38.2,191.67 39.42,192.89 B33.D2 | 38.2,186.79 34.95,190.04 34.95,227.03 32.11,229.87 32.11,239.22 30.48,240.84 A34.M2
  Bottom 0.203: v34.95,127.05 22.76,127.05 21.54,125.83 15.85,125.83 15.04,126.64 C35.D2
N$194  (via drill 0.61)
  Top 0.203: v20.32,166.06 16.26,162 16.26,125.83 17.48,124.61 C35.E2 | v31.29,189.23 31.29,233.53 30.48,234.34 A34.P2
  Route2 0.203: v20.32,166.06 41.05,186.79 41.05,188.82 42.27,190.04 B33.E2
  Bottom 0.203: v31.29,189.23 41.45,189.23 42.27,190.04 B33.E2
N$195  (via drill 0.61)
  Top 0.203: v30.89,118.92 32.51,120.55 32.51,148.18 32.11,148.59 32.11,177.85 | 32.11,177.85 35.76,181.51 v35.76,182.73 | 32.11,177.85 v32.11,228.24
  Route2 0.203: v32.11,228.24 30.89,228.24 A34.S2
  Bottom 0.203: v30.89,118.92 18.69,118.92 17.88,118.11 C35.H2 | v35.76,182.73 41.05,182.73 42.27,183.95 B33.H2
N$196  (via drill 0.61)
  Top 0.203: v40.64,112.01 41.05,112.42 41.05,166.47 41.45,166.88 41.45,175.82 42.67,177.04 B33.K2 | v30.48,207.52 30.48,221.74 A34.U2
  Route15 0.203: v30.48,207.52 30.48,205.89 50.8,185.57 50.8,182.32 45.11,176.63 43.48,178.26 B33.K2
  Bottom 0.203: v40.64,112.01 40.23,112.42 18.69,112.42 17.88,111.61 C35.K2
N$197  (via drill 0.61)
  Top 0.203: v251.56,252.63 250.75,251.82 250.75,222.56 241.81,213.61 241.81,166.88 245.47,163.22 245.47,138.02 244.65,137.21 244.65,108.36 v251.16,101.85 | v296.67,57.56 298.7,55.52 298.7,40.08 299.92,38.86 D13.L1
  Route15 0.203: v251.16,101.85 258.47,94.54 259.28,94.54 296.27,57.56 v296.67,57.56
  Bottom 0.203: v251.56,252.63 282.85,252.63 283.67,253.44 A14.H2
N$198  (via drill 0.61)
  Top 0.203: v38.61,96.98 44.3,96.98 44.3,103.48 | 44.3,103.48 44.3,147.37 41.45,150.22 41.45,163.22 42.67,164.44 B33.P2 | 44.3,103.48 v43.89,103.48
  Bottom 0.203: v38.61,96.98 18.69,96.98 17.88,97.79 C35.P2 | v43.89,103.48 114.2,103.48 115.42,102.26 C27.N2
N$199  (via drill 0.61)
  Top 0.203: v26.42,140.46 25.6,139.65 25.6,110.79 19.51,104.7 19.51,94.13 17.88,92.51 C35.S2
  Route2 0.203: v26.42,140.46 33.73,147.78 34.14,147.78 41.05,154.69 41.05,156.31 42.67,157.94 B33.S2
N$200
  Bottom 0.203: C32.J2 52.83,113.64 53.24,113.23 57.71,113.23 59.33,111.61 61.37,111.61 C32.K1
N$201
  Top 0.203: D17.K1 251.97,41.71 251.97,46.99 D17.H1 | D17.J1 248.72,44.96 248.72,50.24 D17.F1 249.12,51.46 249.12,56.34 D17.D1 249.94,57.56 251.97,59.59 251.97,60 D17.C1 251.97,60.81 251.97,61.21 249.94,63.25 D17.B1 249.94,63.65 249.94,64.06 251.97,66.09 D17.A1
  Bottom 0.203: D16.F1 261.31,50.65 259.69,49.02 254.41,49.02 253.19,47.8 D17.H1 251.97,48.21 251.97,50.24 249.53,50.24 D17.F1
N$203  (via drill 0.61)
  Top 0.203: v280.01,84.38 279.6,84.78 279.6,134.77 278.38,135.99 C15.A1
  Bottom 0.203: v280.01,84.38 287.73,84.38 288.54,83.57 292.2,83.57 293.01,82.75 C13.V2
N$204  (via drill 0.61)
  Top 0.203: v256.85,109.98 256.85,52.27 256.03,51.46 D16.F2 | C15.B1 274.32,132.74 273.51,131.93 273.51,113.64 271.88,112.01 271.88,111.61 C15.K2
  Bottom 0.203: v256.85,109.98 257.66,110.79 270.66,110.79 C15.K2
N$205
  Top 0.203: D14.H2 284.48,48.21 286.11,49.84 286.11,52.68 286.51,53.09 286.51,55.12 279.2,62.43 279.2,128.27 277.98,129.49 C15.C1
N$206  (via drill 0.61)
  Top 0.203: 254.41,59.18 254,59.59 254,87.22 246.28,94.94 246.28,97.79 C17.P2 | 254.41,59.18 255.63,57.96 D16.D2 | v260.91,42.93 254.41,49.43 254.41,59.18
  Bottom 0.203: v260.91,42.93 272.69,42.93 273.91,44.15 D15.J1
N$207  (via drill 0.61)
  Top 0.203: v241.4,43.74 241,44.15 241,119.33 v240.18,120.14
  Route15 0.203: v241.4,43.74 253.19,31.95 254.81,31.95 D16.N2
  Bottom 0.203: v240.18,120.14 242.21,122.17 266.6,122.17 267.82,120.95 C15.F2
N$208
  Top 0.203: D14.N2 281.63,31.95 286.11,31.95 286.11,41.3 290.17,45.36 290.17,46.99 D14.H1
N$209  (via drill 0.61)
  Top 0.203: v285.7,53.49 282.85,50.65 282.85,36.83 284.07,35.61 D14.M2
  Bottom 0.203: v285.7,53.49 286.11,53.9 289.76,53.9 D14.E1
N$210  (via drill 0.61)
  Top 0.203: v287.32,46.58 287.32,44.96 D14.J1 | C15.J1 274.32,113.64 273.1,112.42 273.1,54.3 272.69,53.9 272.69,49.02 271.88,48.21 D15.H2 | v254.41,46.58 254.41,37.24 252.78,35.61 D17.M1
  Route2 0.203: D17.N1 249.94,31.95 249.94,32.36 251.97,34.39 D17.M1
  Bottom 0.203: 272.69,46.18 271.88,46.99 D15.H2 | 272.69,46.18 286.92,46.18 v287.32,46.58 | v254.41,46.58 254.81,46.18 272.69,46.18
N$211
  Route2 0.203: D15.L2 269.04,38.46 270.66,38.46 275.95,43.74 275.95,45.36 277.57,46.99 D15.H1
N$212  (via drill 0.61)
  Top 0.203: v273.51,53.49 273.1,53.09 273.1,19.36 269.04,19.36 D15.T2
  Bottom 0.203: v273.51,53.49 277.17,53.49 D15.E1
N$213  (via drill 0.61)
  Top 0.203: v267.82,27.08 269.44,28.7 269.44,84.38 270.26,85.19 v270.26,109.98
  Bottom 0.203: v267.82,27.08 263.75,27.08 262.53,25.86 D16.R1 | v270.26,109.98 276.35,109.98 277.17,110.79 C15.K1
N$214  (via drill 0.61)
  Top 0.203: v120.29,142.49 120.29,156.72 119.08,157.94 B27.S2 | v169.88,142.09 178.82,151.03 178.82,155.09 B22.T2
  Bottom 0.203: v120.29,142.49 128.42,142.49 129.24,141.68 166.62,141.68 167.44,142.49 169.47,142.49 v169.88,142.09
N$215  (via drill 0.61)
  Top 0.203: v265.38,51.87 266.6,53.09 266.6,62.03 265.38,63.25 265.38,64.87 266.6,66.09 266.6,95.35 266.19,95.76 266.19,124.21 268.22,126.24 C15.D2
  Bottom 0.203: v265.38,51.87 265.79,52.27 286.11,52.27 286.92,51.46 D14.F1
N$216
  Bottom 0.203: B27.R2 116.64,162 118.26,163.63 179.63,163.63 182.47,160.78 182.47,159.56 B22.S2
N$217  (via drill 0.61)
  Top 0.203: v108.92,157.12 114.61,162.81 114.61,185.98 115.42,186.79 B27.F2
  Bottom 0.203: v108.92,157.12 6.5,157.12 5.28,158.34 B36.S2
N$218
  Route2 0.203: B36.V2 2.03,148.59 6.5,148.59 15.44,139.65 26.42,150.62 30.89,150.62 38.2,157.94 38.2,162.41 90.63,214.83 91.44,214.83 92.25,215.65 97.54,215.65 102.41,220.52 104.04,220.52 105.66,222.15 A28.U2
  Bottom 0.203: A27.T2 115.42,224.99 114.2,223.77 108.1,223.77 106.88,222.56 A28.U2
N$219
  Top 0.203: B28.J2 103.63,180.29 105.66,178.26 B28.K2 | B27.J2 116.23,180.29 118.26,178.26 118.26,177.85 B27.K2
  Bottom 0.203: B28.K2 106.88,178.26 108.1,179.48 114.61,179.48 115.42,180.29 B27.J2
N$221  (via drill 0.61)
  Top 0.203: D25.L2 141.02,38.86 139.8,40.08 139.8,96.16 142.65,99.01 142.65,105.92 141.43,107.14 C25.L2 | v125.17,252.22 123.95,251 123.95,114.86 v129.24,109.58
  Bottom 0.203: v125.17,252.22 128.02,252.22 128.02,256.69 A26.F2 | v129.24,109.58 129.64,109.17 139.8,109.17 140.61,108.36 C25.L2
N$222  (via drill 0.61)
  Top 0.203: v252.78,75.84 247.9,80.72 247.9,83.97 246.69,85.19 C17.U2
  Route15 0.203: v252.78,75.84 265.79,62.84 267,62.84 299.52,30.33 301.55,30.33 302.77,29.11 D13.P1
N$223  (via drill 0.61)
  Top 0.203: v282.85,100.63 282.85,59.59 292.2,50.24 292.2,30.33 294.23,30.33 295.05,31.14 299.52,31.14 D13.N1
  Bottom 0.203: v282.85,100.63 282.45,100.23 275.95,100.23 275.13,101.04 C15.N1
N$224  (via drill 0.61)
  Top 0.203: D25.M1 151.18,35.61 151.99,36.42 151.99,103.48 151.18,104.29 C25.M1 | v130.45,108.36 130.45,142.9 127.2,146.15 127.2,185.98 128.02,186.79 B26.F2
  Bottom 0.203: v130.45,108.36 132.89,105.92 149.56,105.92 150.37,105.1 C25.M1
N$225  (via drill 0.61)
  Top 0.203: v153.62,49.02 155.65,49.02 155.65,110.39 v154.43,111.61 | v151.18,108.36 151.99,109.17 151.99,122.58 | 151.99,122.58 151.18,123.39 C25.E1 | 151.99,122.58 151.99,166.47 149.56,168.91 149.56,182.32 144.27,182.32 143.05,183.54 143.05,185.57 141.83,186.79 B25.F2
  Route2 0.203: v154.43,111.61 154.03,111.61 151.18,108.76 v151.18,108.36
  Bottom 0.203: v153.62,49.02 150.37,49.02 150.37,53.49 D25.E1
N$226  (via drill 0.61)
  Top 0.203: v120.29,113.64 120.29,129.08 121.11,129.9 121.11,142.9 120.7,143.31 120.7,181.51 120.29,181.91 120.29,271.32 129.24,271.32 136.14,264.41 136.14,257.5 140.61,257.5 A25.F2 | D25.U2 144.68,16.51 146.3,18.14 146.3,62.03 140.21,68.12 140.21,79.5 143.87,83.16 143.87,85.19 C25.U2
  Route15 0.203: v120.29,113.64 120.29,112.01 142.65,89.66 142.65,88.04 144.27,86.41 C25.U2
N$227
  Route2 0.203: A21.S2 195.88,229.06 199.95,229.06 204.01,233.12 210.51,233.12 238.96,261.57 240.59,261.57 242.21,263.2 A17.D2
N$228  (via drill 0.61)
  Top 0.203: v245.47,227.03 244.65,227.84 244.65,258.32 245.87,259.54 A17.E2