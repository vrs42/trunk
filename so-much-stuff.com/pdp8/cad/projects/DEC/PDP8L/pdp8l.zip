# EAGLE board pdp8l (EAGLE 4.11), part 5 of 8
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
MB07  (via drill 0.61) (continued)
  Route2 0.203: v388.52,207.52 388.52,207.92 408.84,228.24 410.46,228.24 AB04.AS2 | v366.57,207.92 362.92,204.27 362.92,203.45 v359.66,200.2 | v132.08,142.49 126.39,136.8 125.98,136.8 C27.A1
  Bottom 0.203: v126.39,122.58 71.53,122.58 70.71,121.77 66.65,121.77 66.24,122.17 56.08,122.17 56.08,118.11 C32.H2 | v288.54,105.1 284.89,105.1 C14.M2 | v286.11,138.43 v289.76,138.43 | v292.2,180.29 293.01,179.48 298.3,179.48 299.52,180.7 B13.J1 | v388.52,207.52 388.11,207.92 v366.57,207.92 | v359.66,200.2 358.04,198.58 355.19,198.58 354.79,198.98 351.94,198.98 351.54,198.58 342.6,198.58 342.19,198.98 339.34,198.98 338.94,198.58 330,198.58 329.59,198.98 326.34,198.98 325.93,198.58 317.4,198.58 316.99,198.98 313.74,198.98 313.33,198.58 304.39,198.58 303.99,198.98 301.14,198.98 300.74,198.58 v292.61,198.58 | v132.08,142.49 132.49,142.9 258.06,142.9 258.88,143.71 276.35,143.71 277.17,144.53 v286.11,144.53
MB07\  (via drill 0.61)
  Top 0.203: v276.35,205.08 v276.35,158.75 276.35,158.34 v276.35,147.78 | v303.58,205.08 303.58,217.27 303.99,217.68 303.99,222.15 A13.U1 | v421.44,163.63 421.84,164.03 421.84,196.95 419.4,199.39 419.4,200.61 419.81,201.02 419.81,218.08 419,218.9 419,226.62 417.78,227.84 AB04.AS1 | v75.18,51.46 72.75,53.9 72.75,98.2 69.49,101.45 69.49,116.08 | 69.49,116.08 68.68,116.89 C31.H2 | v11.38,218.9 6.5,223.77 6.5,250.19 2.03,250.19 A36.J2 | v71.93,209.14 71.53,208.74 71.53,146.15 | 71.53,146.15 71.53,135.59 69.49,133.55 69.49,116.08 | v75.59,146.15 71.53,146.15
  Route15 0.203: v345.03,166.06 344.63,166.06 340.16,170.54 340.16,170.94 337.72,173.38 337.31,173.38 330.4,180.29 330.4,180.7 328.78,182.32 328.37,182.32 310.9,199.8 310.9,203.86 303.99,210.77 301.55,208.33 301.55,207.52 303.58,205.49 v303.58,205.08 | v75.18,51.46 90.22,36.42 94.28,36.42 106.07,24.64 106.07,23.01 D28.S2
  Bottom 0.203: v276.35,158.75 283.67,158.75 B14.S2 | v303.58,205.08 v276.35,205.08 | B01.R2 445.41,162.41 444.19,163.63 v421.44,163.63 421.03,163.63 353.57,163.63 350.72,166.47 345.44,166.47 v345.03,166.06 | v11.38,218.9 14.63,215.65 65.43,215.65 v71.93,209.14 | v276.35,147.78 275.54,148.59 255.22,148.59 251.16,144.53 189.38,144.53 187.76,146.15 v75.59,146.15
MB08  (via drill 0.61)
  Top 0.203: v301.14,264.82 299.52,264.82 298.3,263.6 298.3,253.44 295.05,250.19 295.05,233.12 294.23,232.31 A13.R2 293.42,231.09 291.8,229.46 291.8,221.74 290.58,220.52 v290.58,214.02 | v416.15,244.5 416.15,234.34 419.81,230.68 419.81,227.03 420.62,226.21 AB03.AT2
  Route2 0.203: v195.07,115.67 195.48,115.67 215.8,135.99 215.8,136.8 263.35,184.35 263.35,184.76 284.48,205.89 284.48,207.92 v290.58,214.02
  Route15 0.203: v348.69,243.69 347.07,243.69 345.03,245.72 341.38,245.72 330.4,256.69 330.4,257.91 328.78,259.54 A11.E1
  Bottom 0.203: C32.J1 59.33,114.86 59.33,119.33 120.29,119.33 121.51,120.55 C27.F1 122.73,120.14 123.95,118.92 191.82,118.92 v195.07,115.67 | v301.14,264.82 301.55,264.41 305.21,264.41 305.61,264.82 309.27,264.82 311.71,262.38 317.81,262.38 318.62,263.2 A11.D2 319.84,263.2 321.46,261.57 327.15,261.57 327.96,260.76 A11.E1 | v416.15,244.5 416.15,245.72 380.39,245.72 377.95,243.28 349.1,243.28 v348.69,243.69
MB08\  (via drill 0.61)
  Top 0.203: v443.79,208.33 443.79,205.89 447.85,201.83 447.85,160.78 449.07,159.56 B01.S2 | v425.09,215.65 424.28,216.46 424.28,221.74 AB03.AU2 | v278.79,240.84 278.79,158.34 280.82,156.31 B14.T2 | v298.7,248.56 298.3,248.16 298.3,243.28 297.08,242.06 A13.M2 | v115.82,112.42 121.11,112.42 121.11,129.08 121.92,129.9 121.92,132.74 C27.B1 122.73,133.96 123.55,134.77 123.55,164.44 v123.14,164.85 123.55,164.85 123.55,240.84 v121.11,243.28 121.11,243.69 121.11,245.31 v123.14,247.34
  Route2 0.203: v123.14,164.85 128.42,170.13 132.49,170.13 153.62,191.26 153.62,192.89 B24.D2
  Route15 0.203: v405.18,220.12 403.56,221.74 403.56,225.4 383.24,245.72 379.17,245.72 v378.76,246.13
  Bottom 0.203: v443.79,208.33 436.47,215.65 v425.09,215.65 | v278.79,240.84 280.42,242.47 295.45,242.47 296.27,241.66 A13.M2 | v405.18,220.12 405.59,220.52 421.44,220.52 423.06,222.15 AB03.AU2 | v378.76,246.13 372.67,246.13 366.57,252.22 342.19,252.22 339.34,249.38 330.4,249.38 329.18,248.16 A11.K1 327.96,248.16 327.15,248.97 299.11,248.97 v298.7,248.56 298.3,248.56 297.89,248.97 269.85,248.97 268.63,247.75 254.41,247.75 252.78,249.38 173.13,249.38 172.31,248.56 170.69,248.56 170.28,248.97 124.77,248.97 v123.14,247.34 | v115.82,112.42 67.46,112.42 65.84,114.05 C31.J2 | v121.11,243.28 120.7,242.88 4.88,242.88 4.88,246.94 A36.K2
MB09  (via drill 0.61)
  Top 0.203: v326.75,253.03 327.15,253.44 327.15,271.73 327.96,272.54 A11.A1 328.78,273.76 v328.78,283.92 | v127.2,141.28 127.2,119.74 125.58,118.11 C27.H1 | v307.64,141.68 307.64,125.42 306.43,124.21 306.43,121.36 C12.F2 | v262.53,197.36 260.91,195.73 v260.91,141.28
  Route2 0.203: v262.53,197.36 315.37,250.19 318.62,250.19 A11.J2
  Route15 0.203: v328.78,283.92 330.81,283.92 332.03,282.7 363.32,282.7 366.17,279.86 369.42,279.86 420.62,228.65 423.06,228.65 AB03.AS2 | v310.08,120.14 322.68,107.54 322.68,106.32 338.53,90.47 338.94,90.47 351.54,77.88 353.57,77.88 353.97,77.47 353.97,77.06 403.15,27.89 403.15,26.67 404.37,25.45 407.21,25.45 D04.R2
  Bottom 0.203: v326.75,253.03 325.93,252.22 321.06,252.22 319.84,251 A11.J2 | v127.2,141.28 127.61,140.87 167.44,140.87 167.84,140.46 252.37,140.46 253.59,141.68 260.91,141.68 | 260.91,141.68 v307.64,141.68 | v310.08,120.14 306.83,120.14 C12.F2 | 260.91,141.68 v260.91,141.28
MB09\  (via drill 0.61)
  Top 0.203: v430.78,166.88 428.75,168.91 428.75,226.62 429.97,227.84 AB03.AS1 | v167.84,215.65 165.41,213.21 165.41,194.11 160.93,194.11 B24.D1
  Route2 0.203: v296.27,216.86 296.27,217.27 308.86,229.87 312.93,229.87 318.21,235.15 319.02,235.15 319.84,235.97 321.06,235.97 324.71,239.62 326.75,239.62 327.96,240.84 A11.M1 328.78,242.06 330.4,243.69 330.4,245.72 340.16,255.47 v340.56,255.47
  Route15 0.203: v430.78,166.88 447.85,149.81 447.85,146.15 448.26,145.75 448.26,140.06 448.67,139.65 449.07,139.65 451.1,137.62 451.1,132.74 451.92,131.93 451.92,127.46 C01.D1 | v402.34,253.44 426.72,229.06 429.56,229.06 AB03.AS1
  Bottom 0.203: v167.84,215.65 290.17,215.65 291.39,216.86 v296.27,216.86 | v402.34,253.44 399.9,255.88 340.97,255.88 v340.56,255.47
MB10  (via drill 0.61)
  Top 0.203: v323.9,266.85 323.9,266.45 319.84,262.38 v319.84,261.57 319.84,258.32 319.43,257.91 A11.F2 | v419,281.08 425.5,274.57 425.5,250.19 432,243.69 432,227.43 433.22,226.21 AB02.AT2 | v330.4,283.11 330,282.7 330,271.32 329.18,270.51 329.18,267.26 A11.C1 | v127.2,77.88 127.2,103.07 125.98,104.29 C27.M1 | v231.24,261.98 221.89,252.63 221.89,206.3 219.46,203.86 219.46,121.36 222.71,118.11 222.71,69.75 v223.11,69.34
  Route15 0.203: v373.89,68.12 403.56,38.46 407.21,38.46 D04.L2
  Bottom 0.203: v323.9,266.85 327.96,266.85 A11.C1 | v419,281.08 416.56,283.52 375.11,283.52 374.7,283.11 369.42,283.11 369.01,283.52 330.81,283.52 v330.4,283.11 | v127.2,77.88 135.33,69.75 162.97,69.75 163.37,69.34 v223.11,69.34 303.99,69.34 304.8,70.16 334.06,70.16 334.47,70.56 336.91,70.56 338.12,69.34 352.75,69.34 353.16,69.75 353.97,69.75 354.38,69.34 354.38,68.53 | 354.38,68.53 354.38,67.31 D09.A1 | v373.89,68.12 373.07,68.94 357.63,68.94 357.23,68.53 354.38,68.53 | v319.84,261.57 319.43,261.98 289.36,261.98 288.95,262.38 253.59,262.38 253.19,261.98 v231.24,261.98
MB10\  (via drill 0.61)
  Top 0.203: v454.36,221.34 454.36,112.42 455.17,111.61 C01.K1 | v262.94,87.63 260.1,90.47 v260.1,136.4 259.69,136.4 259.69,142.09 260.1,142.49 260.1,189.23 v259.69,189.64 | v155.65,139.24 155.65,169.72 156.87,170.94 B24.M2 | v424.28,281.08 434.85,270.51 434.85,224.59 436.47,222.96 AB02.AU2 | v327.56,283.11 327.56,274.17 326.75,273.36 326.75,254.25 325.93,253.44 325.93,252.63 327.15,251.41 328.78,251.41 328.78,253.44 A11.H1
  Route2 0.203: A11.H1 328.78,253.44 328.78,251.82 323.09,246.13 321.46,246.13 319.84,244.5 A11.L2 318.62,244.09 317.81,244.09 316.59,242.88 315.37,242.88 309.27,236.78 308.46,236.78 303.99,232.31 303.58,232.31 288.54,217.27 287.32,217.27 v259.69,189.64
  Bottom 0.203: v454.36,221.34 451.92,223.77 438.51,223.77 437.29,222.56 AB02.AU2 | v262.94,87.63 275.13,87.63 275.54,88.04 280.01,88.04 280.42,88.44 C14.T2 | v260.1,136.4 257.25,139.24 v155.65,139.24 | v424.28,281.08 421.44,283.92 374.7,283.92 374.29,283.52 369.82,283.52 369.42,283.92 330,283.92 329.18,283.11 v327.56,283.11
MB11  (via drill 0.61)
  Top 0.203: v428.35,86.82 428.35,117.3 425.91,119.74 v425.91,205.49 | v435.25,205.89 437.69,208.33 437.69,227.03 436.88,227.84 AB02.AS2 | v312.12,248.16 312.52,248.56 312.52,250.19 A12.J1 | v386.49,279.04 380.8,273.36 380.8,272.54 377.55,269.29 v377.55,267.67
  Route2 0.203: v428.35,86.82 419,77.47 419,72.59 418.59,72.19 418.59,71.37 409.25,62.03 409.25,56.74 408.43,55.93 408.43,51.46 D04.F2 | v287.32,267.26 269.44,249.38 267.82,249.38 254.81,236.37 251.56,236.37 174.35,159.16 174.35,154.69 157.68,138.02 156.46,138.02 122.73,104.29 122.73,102.26 C27.N1 | v343.41,267.67 341.78,269.29 341.78,269.7 340.97,270.51 335.69,265.23 330,265.23 315.37,250.6 314.96,250.6 312.52,248.16 v312.12,248.16
  Route15 0.203: v287.32,267.26 289.36,265.23 290.98,265.23 291.8,264.41 291.8,263.2 305.61,249.38 310.49,249.38 311.71,248.16 v312.12,248.16 | v386.49,279.04 388.93,276.61 397.46,276.61 397.87,276.2 397.87,275.79 425.91,247.75 425.91,243.69 436.07,233.53 436.07,229.06 AB02.AS2
  Bottom 0.203: v425.91,205.49 426.31,205.89 v435.25,205.89 | v377.55,267.67 377.14,268.07 343.81,268.07 v343.41,267.67
MB11\  (via drill 0.61)
  Top 0.203: v446.23,122.58 446.23,124.21 444.6,125.83 444.6,159.56 441.76,162.41 441.76,227.03 442.57,227.84 AB02.AS1 | v168.25,141.28 167.84,141.68 167.84,175.82 165.81,175.82 165,175.01 165,170.13 162.97,170.13 162.15,170.94 162.15,172.97 160.93,174.19 B24.L1 | v311.71,142.49 311.3,142.09 311.3,138.02 311.71,137.62 311.71,134.37 310.9,133.55 310.9,125.83 309.68,124.61 C12.E2 | v325.93,195.73 325.12,194.92 324.31,194.92 324.31,192.89 323.9,192.48 323.9,145.34 323.49,144.93 v323.49,142.9 | v349.91,70.56 349.91,64.47 350.32,64.06 D09.B1 | v334.47,71.37 334.87,71.78 334.87,83.57 336.09,84.78 336.09,103.48 335.28,104.29 C10.M2
  Route2 0.203: v446.23,122.58 450.7,118.11 450.7,106.73 449.48,105.51 C01.M2 | C14.U2 284.48,86.41 284.48,89.66 292.2,97.38 292.2,98.2 295.05,101.04 295.05,111.2 306.02,122.17 307.64,122.17 308.86,123.39 C12.E2
  Route15 0.203: C10.M2 335.28,104.29 335.28,102.67 334.47,101.85 330,106.32 330,106.73 327.96,108.76 326.75,108.76 326.34,109.17 322.27,109.17 311.3,120.14 311.3,122.17 310.08,123.39 C12.E2
  Bottom 0.203: v168.25,141.28 252.37,141.28 253.19,142.09 306.83,142.09 307.24,142.49 v311.71,142.49 311.71,142.9 v323.49,142.9 | v325.93,195.73 327.15,195.73 327.96,196.54 B11.C1 | v349.91,70.56 349.1,69.75 338.53,69.75 336.91,71.37 v334.47,71.37 | C01.M2 448.67,105.1 447.85,105.92 336.5,105.92 335.69,105.1 C10.M2
MB_LOAD  (via drill 0.61)
  Top 0.203: v361.29,187.2 361.7,186.79 361.7,166.47 360.88,165.66 B08.P2
  Route2 0.203: v361.29,187.2 374.7,200.61 374.7,202.23 377.55,205.08 377.55,205.89 389.33,217.68 389.74,217.68 399.9,227.84 399.9,229.46 401.52,231.09 AB05.AR1
  Bottom 0.203: 425.09,233.12 415.75,233.12 414.93,232.31 AB04.AR1 413.71,232.31 412.9,233.12 405.18,233.12 403.96,231.9 402.34,231.9 AB05.AR1 401.12,231.9 397.87,231.9 396.65,233.12 390.96,233.12 389.74,231.9 AB06.AR1 388.52,231.09 387.71,230.28 382.02,230.28 381.2,231.09 377.14,231.09 376.73,231.5 AB07.AR1 | 425.09,233.12 426.31,231.9 AB03.AR1 | 425.09,233.12 438.51,233.12 439.32,232.31 AB02.AR1
MEM00  (via drill 0.61)
  Top 0.203: v301.95,72.59 301.95,65.68 303.17,64.47 303.17,62.84 301.95,61.62 301.95,27.08 300.74,25.86 D13.R1 | v240.18,79.91 238.56,81.53 238.56,133.55 241,135.99 241,159.16 240.59,159.56 240.59,164.03 241,164.44 v241,192.48 241,242.47 241.4,242.88 241.4,271.32 240.18,272.54 A18.A1 | v377.55,158.34 377.55,159.97 376.33,161.19 AB07.BR1
  Route2 0.203: v112.57,270.92 59.33,217.68 58.93,217.68 55.27,214.02 55.27,213.61 32.11,190.45 32.11,188.82 26.82,183.54 20.73,189.64 20.73,192.89 B35.D1
  Route15 0.203: v366.17,157.12 362.51,160.78 361.7,160.78 338.94,183.54 337.72,183.54 335.69,185.57 333.25,185.57 332.84,185.98 331.22,185.98 327.15,190.04 327.15,191.26 329.59,193.7 330.81,192.48 v332.84,192.48
  Bottom 0.203: v301.95,72.59 301.95,78.28 299.11,78.28 298.3,79.1 293.83,79.1 293.42,78.69 290.98,78.69 290.17,79.5 262.13,79.5 261.72,79.91 v240.18,79.91 | v377.55,158.34 376.33,157.12 v366.17,157.12 | v332.84,192.48 328.37,192.48 325.93,194.92 322.27,194.92 319.84,192.48 310.49,192.48 308.05,194.92 290.58,194.92 288.14,192.48 v241,192.48 | v112.57,270.92 116.23,274.57 153.62,274.57 156.87,271.32 162.15,271.32 162.56,270.92 165.81,270.92 166.62,271.73 204.83,271.73 207.67,274.57 237.74,274.57 238.96,273.36 A18.A1
MEM01  (via drill 0.61)
  Top 0.203: C08.E2 360.48,124.61 362.1,126.24 362.1,133.96 366.57,138.43 369.42,138.43 369.42,148.59 AB07.BV2
  Route2 0.203: v137.77,188.82 144.68,188.82 174.75,218.9 v177.19,218.9
  Route15 0.203: v360.48,121.77 360.48,123.39 C08.E2 | v352.75,120.95 351.94,120.14 351.94,119.74 350.32,118.11 332.44,135.99 331.62,135.99 321.06,146.56 318.62,146.56 318.21,146.96 316.99,146.96 277.57,186.38 276.76,186.38 272.29,190.86 272.29,191.26 248.31,215.24 247.5,215.24 247.09,215.65 242.21,215.65 237.34,220.52 235.71,220.52 234.09,222.15 A18.U2
  Bottom 0.203: v137.77,188.82 134.93,191.67 25.2,191.67 24.38,190.86 B35.E1 | v177.19,218.9 178.82,220.52 231.65,220.52 232.87,221.74 A18.U2 | v360.48,121.77 360.07,122.17 353.97,122.17 v352.75,120.95
MEM02  (via drill 0.61)
  Top 0.203: v386.89,140.06 387.71,140.87 387.71,160.38 388.52,161.19 AB06.BR1 388.52,162.41 387.71,163.22 387.71,190.04 388.11,190.45 388.11,192.48 386.89,193.7 v386.89,199.8 | v366.57,231.09 364.95,232.72 364.95,247.34 v364.54,247.75 | v227.18,283.92 227.18,273.76 A19.A1
  Route2 0.203: v386.89,140.06 364.13,117.3 364.13,114.86 C08.J1 | v110.54,185.98 111.35,185.98 124.36,198.98 125.58,198.98 147.12,220.52 176.38,220.52 225.15,269.29 225.15,271.32 226.37,272.54 A19.A1 | v386.89,199.8 v386.89,205.49
  Route15 0.203: v386.89,205.49 386.89,209.55 385.27,211.18 385.27,212.39 v366.57,231.09 | v364.54,247.75 343.81,268.48 343,268.48 341.38,270.1 340.16,270.1 335.69,274.57 330.4,274.57 v321.06,283.92
  Bottom 0.203: v110.54,185.98 26.01,185.98 24.38,184.35 B35.H1 | v321.06,283.92 320.65,284.33 286.92,284.33 286.11,283.52 285.29,283.52 284.48,284.33 227.58,284.33 v227.18,283.92
MEM03  (via drill 0.61)
  Route2 0.203: v360.07,132.74 369.82,142.49 373.07,142.49 379.58,149 382.02,149 AB06.BV2 | v126.39,175.82 132.49,175.82 174.75,218.08 v175.16,218.08
  Route15 0.203: v360.07,132.74 358.04,134.77 352.35,134.77 348.29,138.84 345.44,138.84 313.74,170.54 313.33,170.54 312.93,170.94 312.93,171.35 312.52,171.75 311.3,171.75 277.17,205.89 274.73,205.89 263.35,217.27 246.69,217.27 240.18,223.77 221.89,223.77 221.08,222.96 A19.U2
  Bottom 0.203: v126.39,175.82 91.85,175.82 91.44,176.22 20.73,176.22 20.73,180.29 B35.J1 | v175.16,218.08 178,220.93 218.64,220.93 219.86,222.15 A19.U2
MEM04  (via drill 0.61)
  Top 0.203: v401.52,183.95 403.15,182.32 403.15,163.63 401.93,162.41 AB05.BR1 | v282.45,270.92 280.01,273.36 280.01,280.26 275.54,284.73 224.33,284.73 | 224.33,284.73 214.58,284.73 214.58,273.76 A20.A1 | v224.33,276.61 224.33,284.73
  Route2 0.203: v131.67,277.42 58.93,204.67 48.77,204.67 37.8,193.7 37.8,192.48 36.98,191.67 35.76,191.67 20.73,176.63 20.73,175.41 B35.L1
  Route15 0.203: v401.52,183.95 386.08,199.39 386.08,200.2 384.05,202.23 384.05,203.05 362.1,224.99 362.1,229.06 350.72,240.44 350.72,241.25 353.97,244.5 v341.78,256.69 | v282.45,270.92 v295.05,258.32
  Bottom 0.203: v341.78,256.69 341.38,256.29 339.34,256.29 338.94,255.88 328.78,255.88 326.34,258.32 321.46,258.32 321.06,257.91 320.24,257.91 319.84,258.32 315.77,258.32 313.33,255.88 309.68,255.88 307.24,258.32 v295.05,258.32 | v131.67,277.42 132.49,276.61 v224.33,276.61
MEM05  (via drill 0.61)
  Route2 0.203: v342.19,150.22 341.38,150.22 338.94,147.78 333.65,147.78 324.71,138.84 324.71,136.8 v323.09,135.18 | v132.08,175.01 132.49,175.01 152.81,195.33 172.72,195.33 192.23,214.83 193.04,214.83 193.85,215.65 199.14,215.65 204.01,220.52 205.64,220.52 207.26,222.15 A20.U2
  Route15 0.203: v323.09,135.18 320.65,135.18 320.24,135.59 319.02,135.59 316.59,138.02 315.37,138.02 313.33,140.06 311.71,140.06 293.42,158.34 293.42,159.97 286.11,167.28 286.11,171.35 281.63,175.82 256.44,175.82 211.73,220.52 209.7,220.52 208.48,221.74 A20.U2
  Bottom 0.203: v342.19,150.22 342.6,150.62 358.04,150.62 360.88,147.78 393.39,147.78 394.61,149 AB05.BV2 | v132.08,175.01 130.05,172.97 106.07,172.97 102.82,169.72 60.96,169.72 60.55,170.13 25.2,170.13 24.38,170.94 B35.M1
MEM06  (via drill 0.61)
  Top 0.203: v409.65,277.42 409.65,222.15 410.06,221.74 410.06,209.14 412.9,206.3 412.9,163.22 413.71,162.41 AB04.BR1 | v277.98,277.01 277.17,277.83 277.17,280.26 275.95,281.48 253.59,281.48 253.59,274.98 | 253.59,274.98 253.59,207.11 v250.75,204.27 | v187.35,245.31 187.76,245.72 187.76,255.07 204.42,271.73 236.53,271.73 236.53,274.98 253.59,274.98
  Route2 0.203: v99.16,243.69 24.38,168.91 24.38,165.66 B35.P1
  Bottom 0.203: v409.65,277.42 362.92,277.42 362.51,277.83 355.19,277.83 354.38,278.64 336.09,278.64 335.28,277.83 319.43,277.83 318.21,276.61 307.64,276.61 306.83,277.42 278.38,277.42 v277.98,277.01 | v250.75,204.27 250.34,203.86 240.18,203.86 B18.A1 | v99.16,243.69 100.38,244.91 101.6,244.91 102.41,245.72 186.94,245.72 v187.35,245.31
MEM07  (via drill 0.61)
  Top 0.203: v354.38,145.75 351.94,143.31 348.29,143.31 v348.29,144.12 | v229.62,164.44 231.65,162.41 231.65,154.28 232.87,153.06 B18.U2
  Route2 0.203: v311.3,162.81 311.3,162.41 v296.27,147.37 | v157.68,162.81 158.5,162.81 v161.75,166.06
  Route15 0.203: v348.29,144.12 347.88,144.12 347.07,144.93 345.85,144.93 v332.44,158.34 | v254.41,149 238.96,149 237.34,150.62 235.71,150.62 234.09,152.25 B18.U2
  Bottom 0.203: v354.38,145.75 359.26,145.75 360.48,146.96 405.18,146.96 407.21,149 AB04.BV2 | v332.44,158.34 331.62,159.16 330.4,159.16 329.18,160.38 322.68,160.38 319.84,163.22 311.71,163.22 v311.3,162.81 | v296.27,147.37 277.98,147.37 276.35,149 v254.41,149 | v157.68,162.81 157.28,163.22 147.12,163.22 144.27,160.38 25.6,160.38 24.38,159.16 B35.S1 | v161.75,166.06 162.15,166.47 164.59,166.47 165,166.88 227.18,166.88 v229.62,164.44
MEM08  (via drill 0.61)
  Top 0.203: v424.28,207.52 423.06,208.74 423.06,220.93 422.66,221.34 422.66,240.44 419,244.09 v419,276.2 | v226.77,214.83 226.77,203.86 B19.A1 | v101.6,196.54 114.61,209.55 v114.61,221.34
  Route2 0.203: v424.28,207.52 427.13,210.36 434.85,202.64 434.85,193.29 433.63,192.07 433.63,189.64 428.35,184.35 428.35,167.69 427.53,166.88 427.53,162.41 AB03.BR1 | v288.14,276.2 288.14,274.98 v241.81,228.65 230.84,217.68 229.62,217.68 v226.77,214.83
  Bottom 0.203: v419,276.2 398.68,276.2 398.27,276.61 363.73,276.61 362.92,275.79 361.29,275.79 360.48,276.61 353.97,276.61 353.57,277.01 336.91,277.01 336.5,276.61 321.46,276.61 320.65,275.79 306.83,275.79 306.43,276.2 v288.14,276.2 | v101.6,196.54 99.57,194.51 62.59,194.51 62.18,194.92 37.8,194.92 35.36,192.48 15.85,192.48 15.04,193.29 B35.D2 | v114.61,221.34 120.29,227.03 204.42,227.03 207.26,229.87 240.59,229.87 v241.81,228.65
MEM09  (via drill 0.61)
  Top 0.203: v117.86,181.1 120.29,178.66 120.29,161.59 117.86,159.16 v117.86,149.4
  Route2 0.203: v363.73,203.45 363.73,203.05 358.44,197.76 356.82,197.76 355.6,196.54 355.6,195.33 354.38,194.11 353.16,194.11 332.44,173.38 331.62,173.38 330.81,172.57 330.81,170.94 316.99,157.12 316.59,157.12 v306.83,147.37
  Route15 0.203: v363.73,203.45 363.73,203.05 389.33,177.44 390.55,177.44 418.19,149.81 420.22,149.81 AB03.BV2
  Bottom 0.203: v306.83,147.37 306.43,147.78 298.3,147.78 295.05,151.03 281.23,151.03 280.42,151.84 241,151.84 240.18,151.03 221.89,151.03 221.08,151.84 B19.U2 219.86,152.25 218.64,152.25 214.17,147.78 121.51,147.78 121.11,148.18 119.08,148.18 v117.86,149.4 | v117.86,181.1 110.13,188.82 32.92,188.82 32.51,188.42 30.89,188.42 30.07,189.23 18.69,189.23 17.88,190.04 B35.E2
MEM10  (via drill 0.61)
  Top 0.203: v443.38,232.31 441.35,230.28 441.35,213.21 440.94,212.8 440.94,163.22 440.13,162.41 AB02.BR1 | v102.41,185.17 102.01,185.57 102.01,195.73 v113.79,207.52
  Route2 0.203: v279.2,276.61 279.2,270.1 228.8,219.71 228.8,218.08 214.58,203.86 B20.A1
  Route15 0.203: v443.38,232.31 449.48,238.4 v410.87,277.01
  Bottom 0.203: v410.87,277.01 410.46,276.61 403.15,276.61 402.74,277.01 363.32,277.01 362.51,276.2 361.7,276.2 360.88,277.01 354.38,277.01 353.57,277.83 336.91,277.83 336.09,277.01 321.06,277.01 320.24,276.2 307.24,276.2 306.43,277.01 279.6,277.01 v279.2,276.61 | v102.41,185.17 102.01,185.57 29.67,185.57 26.82,182.73 18.69,182.73 17.88,183.54 B35.H2 | v113.79,207.52 121.51,215.24 143.05,215.24 143.46,215.65 166.62,215.65 175.97,206.3 208.89,206.3 211.73,203.45 213.77,203.45 B20.A1
MEM11  (via drill 0.61)
  Top 0.203: v189.79,185.98 190.6,185.17 190.6,167.69 205.64,152.65 207.26,152.65 B20.U2
  Route2 0.203: v343.81,195.33 342.6,195.33 341.38,194.11 340.56,194.11 338.94,192.48 334.87,192.48 327.15,184.76 327.15,180.7 316.59,170.13 306.02,170.13 v297.08,161.19
  Route15 0.203: v407.21,147.78 384.45,170.54 384.45,171.35 384.05,171.75 383.24,171.75 366.57,188.42 366.57,188.82 362.92,192.48 362.51,192.48 v360.48,194.51
  Bottom 0.203: v407.21,147.78 431.6,147.78 432.82,149 AB02.BV2 | v360.48,194.51 360.07,194.92 355.19,194.92 354.38,194.11 352.35,194.11 351.13,195.33 v343.81,195.33 | v297.08,161.19 296.67,160.78 275.54,160.78 274.32,162 244.65,162 239.78,157.12 204.42,157.12 203.61,156.31 203.61,153.06 207.67,153.06 B20.U2 | v189.79,185.98 159.72,185.98 154.03,191.67 138.58,191.67 138.18,192.07 16.26,192.07 16.26,190.04 17.48,188.82 21.95,188.82 21.95,186.79 21.13,185.98 9.75,185.98 9.75,183.54 13.82,179.48 15.04,179.48 16.66,177.85 B35.K2
MEM_ALT1\  (via drill 0.61)
  Top 0.203: v333.65,256.69 333.65,227.84 332.03,226.21 A10.T2 332.44,224.99 333.25,224.18 333.25,209.14 v333.65,208.74
  Route2 0.203: v451.92,87.22 450.7,86 450.7,85.19 440.94,75.44 440.94,62.84 437.69,59.59 437.69,53.09 434.04,49.43 434.04,48.62 417.78,32.36 417.78,29.11 D04.P1
  Route15 0.203: v451.92,87.22 451.92,87.63 451.1,88.44 451.1,92.91 436.47,107.54 436.47,108.36 427.94,116.89 427.94,117.7 409.65,135.99 409.65,137.21 371.04,175.82 366.57,175.82 365.35,177.04 365.35,177.44 363.32,179.48 362.92,179.48 351.94,190.45 351.94,190.86 350.32,192.48 349.91,192.48 v333.65,208.74
  Bottom 0.203: v333.65,256.69 337.72,256.69 A10.F1
MEM_ALT2\  (via drill 0.61)
  Top 0.203: v321.06,224.18 321.06,233.53 321.87,234.34 A11.P2 | v265.38,81.94 259.69,87.63 259.69,135.59 259.28,135.99 v259.28,181.51
  Route2 0.203: v271.48,180.7 271.48,181.1 290.58,200.2 290.58,201.42 291.8,202.64 291.8,212.39 294.64,215.24 295.45,215.24 295.86,215.65 298.7,215.65 301.55,218.49 301.55,219.71 302.36,220.52 303.58,220.52 304.39,221.34 304.39,223.37 306.02,224.99 A12.T2
  Route15 0.203: v265.38,81.94 302.77,44.55 302.77,43.74 335.28,11.23 346.25,11.23 353.16,4.32 373.07,24.23 408.43,24.23 408.84,23.83 410.06,25.04 413.71,25.04 D04.R1
  Bottom 0.203: v321.06,224.18 307.64,224.18 306.83,224.99 A12.T2 | v259.28,181.51 260.1,180.7 v271.48,180.7
MEM_BEGIN\  (via drill 0.61)
  Top 0.203: D17.S1 252.78,21.79 253.59,20.98 253.59,16.1 258.06,16.1 D16.U2 259.28,16.51 261.31,16.51 266.6,21.79 266.6,39.27 265.38,40.49 D16.K1 | A20.B1 211.73,269.7 216.21,269.7 216.21,269.29 217.02,268.48 223.11,268.48 223.11,269.7 A19.B1 224.33,270.51 224.33,271.32 230.84,271.32 231.24,270.92 231.24,270.51 236.12,270.51 A18.B1 236.93,270.51 236.93,274.57 237.74,274.57 | 237.74,274.57 240.18,274.57 244.25,270.51 248.72,270.51 A17.B1 | 237.74,274.57 237.74,201.42 236.93,200.61 B18.B1 | v227.18,42.93 225.15,44.96 225.15,158.75 222.3,161.59 222.3,198.17 223.52,199.39 B19.B1
  Bottom 0.203: 221.89,198.58 212.95,198.58 211.73,199.8 B20.B1 | 221.89,198.58 223.11,199.8 B19.B1 | 221.89,198.58 235.31,198.58 236.12,199.39 B18.B1 | v227.18,42.93 258.88,42.93 259.69,42.11 264.16,42.11 264.57,41.71 D16.K1
MEM_DONE\  (via drill 0.61)
  Top 0.203: v270.26,48.62 v270.26,80.31 | v331.22,48.62 331.22,50.24 D10.F2 | v404.77,120.14 403.96,119.33 403.96,118.52 403.56,118.11 403.56,113.64 403.96,113.23 403.96,112.01 403.56,111.61 403.56,109.17 405.18,107.54 405.59,107.54 405.99,107.14 405.99,94.94 403.15,92.1 403.15,54.3 400.3,51.46 v400.3,49.84
  Route15 0.203: v73.56,95.76 27.23,142.09 27.23,148.59 B34.V2
  Bottom 0.203: 400.3,49.43 419.4,49.43 420.22,50.24 CD03.BF2 | 400.3,49.43 337.31,49.43 336.91,49.84 333.25,49.84 332.44,50.65 D10.F2 | 244.25,81.13 245.06,80.31 v270.26,80.31 | 244.25,81.13 243.43,81.94 C17.V2 | v270.26,48.62 270.66,49.02 299.92,49.02 302.77,46.18 316.99,46.18 319.84,49.02 330.81,49.02 v331.22,48.62 | v404.77,120.14 406.81,120.14 407.21,120.55 C04.F2 | v400.3,49.84 400.3,49.43 | v73.56,95.76 76,93.32 120.7,93.32 129.64,84.38 133.3,84.38 133.71,83.97 133.71,80.72 163.37,80.72 163.78,81.13 170.69,81.13 171.91,79.91 229.21,79.91 230.43,81.13 244.25,81.13
MEM_ENABLE(0-4)  (via drill 0.61)
  Top 0.203: v318.21,195.33 317.81,195.73 317.81,230.28 | 317.81,230.28 317.81,279.45 314.15,283.11 311.71,283.11 311.71,281.48 312.52,280.67 312.52,270.51 A12.B1 | v319.84,230.28 317.81,230.28 | v377.14,203.45 377.55,203.05 377.55,186.79 375.11,184.35 375.11,150.62 375.92,149.81 AB07.BV1 | v361.29,223.77 361.7,224.18 361.7,230.68 360.48,231.9 360.48,234.34 A08.P2
  Route15 0.203: v377.14,203.45 378.76,205.08 369.42,214.43 369.42,215.65 v361.29,223.77
  Bottom 0.203: AB07.BU2 373.48,151.84 373.89,151.84 375.92,149.81 AB07.BV1 376.73,149.81 377.95,151.03 387.3,151.03 | 387.3,151.03 386.49,151.84 386.08,151.84 AB06.BU2 | 387.3,151.03 387.71,150.62 | 387.71,150.62 388.52,149.81 AB06.BV1 | 387.71,150.62 396.65,150.62 397.87,151.84 AB05.BU2 | v318.21,195.33 314.55,195.33 313.33,194.11 B12.D1 | v319.84,230.28 360.07,230.28 360.07,234.34 A08.P2
MEM_ENABLE(5-11)  (via drill 0.61)
  Top 0.203: v330.81,125.42 330.4,125.83 v330.4,138.43 | v401.52,138.43 401.52,148.59 AB05.BV1 | v347.47,231.09 347.47,234.34 A09.P2 | v340.16,223.37 339.75,222.96 v339.75,138.43
  Route2 0.203: v347.47,231.09 347.47,230.68 v340.16,223.37
  Route15 0.203: v315.77,125.83 315.77,124.61 C12.E1
  Bottom 0.203: AB02.BV1 439.32,149.81 438.91,149.81 436.88,151.84 AB02.BU2 436.07,151.84 434.85,150.62 425.5,150.62 | 425.5,150.62 426.31,149.81 426.72,149.81 AB03.BV1 | 425.09,151.03 425.5,150.62 | 425.09,151.03 424.28,151.84 AB03.BU2 | 425.09,151.03 416.56,151.03 414.93,149.4 AB04.BV1 414.12,149.81 413.71,149.81 411.68,151.84 AB04.BU2 410.46,152.25 408.84,150.62 403.56,150.62 402.34,149.4 AB05.BV1 | v315.77,125.83 316.18,125.42 v330.81,125.42 | v401.52,138.43 v339.75,138.43 v330.4,138.43
MEM_IDLE  (via drill 0.61)
  Top 0.203: v408.43,68.12 406.81,69.75 406.81,83.97 409.25,86.41 409.25,106.73 412.5,109.98 412.5,111.61 412.09,112.01 412.09,116.48 411.68,116.89 C04.H2
  Bottom 0.203: v408.43,68.12 415.75,68.12 416.97,66.9 D04.A1
MEM_P  (via drill 0.61)
  Top 0.203: v65.02,199.39 65.84,200.2 65.84,248.56 65.43,248.97 65.43,257.91 v82.91,275.39
  Bottom 0.203: v65.02,199.39 63.8,198.17 22.35,198.17 21.13,199.39 B35.B1 | v82.91,275.39 83.31,274.98 105.66,274.98 106.07,275.39 250.34,275.39 251.97,273.76 A17.A1
MEM_RET
  Top 0.508: A26.B2 128.02,269.29 127.2,268.48 127.2,201.42 128.02,200.61 B26.B2
  Route2 0.508: B28.L2 103.23,175.41 103.23,177.04 124.36,198.17 126.39,198.17 128.02,199.8 B26.B2
  Bottom 0.508: A26.B2 129.24,270.1 130.45,271.32 139.4,271.32 140.61,270.1 A25.B2 | B25.B2 140.61,199.8 139.8,198.98 136.14,198.98 135.74,198.58 130.45,198.58 129.24,199.8 B26.B2
MEM_START  (via drill 0.61)
  Top 0.203: v299.52,79.1 297.49,81.13 297.49,85.19 C13.U2 | v258.06,90.07 257.66,89.66 257.66,69.75 261.72,65.68 261.72,64.06 D16.B1
  Route2 0.203: v266.19,63.65 289.76,87.22 295.05,87.22 296.27,86 C13.U2 | v371.04,33.58 373.89,33.58 407.62,67.31 407.62,69.75 410.06,72.19 410.06,76.66 411.68,78.28 412.09,78.28 432,98.2 432,99.01 432.82,99.82 432.82,101.04 C02.N2
  Route15 0.203: v371.04,33.58 345.85,33.58 340.16,39.27 339.34,39.27 v299.52,79.1 | v125.17,161.19 136.14,150.22 136.14,149 v189.38,95.76
  Bottom 0.203: v266.19,63.65 262.53,63.65 D16.B1 | v125.17,161.19 124.77,160.78 115.01,160.78 112.57,163.22 32.51,163.22 30.89,164.85 B34.P2 | v189.38,95.76 194.26,90.88 231.65,90.88 232.46,90.07 v258.06,90.07
MEM_SUPPLY+  (via drill 0.61)
  Top 0.508: B24.U2 157.28,153.06 157.28,154.69 160.12,157.53 160.12,158.34 162.97,158.34 B24.S1 163.78,159.56 165.41,161.19 165.41,169.72 166.22,170.54 166.22,174.19 B23.L2 | A24.L2 154.43,244.09 158.9,244.09 158.9,243.69 159.72,242.88 166.22,242.88 166.22,244.09 A23.L2 | A23.S1 175.56,229.06 174.75,229.87 174.75,245.72 175.97,246.94 A23.K1 | B28.R2 103.63,162.41 105.66,164.44 105.66,164.85 B28.P2 105.66,165.25 105.66,165.66 103.63,167.69 B28.N2 | A26.E2 131.67,259.54 130.45,258.32 130.45,253.03 128.83,251.41 A26.J2 128.83,250.19 129.64,249.38 129.64,245.72 130.45,244.91 130.45,226.21 131.67,224.99 131.67,222.96 A26.U2 | B25.E2 144.27,191.26 142.65,192.89 142.65,206.7 139.8,209.55 139.8,215.24 143.87,219.3 143.87,221.74 A25.U2 | v153.21,185.17 153.21,182.73 152.4,181.91 152.4,180.29 153.21,179.48 153.21,175.82 153.62,175.41 B24.L2
  Route2 0.508: A23.L2 167.44,244.5 171.09,244.5 172.72,246.13 174.35,246.13 175.56,247.34 A23.K1 | B27.M2 119.48,172.16 119.48,174.19 127.61,182.32 130.05,182.32 131.27,183.54 B26.H2 | A23.S1 175.56,228.24 173.53,228.24 171.5,226.21 171.5,224.18 170.28,222.96 A23.U2
  Bottom 0.508: B24.U2 157.68,152.65 158.9,153.87 165,153.87 166.22,152.65 169.06,152.65 B23.U2 | B23.S1 175.56,159.16 174.35,160.38 165.81,160.38 164.59,159.16 164.19,159.16 B24.S1 | B24.L2 154.43,175.01 155.65,176.22 161.75,176.22 162.97,177.44 B24.K1 163.78,177.04 164.19,177.04 166.22,175.01 B23.L2 167.44,175.01 169.06,175.01 170.69,176.63 174.75,176.63 175.56,177.44 B23.K1 | 105.26,170.13 104.04,168.91 103.63,168.91 B28.N2 | 105.26,170.13 106.07,170.94 B28.M2 | 105.26,170.13 117.04,170.13 118.26,171.35 B27.M2 | A25.J2 140.61,251 139.4,252.22 130.45,252.22 129.24,251 A26.J2 | B26.H2 132.49,184.35 134.11,185.98 136.55,185.98 140.61,190.04 143.87,190.04 B25.E2 145.09,190.04 148.34,190.04 v153.21,185.17 | A26.U2 132.49,222.56 133.71,223.77 142.65,223.77 143.87,222.56 A25.U2 145.09,221.74 145.9,220.93 167.84,220.93 169.06,222.15 A23.U2
MEM_SUPPLY-  (via drill 0.61)
  Top 0.508: A26.M2 131.67,242.06 131.27,242.47 131.27,246.13 130.45,246.94 130.45,251.82 131.27,252.63 131.27,253.44 A26.H2 | 143.87,187.2 143.87,185.17 144.27,184.76 B25.H2 | 143.87,187.2 142.24,188.82 140.21,188.82 140.21,188.42 139.8,188.01 139.8,185.98 141.02,184.76 141.02,181.51 B25.J2 141.43,180.29 143.05,178.66 143.05,154.28 144.27,153.06 B25.U2 | v40.23,144.93 37.39,142.09 37.39,96.57 37.8,96.16 37.8,14.88 39.42,13.26 D33.V2 | B28.U2 105.66,152.65 105.66,153.06 103.63,155.09 B28.T2 103.63,155.91 103.63,156.31 105.66,158.34 B28.S2 | v147.93,207.92 145.9,205.89 145.9,189.23 143.87,187.2
  Route2 0.508: v147.93,207.92 153.62,213.61 153.62,218.49 A24.V2
  Route15 0.508: A24.V2 153.62,219.71 153.62,221.74 135.74,239.62 134.11,239.62 132.49,241.25 A26.M2
  Bottom 0.508: A24.V2 154.43,218.49 155.25,217.68 165.41,217.68 166.22,218.49 A23.V2 | A25.H2 143.87,253.85 140.61,253.85 138.99,255.47 133.71,255.47 132.49,254.25 A26.H2 | B26.J2 129.24,180.7 130.45,179.48 136.96,179.48 138.18,180.7 140.61,180.7 B25.J2 | v40.23,144.93 41.45,146.15 73.97,146.15 76.81,149 102.41,149 B28.V2 103.63,149.81 104.04,149.81 105.26,151.03 | 105.26,151.03 106.07,151.84 B28.U2 | 114.61,150.62 114.2,151.03 105.26,151.03 | 114.61,150.62 115.42,149.81 B27.V2 | 130.45,151.03 130.05,150.62 114.61,150.62 | 130.45,151.03 131.27,151.84 B26.U2 | 143.05,151.03 143.87,151.84 B25.U2 | 130.45,151.03 143.05,151.03 | 151.99,150.62 151.59,151.03 143.05,151.03 | 151.99,150.62 153.21,149.4 B24.V2 | 151.99,150.62 165.41,150.62 166.22,149.81 B23.V2
MEMORY_INCREMENT  (via drill 0.61)
  Top 0.203: v254.41,181.91 251.16,178.66 251.16,109.17 v252.37,107.95
  Route2 0.203: v254.41,181.91 277.17,204.67 277.17,205.08 302.77,230.68 304.39,230.68 305.21,231.5 305.61,231.5 A12.R2
  Route15 0.203: v252.37,107.95 252.78,107.95 271.88,88.85 272.69,88.85 305.61,55.93 306.43,55.93 307.24,55.12 307.24,54.3 315.37,46.18 317.4,46.18 318.62,44.96 D11.J2
MFTP0  (via drill 0.61)
  Top 0.203: B08.B1 364.13,199.8 366.17,197.76 366.17,197.36 B08.C1 366.17,196.54 366.17,196.14 364.13,194.11 B08.D1 363.73,192.89 365.35,191.26 v365.35,188.01 | v271.48,80.31 271.48,85.19 C15.U2 | v419.81,83.97 420.22,84.38 420.22,88.44 CD03.AT2 | v426.72,124.21 427.94,122.99 427.94,121.77 428.75,120.95 428.75,90.07 v429.56,89.26
  Route15 0.203: v365.35,188.01 365.35,187.6 403.15,149.81 403.15,147.78 v426.72,124.21
  Bottom 0.203: v271.48,80.31 416.15,80.31 v419.81,83.97 | 429.56,90.07 422.25,90.07 421.44,89.26 CD03.AT2 | 429.56,90.07 432,90.07 432.82,89.26 C02.T2 | v429.56,89.26 429.56,90.07
MFTP1  (via drill 0.61)
  Top 0.203: v275.54,34.8 276.35,33.98 276.35,20.98 296.27,1.07 357.23,1.07 357.23,8.38 366.57,17.73 384.05,17.73 384.05,64.47 383.64,64.87 v383.64,77.88
  Route2 0.203: D17.L2 243.43,38.46 243.43,38.86 245.47,40.89 D17.K2 | CD03.AE2 423.47,123.39 421.84,121.77 421.84,119.74 401.52,99.42 399.9,99.42 399.08,98.6 C05.P2 398.27,97.79 396.65,96.16 396.65,94.54 385.67,83.57 385.67,81.13 383.64,79.1 v383.64,77.88
  Bottom 0.203: v275.54,34.8 273.91,36.42 249.12,36.42 248.31,37.24 243.84,37.24 243.43,37.64 D17.L2
MFTP2  (via drill 0.61)
  Top 0.203: v437.29,107.95 437.69,107.54 437.69,99.82 436.88,99.01 C02.P2 436.88,97.79 437.69,96.98 v437.69,77.47 | v353.57,68.94 354.38,69.75 v354.38,72.19 | v419.4,68.53 419.4,59.18 420.62,57.96 CD03.BD2 | v336.09,246.53 336.5,246.13 336.5,196.14 336.09,195.73 336.09,104.29 336.5,103.89 336.5,77.06 335.28,75.84 v335.28,69.75
  Bottom 0.203: v437.29,107.95 439.32,107.95 C02.L1 | 335.28,68.53 349.91,68.53 350.32,68.94 v353.57,68.94 | 335.28,68.53 328.37,68.53 327.56,67.72 323.9,67.72 323.49,68.12 317.81,68.12 316.59,66.9 D12.A1 | v354.38,72.19 361.29,79.1 403.56,79.1 414.12,68.53 v419.4,68.53 419.4,68.94 429.16,68.94 v437.69,77.47 | v336.09,246.53 335.69,246.13 305.21,246.13 303.99,247.34 A13.K1 | 335.28,68.53 v335.28,69.75
MFTS0  (via drill 0.61)
  Top 0.203: v413.31,42.93 412.9,43.33 412.9,51.46 414.93,53.49 416.97,53.49 D04.E1 418.19,53.49 418.19,52.68 424.28,52.68 425.09,53.49 425.09,103.48 424.28,104.29 CD03.AM2
  Bottom 0.203: v413.31,42.93 385.67,42.93 382.83,40.08 365.76,40.08 362.1,43.74 359.26,43.74 358.44,42.93 356.82,42.93 356.41,43.33 352.35,43.33 351.54,44.15 D09.J1
MFTS1  (via drill 0.61)
  Route2 0.203: v332.84,100.23 334.06,100.23 343.41,109.58 349.1,109.58 356.41,116.89 v356.82,116.89
  Bottom 0.203: v332.84,100.23 331.22,100.23 328.37,103.07 320.65,103.07 316.59,107.14 313.74,107.14 313.33,107.54 C12.L1 | v356.82,116.89 359.26,119.33 413.71,119.33 418.19,114.86 420.22,114.86 CD03.AJ2
MFTS1\  (via drill 0.61)
  Top 0.203: D04.F1 414.93,51.05 419.4,51.05 419.4,51.46 420.22,52.27 425.5,52.27 425.5,109.17 424.28,110.39 CD03.AK2
  Route2 0.203: v311.71,147.78 284.89,120.95 279.2,126.64 275.13,126.64 C15.D1
  Route15 0.203: v365.35,149.81 365.35,148.18 371.04,142.49 375.92,142.49 v401.93,116.48
  Bottom 0.203: v311.71,147.78 315.77,147.78 319.02,151.03 337.31,151.03 338.12,151.84 339.75,151.84 340.56,151.03 364.13,151.03 v365.35,149.81 | v401.93,116.48 402.74,115.67 416.56,115.67 421.03,111.2 423.06,111.2 CD03.AK2
MFTS2  (via drill 0.61)
  Top 0.203: v314.55,252.22 314.15,251.82 314.15,220.93 312.93,219.71 A12.V1 | v324.71,192.07 324.31,191.67 324.31,177.04 v325.12,176.22
  Route15 0.203: v389.74,122.17 384.45,122.17 380.39,126.24 378.76,126.24 376.73,128.27 373.07,128.27 365.35,135.99 365.35,137.21 345.03,157.53 345.03,159.16 333.65,170.54 333.65,172.97 332.44,174.19 B10.L2 | v324.71,192.07 320.24,196.54 320.24,201.02 319.84,201.42 319.84,210.36 316.18,214.02 316.18,215.24 312.93,218.49 A12.V1
  Bottom 0.203: v314.55,252.22 310.49,252.22 309.27,251 306.83,251 A12.J2 | v389.74,122.17 395.83,122.17 397.05,120.95 398.27,120.95 399.49,122.17 419,122.17 420.22,120.95 CD03.AF2 | v325.12,176.22 325.53,175.82 330.4,175.82 331.22,175.01 B10.L2
MFTS2\  (via drill 0.61)
  Top 0.203: v432,53.9 431.6,54.3 431.6,75.84 425.91,81.53 425.91,115.27 424.28,116.89 CD03.AH2 | v351.94,46.58 355.19,43.33 v355.19,31.55 | v415.34,30.33 416.15,31.14 416.15,45.77 417.37,46.99 D04.H1
  Route15 0.203: v351.94,46.58 351.54,46.58 330.4,67.72 330.4,69.75 325.12,75.03 325.12,76.25 320.65,80.72 319.84,80.72 319.43,81.13 318.62,81.13 307.64,92.1 306.83,92.1 306.43,92.51 306.43,92.91 285.29,114.05 285.29,118.52 280.42,123.39 278.38,123.39 C15.E1
  Bottom 0.203: v432,53.9 430.78,52.68 426.72,52.68 422.66,48.62 419,48.62 418.19,47.8 D04.H1 | v355.19,31.55 356.41,30.33 v415.34,30.33
MFTS3  (via drill 0.61)
  Top 0.203: v303.17,219.3 302.36,218.49 v302.36,207.92 | v299.11,204.27 298.7,203.86 298.7,198.98 301.14,196.54 301.14,195.73 300.33,194.92 295.45,194.92 295.45,185.98 294.23,184.76 294.23,182.32 295.05,181.51 295.05,165.25 291.8,162 291.8,144.93 v291.39,144.53 | v307.24,123.8 307.64,123.39 307.64,106.73 306.43,105.51 306.43,103.48 307.64,102.26 307.64,99.01 v307.24,98.6
  Route2 0.203: v303.17,219.3 303.58,219.3 317.81,233.53 323.09,233.53 324.31,234.75 325.12,234.75 327.96,237.59 331.22,237.59 A10.N2 | v302.36,207.92 302.36,207.52 v299.11,204.27
  Route15 0.203: v360.88,42.93 335.69,68.12 335.28,68.12 334.06,69.34 334.06,69.75 316.18,87.63 316.18,91.29 C12.S1 315.37,92.51 314.15,93.73 312.12,93.73 v307.24,98.6 | v291.39,144.53 289.36,142.49 295.45,136.4 295.45,135.99 307.24,124.21 v307.24,123.8
  Bottom 0.203: v360.88,42.93 364.13,39.68 386.08,39.68 386.89,40.49 390.96,40.49 391.36,40.08 441.35,40.08 442.16,40.89 D02.K1
MP_SKIP\  (via drill 0.61)
  Route2 0.203: v258.88,231.9 170.69,143.71 170.69,141.68 129.24,100.23 129.24,95.76 C26.R2
  Bottom 0.203: v258.88,231.9 280.42,231.9 A14.R2
N$1
  Bottom 0.203: C02.S2 437.29,92.51 438.1,93.32 446.23,93.32 447.45,94.54 447.45,96.57 441.76,96.57 440.54,95.35 C02.R1
N$2
  Route15 0.203: C02.N1 439.32,102.26 437.29,102.26 435.25,104.29 435.25,105.51 433.63,107.14 C02.L2
N$3
  Route2 0.203: D04.D1 414.53,57.96 414.53,61.62 415.75,62.84 415.75,67.72 419,70.97 419,71.78 419.4,72.19 419.4,73 440.94,94.54 440.94,96.16 442.57,97.79 C02.P1
  Bottom 0.203: C02.M2 436.88,104.29 436.88,99.82 440.94,99.82 442.16,98.6 C02.P1
N$4
  Top 0.203: D05.R2 395.83,25.86 400.3,25.86 400.3,47.4 404.37,51.46 404.37,53.49 D05.E1
N$5  (via drill 0.61)
  Top 0.203: v399.49,32.77 399.9,33.17 399.9,45.77 398.68,46.99 D05.H2
  Bottom 0.203: v399.49,32.77 399.9,33.17 421.44,33.17 428.75,25.86 432.82,25.86 D02.R2
N$6  (via drill 0.61)
  Top 0.203: v405.18,90.47 403.56,88.85 403.56,53.09 401.93,51.46 D05.F1 | v414.12,99.42 416.15,101.45 416.15,116.08 416.97,116.89 C04.H1
  Route2 0.203: v414.12,99.42 v405.18,90.47
N$7
  Bottom 0.203: D04.J1 414.93,44.15 416.15,42.93 438.51,42.93 439.32,43.74 D02.J1
N$8  (via drill 0.61)
  Top 0.203: 390.96,46.18 390.96,52.68 391.77,53.49 D06.E1 | 390.96,46.18 390.96,30.33 388.11,30.33 387.71,30.73 387.71,32.77 386.08,34.39 D06.M2 | 390.96,46.18 v392.99,46.18
  Bottom 0.203: v392.99,46.18 403.56,46.18 404.37,46.99 D05.H1
N$9
  Top 0.203: D06.T2 382.42,19.76 380.8,21.39 380.8,45.77 379.58,46.99 D07.H1
  Bottom 0.203: D06.H1 391.36,47.8 390.14,49.02 380.8,49.02 379.98,48.21 D07.H1
N$10  (via drill 0.61)
  Top 0.203: v371.86,70.56 371.86,49.02 372.67,48.21 D07.H2 | v405.18,73.81 405.99,74.62 405.99,91.29 405.59,91.69 C05.S1
  Bottom 0.203: v371.86,70.56 372.26,70.97 396.24,70.97 397.05,70.16 401.52,70.16 v405.18,73.81
N$11
  Route15 0.203: D02.S1 442.57,23.01 442.57,27.08 441.76,27.89 441.76,39.27 432.41,48.62 432.41,49.84 428.75,53.49 428.75,64.47 426.31,66.9 426.31,68.94 414.12,81.13 413.71,81.13 412.9,81.94 412.9,83.97 411.68,85.19 C04.U2
N$12
  Route2 0.203: C05.D1 402.34,127.46 404.37,129.49 C05.C1
N$13  (via drill 0.61)
  Top 0.203: v365.76,42.52 366.57,43.33 366.57,46.99 D08.H1
  Bottom 0.203: v365.76,42.52 371.04,42.52 372.26,41.3 D07.K2
N$14
  Top 0.203: D07.N2 370.64,31.95 375.11,31.95 375.11,41.3 377.55,43.74 377.55,47.8 377.14,48.21 377.14,49.84 378.76,51.46 378.76,53.49 D07.E1
N$15  (via drill 0.61)
  Top 0.203: v372.26,46.18 375.51,46.18 375.51,50.65 D07.F1 376.73,51.46 377.55,52.27 377.55,69.75 v379.98,72.19 | v395.02,78.28 397.05,80.31 397.05,99.01 397.87,99.82 397.87,104.29 C05.M2
  Route15 0.203: C05.M2 397.87,105.1 397.46,105.1 395.43,107.14 C05.L2
  Bottom 0.203: v372.26,46.18 361.7,46.18 360.88,46.99 D08.H2 | v395.02,78.28 388.93,72.19 v379.98,72.19
N$16
  Top 0.203: D08.V2 357.63,13.26 358.85,14.48 358.85,18.14 364.95,24.23 364.95,52.27 366.17,53.49 D08.E1
N$19  (via drill 0.61)
  Top 0.203: v357.63,86.41 356.01,84.78 356.01,76.66 358.44,74.22 358.44,20.98 353.57,20.98 352.75,21.79 352.75,23.01 351.13,24.64 D09.R1
  Route2 0.203: v357.63,86.41 358.04,86.41 362.1,90.47 363.32,90.47 366.17,93.32 369.82,93.32 390.55,114.05 391.36,114.05 v392.18,114.86
  Route15 0.203: v392.18,114.86 392.18,115.27 390.96,116.48 390.96,120.55 390.55,120.95 390.55,122.58 376.73,136.4 376.33,136.4 375.92,136.8 375.92,137.62 376.73,138.43 378.76,136.4 C07.A1
N$20  (via drill 0.61)
  Top 0.203: v390.96,113.23 390.96,99.82 391.77,99.01 C06.P1 | v378.36,116.08 377.95,116.48 377.95,131.52 376.73,132.74 C07.B1
  Bottom 0.203: v390.96,113.23 390.55,112.83 381.61,112.83 v378.36,116.08
N$21
  Route15 0.203: C02.V2 433.22,83.16 433.22,84.78 429.56,88.44 429.16,88.44 428.35,89.26 428.35,89.66 424.69,93.32 423.88,93.32 422.25,94.94 422.25,95.76 405.59,112.42 404.37,112.42 401.12,109.17 401.52,108.76 C05.L1
N$22
  Route15 0.203: D01.N1 451.92,32.36 451.92,36.83 451.1,37.64 451.1,48.62 448.26,51.46 448.26,53.09 447.85,53.49 447.85,64.06 441.76,70.16 441.76,72.19 425.91,88.04 425.91,89.26 423.88,91.29 CD03.AS2
N$23  (via drill 0.61)
  Top 0.203: v336.91,64.47 338.12,65.68 v338.12,73 | v379.98,125.42 379.58,125.83 379.58,129.49 C07.C1
  Route2 0.203: v336.91,64.47 317.81,45.36 317.81,44.55 316.59,43.33 316.59,41.71 D12.K1 | v338.12,73 338.53,73 353.16,87.63 353.97,87.63 357.23,90.88 357.63,90.88 358.04,91.29 358.04,92.51 372.26,106.73 372.26,108.36 390.14,126.24 390.14,128.68 388.11,130.71 384.05,126.64 384.05,126.24 383.64,125.83 380.39,125.83 v379.98,125.42
N$24
  Bottom 0.203: D11.N2 319.84,31.95 321.46,33.58 333.65,33.58 334.47,34.39 D10.M2
N$25
  Bottom 0.203: D12.N2 306.83,31.14 307.64,30.33 310.49,30.33 311.71,29.11 315.37,29.11 D12.P1
N$26
  Top 0.203: 368.61,125.02 369.82,126.24 C07.D2 | 368.61,125.02 368.2,124.61 368.2,119.33 366.98,118.11 C08.H1 | 368.61,125.02 368.61,133.15 364.13,133.15 C08.B1
  Bottom 0.203: C08.D2 357.63,127.46 358.04,127.86 362.51,127.86 362.92,128.27 364.54,128.27 365.35,127.46 369.42,127.46 C07.D2
N$27  (via drill 0.61)
  Top 0.203: v353.16,77.06 352.35,77.88 352.35,91.69 349.1,94.94 349.1,114.45 v348.69,114.86
  Route2 0.203: v353.57,70.97 351.54,68.94 351.54,67.72 349.1,65.28 336.09,65.28 312.52,41.71 310.08,41.71 D12.K2 | v348.69,114.86 348.69,115.67 350.32,117.3 351.94,117.3 359.66,125.02 360.07,125.02 360.48,125.42 360.48,128.27 364.95,132.74 364.95,134.77 366.17,135.99 C08.A1
  Bottom 0.203: v353.57,70.97 353.57,77.06 v353.16,77.06
N$28  (via drill 0.61)
  Top 0.203: v304.39,39.27 304.39,23.83 303.58,23.01 D13.S1 | v330.4,71.37 330.4,84.38 v332.84,86.82 | v365.76,116.08 365.35,116.48 365.35,128.27 366.57,129.49 C08.C1
  Route2 0.203: v304.39,39.27 304.39,45.36 v330.4,71.37 | v332.84,86.82 333.25,86.82 334.06,87.63 334.87,87.63 337.31,90.07 341.38,90.07 364.95,113.64 364.95,115.27 v365.76,116.08
N$29  (via drill 0.61)
  Top 0.203: v336.91,76.25 336.09,75.44 336.09,38.46 333.65,36.02 v333.65,10.41
  Route15 0.203: v336.91,76.25 335.28,77.88 335.28,85.19 C10.U2
  Bottom 0.203: v333.65,10.41 334.47,9.6 399.49,9.6 400.3,10.41 435.25,10.41 440.54,15.7 442.16,15.7 D02.U1
N$30  (via drill 0.61)
  Top 0.203: v378.36,20.98 368.2,20.98 368.2,22.61 367.79,23.01 367.79,27.48 368.2,27.89 368.2,70.97 368.61,71.37 368.61,92.1 371.45,94.94 371.45,105.92 370.23,107.14 C07.L2
  Bottom 0.203: v378.36,20.98 405.59,20.98 407.21,19.36 D04.T2
N$31
  Top 0.203: D04.V2 408.43,13.26 412.9,13.26 414.93,15.29 416.97,15.29 D04.U1
N$32  (via drill 0.61)
  Route2 0.203: v363.32,110.79 357.23,104.7 357.23,103.48 356.82,103.07 356.41,103.07 336.09,82.75 332.44,82.75 C10.V2
  Bottom 0.203: v363.32,110.79 364.13,109.98 371.45,109.98 372.26,110.79 C07.K2
N$36
  Top 0.203: D12.N1 312.52,32.36 310.9,33.98 310.9,36.83 305.61,42.11 305.61,43.33 304.8,44.15 304.8,56.74 303.58,57.96 303.58,59.59 D13.C1
N$37  (via drill 0.61)
  Top 0.203: v350.72,68.12 351.94,69.34 351.94,77.47 348.29,81.13 348.29,85.19 C09.U2
  Route2 0.203: v350.72,68.12 335.28,68.12 334.06,69.34 330.81,69.34 329.59,68.12 327.96,68.12 327.15,67.31 327.15,66.9 326.34,66.09 325.93,66.09 312.93,53.09 312.93,51.46 D12.F1
N$38  (via drill 0.61)
  Top 0.203: v343.81,87.22 343.81,83.57 344.22,83.16 C09.V2
  Route15 0.203: v343.81,87.22 343.81,87.63 327.15,104.29 327.15,105.51 325.53,107.14 C11.L1
N$39  (via drill 0.61)
  Top 0.203: v359.26,236.37 359.66,236.78 359.66,240.84 A08.M2 360.07,242.06 358.85,243.28 358.85,252.22 356.41,252.22 356.01,251.82 356.01,245.72 356.82,244.91 A08.L2
  Bottom 0.203: v359.26,236.37 356.41,233.53 340.56,233.53 338.94,231.9 A10.R1
N$40  (via drill 0.61)
  Top 0.203: v97.54,184.76 108.1,174.19 108.1,148.18 111.35,144.93 111.35,131.52 112.17,130.71 C28.C1
  Route15 0.203: v97.54,184.76 50.8,231.5 50.39,231.5 23.98,257.91 23.98,259.54 A35.E1
N$41  (via drill 0.61)
  Top 0.203: v312.52,129.9 312.52,129.08 311.3,127.86 311.3,122.58 312.52,121.36 C12.F1 | v313.74,144.93 314.15,145.34 314.15,164.03 314.55,164.44 314.55,175.41 312.12,177.85 v312.12,179.07 | v315.37,186.38 315.37,190.04 B12.E1 | v323.9,214.02 323.49,213.61 323.49,200.2 321.06,197.76 321.06,194.51 320.24,193.7 v320.24,188.42
  Route2 0.203: v319.84,137.21 v312.52,129.9 | v312.12,179.07 310.08,181.1 v315.37,186.38 | v323.9,214.02 347.07,237.19 347.07,240.84 A09.M2
  Route15 0.203: v319.84,137.21 319.84,138.84 v313.74,144.93
  Bottom 0.203: v320.24,188.42 320.24,190.04 316.59,190.04 B12.E1
N$42  (via drill 0.61)
  Top 0.203: v248.31,173.38 249.94,175.01 249.94,209.14 251.16,210.36 251.16,250.19 v251.56,250.6 | v356.01,279.04 356.01,264.82 356.82,264.01 A08.D2
  Route2 0.203: v251.56,250.6 251.56,251 253.59,253.03 253.59,256.69 v270.66,273.76
  Route15 0.203: v303.17,113.23 291.39,125.02 287.32,125.02 286.11,126.24 286.11,131.12 277.98,139.24 277.98,141.68 277.17,142.49 277.17,144.53 v248.31,173.38
  Bottom 0.203: v303.17,113.23 303.58,112.83 310.9,112.83 312.12,114.05 C12.J1 | v270.66,273.76 273.91,277.01 275.95,277.01 277.17,278.23 307.64,278.23 308.46,277.42 317.4,277.42 318.62,278.64 334.47,278.64 335.28,279.45 355.6,279.45 v356.01,279.04
N$43  (via drill 0.61)
  Route2 0.203: v291.39,101.85 288.95,104.29 288.14,104.29 284.48,107.95 300.33,123.8 301.14,123.8 315.37,138.02 316.18,138.02 342.6,164.44 342.6,168.5 351.13,177.04 v351.54,177.04 | v364.54,179.48 364.54,179.88 364.95,180.29 364.95,184.35 372.26,191.67 376.33,191.67 382.02,197.36 v382.42,197.36
  Route15 0.203: v382.42,197.36 385.27,200.2 383.64,201.83 383.64,202.64 361.7,224.59 361.7,225.4 358.85,228.24 358.85,229.87 357.63,231.09 A08.R2
  Bottom 0.203: v291.39,101.85 293.01,100.23 310.9,100.23 312.12,101.45 C12.N1 | v351.54,177.04 353.97,179.48 v364.54,179.48
N$44  (via drill 0.61)
  Route2 0.203: v253.19,165.66 254.41,165.66 259.69,170.94 259.69,173.38 263.75,177.44 263.75,180.7 289.36,206.3 289.36,211.58 293.01,215.24 293.01,215.65 308.05,230.68 v308.05,231.09
  Route15 0.203: v253.19,165.66 277.57,141.28 277.57,138.84 282.85,133.55 282.85,129.49 283.67,128.68 283.67,125.42 284.07,125.02 284.89,125.02 292.2,117.7 292.2,113.64 297.49,108.36 299.52,108.36 C13.L1
  Bottom 0.203: v308.05,231.09 310.49,233.53 330.4,233.53 333.65,236.78 342.6,236.78 343.81,238 A09.N2
N$45  (via drill 0.61)
  Top 0.203: A08.F2 357.63,256.69 359.66,254.66 359.66,254.25 A08.H2 | v343,156.72 343,246.53 347.07,250.6 347.07,253.44 A09.H2 347.07,254.25 347.07,254.66 345.03,256.69 A09.F2 345.03,257.5 345.03,257.91 347.07,259.94 A09.E2 347.07,260.76 347.07,261.16 345.03,263.2 A09.D2
  Bottom 0.203: A08.E2 360.07,259.54 358.04,257.5 357.63,257.5 A08.F2 356.41,257.5 354.79,259.13 349.1,259.13 348.29,259.94 A09.E2 | v343,156.72 333.25,156.72 332.44,155.91 B10.T2
N$46
  Top 0.203: C13.H1 302.77,118.11 301.95,118.92 301.95,195.33 302.77,196.14 B13.C1
N$47  (via drill 0.61)
  Top 0.203: v342.19,95.35 342.6,94.94 342.6,39.68 343,39.27 343,20.98 344.22,19.76 D09.T2 | v344.63,97.79 343.81,98.6 343.81,100.23 343,101.04 343,155.5 342.19,156.31 342.19,157.94 342.6,158.34 342.6,248.56 v342.19,248.97 | A09.H1 353.57,253.44 351.54,251.41 351.54,251 A09.J1
  Route2 0.203: v344.63,97.79 v342.19,95.35
  Bottom 0.203: v342.19,248.97 342.6,249.38 349.5,249.38 350.32,250.19 A09.J1
N$48  (via drill 0.61)
  Top 0.203: v342.19,29.92 342.6,29.52 342.6,14.88 344.22,13.26 D09.V2
  Bottom 0.203: v342.19,29.92 342.19,33.98 346.66,33.98 347.07,34.39 D09.M2
N$49  (via drill 0.61)
  Top 0.203: A09.T2 344.22,226.21 344.22,231.09 A09.R2 345.03,232.31 345.85,233.12 345.85,235.97 347.47,237.59 347.47,238 347.88,238.4 349.1,238.4 349.1,229.87 348.29,229.06 A09.S2 347.47,227.84 347.47,222.96 A09.U2 347.47,221.74 347.47,216.46 v347.88,216.05 | v351.54,54.71 349.5,54.71 349.5,60 352.75,63.25 352.75,74.62 353.97,75.84 353.97,83.57 355.19,84.78 355.19,90.47 355.6,90.88 v355.6,216.05
  Route2 0.203: v351.54,54.71 349.5,52.68 349.5,50.24 348.29,49.02 347.07,49.02 338.12,40.08 337.72,40.08 329.59,31.95 325.93,31.95 D11.N1