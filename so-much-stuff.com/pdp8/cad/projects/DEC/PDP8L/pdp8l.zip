# EAGLE board pdp8l (EAGLE 4.11), part 7 of 8
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
N$228  (via drill 0.61) (continued)
  Bottom 0.203: v245.47,227.03 205.64,227.03 205.23,226.62 193.45,226.62 192.63,225.81 A21.T2
N$229
  Bottom 0.203: A21.C2 195.48,266.04 195.48,262.38 228.8,262.38 229.62,263.2 A18.D2
N$230
  Bottom 0.203: A21.D2 192.63,263.2 194.26,261.57 230.43,261.57 231.24,260.76 232.87,260.76 A18.E2
N$231  (via drill 0.61)
  Top 0.203: v190.6,248.56 190.6,251.41 193.45,254.25 193.45,257.91 195.07,259.54 A21.E2
  Bottom 0.203: v190.6,248.56 191.01,248.97 230.02,248.97 234.09,244.91 236.12,244.91 A18.L1
N$232  (via drill 0.61)
  Top 0.203: v239.37,256.29 241,254.66 241,243.28 239.78,242.06 A18.M1
  Bottom 0.203: v239.37,256.29 238.96,255.88 193.45,255.88 192.63,256.69 A21.F2
N$233
  Top 0.203: A21.H2 195.48,254.66 197.1,256.29 197.1,257.91 204.01,264.82 217.02,264.82 217.02,264.01 A19.D2
N$234
  Top 0.203: A21.J2 192.63,251.41 193.85,252.63 193.85,255.47 203.61,265.23 220.68,265.23 220.68,261.16 A19.E2
N$235
  Bottom 0.203: A21.K2 195.88,247.34 197.51,245.72 222.3,245.72 223.11,244.91 A19.L1
N$236  (via drill 0.61)
  Top 0.203: v193.85,240.44 193.85,242.06 192.23,243.69 A21.L2
  Bottom 0.203: v193.85,240.44 194.26,240.03 225.55,240.03 226.37,240.84 A19.M1
N$237
  Top 0.203: A21.M2 195.48,242.06 196.7,243.28 196.7,253.44 204.42,261.16 204.42,262.79 A20.D2
N$238
  Top 0.203: A21.N2 192.63,238.4 197.1,238.4 197.1,246.53 207.67,257.1 207.67,259.54 A20.E2
N$239
  Top 0.203: A21.P2 195.88,235.15 200.35,235.15 200.35,235.97 208.48,244.09 210.51,244.09 A20.L1
N$240
  Top 0.203: A21.R2 192.63,232.31 197.1,232.31 198.32,233.53 212.95,233.53 212.95,240.03 213.77,240.84 A20.M1
N$241  (via drill 0.61)
  Route15 0.203: v200.35,194.11 197.92,196.54 195.88,196.54 B21.C2
  Bottom 0.203: v200.35,194.11 201.98,192.48 228.8,192.48 229.62,193.29 B18.D2
N$242
  Bottom 0.203: B21.D2 192.63,193.29 193.85,192.07 231.65,192.07 232.87,190.86 B18.E2
N$243  (via drill 0.61)
  Top 0.203: v236.12,183.54 237.74,181.91 237.74,176.63 236.53,175.41 B18.L1
  Bottom 0.203: v236.12,183.54 227.99,191.67 196.7,191.67 195.88,190.86 B21.E2
N$244  (via drill 0.61)
  Route15 0.203: v196.7,180.29 192.63,184.35 192.63,186.79 B21.F2
  Bottom 0.203: v196.7,180.29 200.76,176.22 233.27,176.22 237.74,171.75 238.96,171.75 B18.M1
N$245  (via drill 0.61)
  Top 0.203: v217.42,189.23 217.42,192.89 B19.D2
  Bottom 0.203: v217.42,189.23 195.48,189.23 195.48,184.76 B21.H2
N$246
  Bottom 0.203: B21.J2 192.63,181.51 193.85,182.73 197.1,182.73 200.35,185.98 218.24,185.98 220.27,188.01 220.27,190.04 B19.E2
N$247
  Bottom 0.203: B21.K2 195.88,177.44 197.51,175.82 222.3,175.82 223.11,175.01 B19.L1
N$248
  Bottom 0.203: B21.L2 192.63,174.19 193.45,173.38 224.74,173.38 226.37,171.75 B19.M1
N$249
  Top 0.203: B21.M2 195.48,172.16 196.7,173.38 196.7,176.22 203.61,183.13 203.61,192.07 204.42,192.89 B20.D2
N$250
  Top 0.203: B21.N2 192.63,168.5 197.1,168.5 197.1,175.82 207.26,185.98 207.26,190.04 B20.E2
N$251
  Top 0.203: B21.P2 195.88,165.25 200.35,165.25 200.35,166.06 208.48,174.19 210.51,174.19 B20.L1
N$252  (via drill 0.61)
  Top 0.203: v212.95,163.63 212.95,170.13 213.77,170.94 B20.M1
  Bottom 0.203: v212.95,163.63 193.85,163.63 192.63,162.41 B21.R2
N$253
  Route2 0.203: A26.P2 132.49,235.15 134.52,235.15 150.37,251 151.99,251 153.21,252.22 154.84,252.22 156.46,253.85 A24.H2
N$267
  Route15 0.203: A22.T2 178.82,225.81 176.78,225.81 158.9,243.69 158.9,245.31 157.28,246.94 A24.K2
N$268
  Route15 0.203: A24.J2 154.43,250.19 158.9,250.19 178.82,230.28 180.85,230.28 182.07,229.06 A22.S2
N$269
  Bottom 0.203: B25.K2 143.87,177.44 142.24,175.82 140.61,175.82 139.8,175.01 139.8,173.38 146.3,173.38 146.71,172.97 167.84,172.97 168.25,172.57 169.06,172.57 169.47,172.97 174.35,172.97 175.56,171.75 B23.M1
N$270  (via drill 0.61)
  Top 0.203: v139.8,256.29 139.8,240.03 141.02,238.81 A25.N2
  Bottom 0.203: v139.8,256.29 140.21,255.88 165.41,255.88 166.22,256.69 A23.F2
N$271
  Route2 0.203: A26.N2 129.24,238.4 133.3,238.4 150.37,255.47 151.59,255.47 153.21,257.1 A24.F2
N$272
  Route2 0.203: A25.M2 145.09,241.66 149.15,241.66 149.96,242.47 155.25,242.47 168.66,255.88 169.88,255.88 172.31,258.32 173.94,258.32 175.56,259.94 A23.E1
N$273  (via drill 0.61)
  Top 0.203: v169.06,243.28 168.66,242.88 168.66,237.19 169.47,236.37 169.47,235.56 A23.P2
  Bottom 0.203: v169.06,243.28 142.65,243.28 141.83,244.09 A25.L2
N$274  (via drill 0.61)
  Top 0.203: v146.3,240.44 146.3,245.31 144.68,246.94 A25.K2
  Bottom 0.203: v146.3,240.44 146.71,240.03 174.75,240.03 175.56,240.84 A23.M1
N$275  (via drill 0.61)
  Top 0.203: v142.24,252.22 142.65,251.82 142.65,237.19 144.27,235.56 A25.P2
  Bottom 0.203: v142.24,252.22 142.65,252.63 167.84,252.63 169.06,253.85 A23.H2
N$276
  Route2 0.203: A25.R2 141.83,232.31 145.9,232.31 169.06,255.47 170.69,255.47 172.31,257.1 A23.F1
N$277
  Route2 0.203: A25.T2 141.83,225.81 145.9,225.81 146.71,226.62 158.09,226.62 168.25,236.78 171.09,236.78 172.31,238 A23.N1
N$278
  Bottom 0.203: A25.S2 145.09,229.06 146.3,230.28 165.41,230.28 166.22,231.09 A23.R2
N$279  (via drill 0.61)
  Top 0.203: v171.91,259.54 171.91,253.85 170.69,252.63 170.69,248.56 170.28,248.16 A23.K2
  Bottom 0.203: v171.91,259.54 175.56,263.2 178.82,263.2 A22.D2
N$280  (via drill 0.61)
  Top 0.203: v167.84,260.35 167.84,252.22 167.03,251.41 A23.J2
  Bottom 0.203: v167.84,260.35 172.72,265.23 181.25,265.23 182.07,266.04 A22.C2
N$281
  Top 0.203: A23.H1 176.38,254.66 177.6,255.88 177.6,257.5 180.03,259.94 182.07,259.94 A22.E2
N$282
  Top 0.203: A23.J1 173.53,251.41 178,251.41 178,255.88 178.82,256.69 A22.F2
N$283  (via drill 0.61)
  Top 0.203: v176.38,230.28 178,231.9 178,246.53 182.07,250.6 182.07,253.44 A22.H2
  Bottom 0.203: v176.38,230.28 171.5,230.28 170.28,229.06 A23.S2
N$284
  Route2 0.203: A23.T2 167.03,226.21 167.03,229.87 174.35,237.19 174.35,243.69 177.6,246.94 177.6,248.56 179.22,250.19 A22.J2
N$285
  Route2 0.203: A23.R1 173.53,232.31 173.53,235.56 174.75,236.78 174.75,238 177.6,240.84 177.6,242.06 179.22,243.69 A22.L2
N$286
  Top 0.203: A23.P1 176.38,235.56 177.6,236.78 177.6,246.94 180.85,250.19 180.85,254.25 182.07,255.47 183.69,255.47 183.69,248.97 182.88,248.16 A22.K2
N$287  (via drill 0.61)
  Top 0.203: v168.66,173.38 168.66,166.47 169.47,165.66 B23.P2
  Bottom 0.203: v168.66,173.38 147.12,173.38 146.71,173.79 142.24,173.79 141.83,174.19 B25.L2
N$288
  Route2 0.203: B25.M2 145.09,171.75 148.34,171.75 162.56,185.98 163.37,185.98 166.22,188.82 174.35,188.82 175.56,190.04 B23.E1
N$289
  Route2 0.203: B25.N2 141.83,168.5 145.9,168.5 162.97,185.57 165,185.57 166.22,186.79 B23.F2
N$290  (via drill 0.61)
  Top 0.203: v145.9,180.7 145.9,166.88 144.68,165.66 B25.P2
  Bottom 0.203: v145.9,180.7 145.9,182.32 154.43,182.32 154.84,182.73 167.84,182.73 169.06,183.95 B23.H2
N$291
  Route2 0.203: B25.R2 141.83,161.59 145.09,161.59 169.06,185.57 170.69,185.57 172.31,187.2 B23.F1
N$292
  Bottom 0.203: B25.S2 145.09,159.16 146.3,160.38 165,160.38 166.22,161.59 B23.R2
N$293  (via drill 0.61)
  Top 0.203: v171.5,156.72 171.91,157.12 171.91,166.88 172.72,167.69 B23.N1
  Bottom 0.203: v171.5,156.72 142.65,156.72 141.83,155.91 B25.T2
N$294  (via drill 0.61)
  Top 0.203: v182.07,194.11 183.69,195.73 183.69,240.03 182.88,240.84 A22.M2
  Route2 0.203: v182.07,194.11 169.06,181.1 167.44,181.1 B23.J2
N$295  (via drill 0.61)
  Top 0.203: v168.66,235.97 168.66,179.07 169.47,178.26 B23.K2
  Bottom 0.203: v168.66,235.97 169.47,236.78 178,236.78 178.82,237.59 A22.N2
N$296
  Top 0.203: B23.J1 173.53,181.51 174.35,182.32 174.35,192.07 178,195.73 178,229.87 179.22,231.09 A22.R2
N$297
  Top 0.203: B23.H1 176.38,184.76 177.19,185.57 177.19,188.82 181.25,192.89 181.25,233.53 182.07,234.34 A22.P2
N$298  (via drill 0.61)
  Top 0.203: v175.56,195.33 175.56,194.11 171.09,189.64 171.09,160.78 169.88,159.56 B23.S2
  Bottom 0.203: v175.56,195.33 177.19,195.33 178.41,196.54 182.07,196.54 B22.C2
N$299
  Top 0.203: B23.T2 166.22,155.09 165.41,154.28 165.41,142.9 167.84,140.46 169.06,140.46 169.06,151.03 168.66,151.44 168.66,155.91 171.5,158.75 171.5,177.44 174.75,180.7 174.75,187.2 179.22,191.67 179.22,192.89 B22.D2
N$300
  Top 0.203: B23.P1 176.78,165.66 177.6,166.47 177.6,187.6 178.82,188.82 180.85,188.82 180.85,185.57 180.03,184.76 180.03,183.95 181.25,182.73 183.69,182.73 183.69,189.23 182.88,190.04 B22.E2
N$301
  Top 0.203: B23.R1 173.53,162.41 178,162.41 178,171.35 180.85,174.19 180.85,182.32 179.63,183.54 179.63,186.79 B22.F2
N$302  (via drill 0.61)
  Top 0.203: v158.9,179.48 163.37,175.01 163.37,172.16 B24.M1
  Bottom 0.203: v158.9,179.48 137.77,179.48 136.96,178.66 133.3,178.66 132.49,177.85 B26.K2
N$303  (via drill 0.61)
  Top 0.203: v130.45,167.28 130.45,172.97 129.24,174.19 B26.L2
  Bottom 0.203: v130.45,167.28 130.86,166.88 152.4,166.88 154.03,165.25 156.46,165.25 B24.P2
N$304
  Route2 0.203: B26.M2 132.08,172.16 132.08,173.79 153.21,194.92 156.87,194.92 162.15,189.64 162.97,190.45 B24.E1
N$305
  Route2 0.203: B26.N2 129.24,168.5 132.49,168.5 149.56,185.57 151.59,185.57 153.21,187.2 B24.F2
N$306  (via drill 0.61)
  Top 0.203: v132.89,181.1 132.89,166.47 132.08,165.66 B26.P2
  Bottom 0.203: v132.89,181.1 134.52,182.73 154.03,182.73 155.25,183.95 156.46,183.95 B24.H2
N$307
  Route2 0.203: B26.R2 129.24,162.41 133.3,162.41 156.46,185.57 158.5,185.57 159.72,186.79 B24.F1
N$308
  Bottom 0.203: B26.S2 132.49,159.16 133.3,159.97 145.09,159.97 145.9,160.78 152.4,160.78 153.21,161.59 B24.R2
N$309  (via drill 0.61)
  Top 0.203: v158.9,158.34 158.9,166.47 160.12,167.69 B24.N1
  Bottom 0.203: v158.9,158.34 157.68,157.12 130.45,157.12 129.24,155.91 B26.T2
N$310  (via drill 0.61)
  Top 0.203: v178.41,179.48 179.22,178.66 179.22,175.41 B22.L2
  Bottom 0.203: v178.41,179.48 162.15,179.48 160.93,180.7 B24.J1
N$311
  Bottom 0.203: B24.H1 164.19,184.35 165.41,185.57 183.29,185.57 183.69,185.17 183.69,178.26 182.88,178.26 B22.K2
N$312
  Bottom 0.203: B24.K2 157.68,178.26 158.09,178.66 162.56,178.66 162.97,179.07 177.6,179.07 178,178.66 178.82,178.66 179.22,179.07 179.22,180.29 B22.J2
N$313
  Bottom 0.203: B24.J2 154.43,181.51 155.25,182.32 180.85,182.32 182.07,183.54 B22.H2
N$314  (via drill 0.61)
  Top 0.203: v158.5,170.54 158.5,160.78 157.28,159.56 B24.S2
  Bottom 0.203: v158.5,170.54 158.9,170.13 181.25,170.13 182.07,170.94 B22.M2
N$315
  Route2 0.203: B24.T2 154.43,155.91 158.5,155.91 159.31,156.72 165.81,156.72 175.56,166.47 177.6,166.47 178.82,167.69 B22.N2
N$316
  Bottom 0.203: B24.P1 164.19,165.25 165.41,166.47 181.25,166.47 182.07,165.66 B22.P2
N$317
  Bottom 0.203: B24.R1 160.93,162.41 161.75,163.22 178,163.22 178.82,162.41 B22.R2
N$318  (via drill 0.61)
  Top 0.203: v21.54,195.73 21.95,196.14 21.95,230.28 22.35,230.68 22.35,245.72 23.57,246.94 A35.K1
  Bottom 0.203: v21.54,195.73 22.35,194.92 32.11,194.92 32.92,194.11 B34.D1
N$319  (via drill 0.61)
  Top 0.203: v36.17,213.21 36.58,212.8 36.58,205.08 37.8,203.86 37.8,192.48 36.58,191.26 B34.E1
  Route15 0.203: v36.17,213.21 28.45,220.93 28.45,232.31 24.38,236.37 24.38,240.84 A35.M1
N$320  (via drill 0.61)
  Top 0.203: v24.79,181.91 23.98,181.1 21.95,181.1 21.95,194.92 22.35,195.33 22.35,229.87 23.57,231.09 23.57,234.34 A35.P1
  Bottom 0.203: v24.79,181.91 25.2,182.32 27.64,182.32 28.04,181.91 31.7,181.91 32.11,182.32 34.14,182.32 35.76,183.95 B34.H1
N$321  (via drill 0.61)
  Top 0.203: v33.73,227.03 34.54,226.21 34.54,182.32 33.73,181.51 B34.J1
  Bottom 0.203: v33.73,227.03 33.33,227.43 28.04,227.43 27.23,228.24 24.38,228.24 A35.S1
N$322  (via drill 0.61)
  Top 0.203: v23.57,181.91 22.35,183.13 22.35,193.29 25.2,196.14 25.2,217.68 24.38,218.49 24.38,221.74 A35.U1
  Route15 0.203: v23.57,181.91 30.48,175.01 32.92,175.01 B34.L1
N$323
  Route15 0.203: A35.F2 13.82,256.69 9.35,256.69 6.91,254.25 5.69,255.47 4.06,255.47 1.63,253.03 2.85,251.82 2.85,231.09 3.25,230.68 3.25,225.81 9.35,219.71 9.35,216.05 12.19,213.21 12.19,204.27 18.69,197.76 18.69,192.07 22.76,188.01 22.76,187.2 34.54,175.41 34.54,173.79 36.17,172.16 B34.M1
N$324  (via drill 0.61)
  Top 0.203: v19.1,166.88 19.1,250.6 15.04,250.6 A35.J2
  Bottom 0.203: v19.1,166.88 34.14,166.88 35.76,165.25 B34.P1
N$325
  Route2 0.203: B34.S1 35.76,159.16 32.11,159.16 30.07,161.19 29.26,160.38 13.41,160.38 1.22,172.57 2.85,174.19 2.85,231.09 12.6,240.84 12.6,242.06 14.22,243.69 A35.L2
N$326
  Route15 0.203: B34.E2 30.07,191.26 30.07,194.92 28.85,196.14 28.85,205.08 28.04,205.89 28.04,214.02 23.98,218.08 23.98,219.3 19.1,224.18 19.1,224.99 16.26,227.84 16.26,229.46 14.63,231.09 A35.R2
N$327  (via drill 0.61)
  Top 0.203: v17.88,194.92 18.69,195.73 18.69,218.9 15.44,222.15 15.44,236.78 14.63,237.59 A35.N2
  Bottom 0.203: v17.88,194.92 21.13,194.92 21.54,194.51 26.01,194.51 26.42,194.11 B34.D2
N$328  (via drill 0.61)
  Top 0.203: v29.67,218.08 29.67,205.89 28.85,205.08 28.85,190.04 29.26,189.64 29.26,185.17 29.67,184.76 B34.H2
  Bottom 0.203: v29.67,218.08 29.67,220.93 20.73,220.93 16.26,225.4 15.04,225.4 A35.T2
N$329  (via drill 0.61)
  Top 0.203: v25.2,218.9 25.6,218.49 25.6,190.86 28.45,188.01 28.45,179.48 29.67,178.26 B34.K2
  Bottom 0.203: v25.2,218.9 23.57,220.52 16.26,220.52 15.04,219.3 A35.V2
N$330
  Top 0.203: D17.P2 246.28,27.89 247.5,26.67 247.5,6.76 241.81,1.07 3.25,1.07 3.25,182.32 4.47,183.54 B36.H2
N$331  (via drill 0.61)
  Top 0.203: v8.53,206.7 6.1,204.27 6.1,192.48 4.88,191.26 B36.E2
  Route15 0.203: v156.06,206.3 225.55,136.8 225.55,135.99 269.44,92.1 270.66,92.1 C15.S2
  Bottom 0.203: v156.06,206.3 155.65,206.7 29.67,206.7 29.26,207.11 9.35,207.11 8.94,206.7 v8.53,206.7
N$332  (via drill 0.61)
  Route15 0.203: v181.66,12.85 165,29.52 165,35.61 52.83,147.78 51.61,147.78 6.1,193.29 2.03,193.29 B36.D2
  Bottom 0.203: v181.66,12.85 183.29,11.23 232.87,11.23 235.71,14.07 241,14.07 242.21,12.85 D17.V2
N$333  (via drill 0.61)
  Top 0.203: v13.01,169.32 13.01,161.19 11.38,159.56 B36.S1
  Route2 0.203: v204.83,172.57 234.49,202.23 234.49,205.89 243.84,215.24 244.65,215.24 245.06,215.65 249.12,215.65 301.95,268.48 302.77,268.48 305.61,271.32 306.02,271.32 309.27,274.57 313.74,274.57 314.96,275.79 317.4,275.79 319.43,277.83 320.65,277.83 v326.34,283.52
  Route15 0.203: v326.34,283.52 327.56,284.73 369.42,284.73 370.64,283.52 371.45,283.52 v384.05,270.92
  Bottom 0.203: v13.01,169.32 13.41,169.72 60.15,169.72 62.99,166.88 125.17,166.88 131.27,172.97 138.58,172.97 141.83,169.72 201.98,169.72 v204.83,172.57 | v384.05,270.92 384.45,271.32 451.1,271.32 451.92,270.51 A01.B1
N$334  (via drill 0.61)
  Route2 0.203: v158.5,284.33 65.84,191.67 60.96,191.67 45.11,175.82 43.89,175.82 28.85,160.78 19.91,160.78 15.85,164.85 11.79,164.85 B36.P1
  Route15 0.203: v208.89,284.33 226.37,284.33 226.77,284.73 284.07,284.73 285.29,283.52 286.11,283.52 286.92,282.7 291.8,282.7 292.2,282.3 305.21,282.3 305.61,281.89 310.08,281.89 v311.3,280.67
  Bottom 0.203: v208.89,284.33 v158.5,284.33 | v311.3,280.67 311.71,281.08 315.37,281.08 315.77,281.48 331.62,281.48 332.44,282.3 367.79,282.3 368.61,281.48 392.18,281.48 392.99,282.3 405.18,282.3 407.21,280.26 449.88,280.26 454.36,275.79 454.36,267.26 455.17,267.26 A01.C1
N$335  (via drill 0.61)
  Top 0.203: v248.31,100.23 244.25,104.29 v244.25,147.78 | v81.69,147.78 80.87,148.59 v80.87,175.01
  Bottom 0.203: v248.31,100.23 267,100.23 267.82,101.04 C15.N2 | v244.25,147.78 243.84,147.37 120.29,147.37 119.89,147.78 v81.69,147.78 | v80.87,175.01 79.25,173.38 13.41,173.38 11.79,171.75 B36.M1
N$336  (via drill 0.61)
  Route15 0.203: v99.57,94.54 56.08,138.02 52.83,138.02 11.79,179.07 10.16,179.07 8.53,180.7 B36.J1
  Bottom 0.203: v99.57,94.54 100.38,93.73 121.11,93.73 124.36,90.47 163.78,90.47 164.19,90.07 167.44,90.07 169.88,87.63 182.47,87.63 185.72,84.38 249.53,84.38 250.34,83.57 267.41,83.57 267.82,83.16 C15.V2
N$337
  Top 0.203: B36.E1 11.38,191.26 13.01,192.89 13.01,259.54 14.22,260.76 14.22,262.79 A35.D2
N$338
  Top 0.203: B36.D1 7.32,194.11 6.5,194.92 6.5,203.45 12.19,209.14 12.19,219.3 9.75,221.74 9.75,257.1 13.01,260.35 13.01,264.01 13.82,264.82 16.26,264.82 16.26,259.94 17.07,259.13 19.51,259.13 19.51,268.48 20.32,269.29 A35.B1
N$339  (via drill 0.61)
  Top 0.203: v8.94,159.97 9.35,160.38 9.35,198.17 8.13,199.39 B36.B1
  Route15 0.203: v206.45,164.44 232.87,138.02 234.09,138.02 277.17,94.94 277.17,92.51 C15.S1
  Bottom 0.203: v206.45,164.44 204.42,166.47 192.23,166.47 183.29,157.53 160.93,157.53 158.5,159.97 147.93,159.97 145.49,157.53 110.95,157.53 108.51,159.97 27.23,159.97 24.79,157.53 14.22,157.53 11.79,159.97 v8.94,159.97
N$340  (via drill 0.61)
  Top 0.203: v65.02,212.39 65.02,271.32 55.27,271.32 54.05,272.54 54.05,284.73 35.76,284.73 24.38,273.36 A35.A1
  Route15 0.203: v65.02,212.39 65.43,212.39 95.1,182.73 96.32,182.73 101.6,177.44 102.41,177.44 130.05,149.81 130.05,149 213.77,65.28 217.83,65.28 223.93,59.18 224.74,59.18 247.09,36.83 247.5,36.83 252.78,31.55 253.59,31.55 270.66,14.48 303.99,14.48 305.61,12.85 D12.V2
N$341  (via drill 0.61)
  Top 0.203: v395.02,34.39 397.05,36.42 397.05,69.75 394.21,72.59 394.21,81.13 395.02,81.94 C05.V2
  Route15 0.203: v395.02,34.39 387.71,27.08 372.26,27.08 371.04,28.3 366.57,23.83 349.5,23.83 349.1,24.23 343.41,24.23 330.81,36.83 324.71,36.83 323.49,38.05 322.27,38.05 319.84,40.49 318.21,40.49 317.81,40.89 317.81,41.3 290.98,68.12 290.17,68.12 277.17,81.13 273.91,81.13 270.26,84.78 270.26,86 268.63,87.63 268.63,88.44 C15.T2
N$342
  Route15 0.203: C22.V2 178.82,82.75 177.19,82.75 168.66,91.29 168.66,92.91 167.03,94.54 C23.R2
N$343  (via drill 0.61)
  Top 0.203: v172.31,84.38 171.09,85.6 171.09,90.07 169.88,91.29 C23.S2
  Bottom 0.203: v172.31,84.38 181.25,84.38 182.07,85.19 C22.U2
N$344
  Top 0.203: C22.T2 178.82,89.26 174.35,89.26 174.35,96.16 169.06,101.45 167.44,101.45 C23.N2
N$345
  Top 0.203: C23.P2 170.28,97.79 171.91,96.16 171.91,88.04 172.31,87.63 181.66,87.63 181.66,90.47 182.47,91.29 C22.S2
N$346
  Route2 0.203: C24.K2 157.68,111.61 161.75,111.61 178.41,128.27 180.44,128.27 182.07,129.9 C22.C2
N$347
  Top 0.203: C24.J2 154.43,114.86 158.9,114.86 172.72,128.68 183.69,128.68 183.69,122.99 183.29,122.58 179.63,122.58 179.63,126.24 C22.D2
N$348
  Top 0.203: C24.M2 157.28,105.51 158.9,107.14 158.9,108.76 178.41,128.27 182.47,128.27 182.47,124.61 C22.E2
N$349  (via drill 0.61)
  Top 0.203: v171.91,109.98 178.82,116.89 178.82,120.14 C22.F2
  Bottom 0.203: v171.91,109.98 156.06,109.98 154.43,108.36 C24.L2
N$350
  Route2 0.203: C24.P2 157.68,99.01 161.34,99.01 169.47,107.14 170.28,107.14 178.82,115.67 180.85,115.67 182.07,116.89 C22.H2
N$351  (via drill 0.61)
  Top 0.203: v174.35,106.73 179.22,111.61 179.22,113.64 C22.J2
  Bottom 0.203: v174.35,106.73 172.31,106.73 171.91,107.14 169.47,107.14 165.41,103.07 155.25,103.07 154.43,102.26 C24.N2
N$352  (via drill 0.61)
  Top 0.203: v177.6,91.29 181.25,94.94 181.25,109.17 182.47,110.39 C22.K2
  Bottom 0.203: v177.6,91.29 177.19,90.88 169.06,90.88 166.62,93.32 158.5,93.32 157.68,92.51 C24.S2
N$353
  Route2 0.203: C24.R2 154.43,95.76 158.9,95.76 159.72,96.57 165.81,96.57 175.16,105.92 177.19,105.92 178.82,107.54 C22.L2
N$354  (via drill 0.61)
  Top 0.203: v169.88,106.32 169.88,110.39 C23.K2
  Bottom 0.203: v169.88,106.32 170.28,105.92 181.25,105.92 182.07,105.1 C22.M2
N$355
  Top 0.203: C22.N2 178.82,101.85 174.35,101.85 174.35,104.7 171.09,107.95 171.09,114.05 169.47,115.67 167.03,115.67 167.03,114.86 C23.J2
N$356
  Bottom 0.203: C23.M2 170.28,104.29 170.28,99.82 181.25,99.82 182.07,99.01 C22.P2
N$357
  Top 0.203: C22.R2 178.82,95.76 174.75,95.76 174.75,97.79 167.03,105.51 167.03,107.14 C23.L2
N$358
  Top 0.203: D20.C2 208.48,60 212.95,60 212.95,53.09 228.8,37.24 228.8,26.67 229.62,25.86 D18.R2
N$359
  Route15 0.203: D20.D2 204.83,56.34 204.83,52.68 231.65,25.86 231.65,24.64 233.27,23.01 D18.S2
N$360
  Route15 0.203: D18.N2 229.62,31.95 227.99,31.95 209.7,50.24 209.7,52.27 208.48,53.49 D20.E2
N$361
  Route2 0.203: D20.F2 205.23,50.24 209.7,50.24 232.05,27.89 232.87,28.7 D18.P2
N$362
  Top 0.203: D18.L2 230.84,37.64 231.65,36.83 231.65,24.64 231.24,24.23 221.89,24.23 221.89,42.11 217.83,46.18 208.48,46.18 208.48,46.99 D20.H2
N$363
  Bottom 0.203: D18.M2 232.87,35.2 231.24,36.83 204.01,36.83 203.61,37.24 203.61,44.15 204.01,44.15 D20.J2
N$364
  Bottom 0.203: D20.K2 208.48,41.71 209.7,42.93 225.96,42.93 227.18,44.15 229.62,44.15 D18.J2
N$365
  Bottom 0.203: D20.L2 205.23,38.46 206.86,40.08 232.05,40.08 232.87,40.89 D18.K2
N$366
  Top 0.203: D20.M2 208.48,34.39 212.95,34.39 212.95,31.95 217.02,27.89 217.02,25.86 D19.R2
N$367  (via drill 0.61)
  Top 0.203: v206.45,23.42 206.45,29.92 205.23,31.14 D20.N2
  Bottom 0.203: v206.45,23.42 218.64,23.42 219.86,22.2 D19.S2
N$368
  Bottom 0.203: D20.P2 208.48,29.11 209.7,30.33 216.21,30.33 217.02,31.14 D19.N2
N$369
  Bottom 0.203: D20.R2 205.23,25.04 206.04,24.23 213.77,24.23 217.83,28.3 219.86,28.3 D19.P2
N$370
  Top 0.203: D20.S2 207.26,21.79 206.45,20.98 206.45,15.29 207.26,14.48 216.21,14.48 216.21,22.2 218.64,24.64 218.64,36.83 217.83,37.64 D19.L2
N$371
  Route2 0.203: D20.T2 205.23,19.76 207.67,19.76 218.64,30.73 218.64,32.77 220.27,34.39 D19.M2
N$372
  Top 0.203: D20.U2 208.48,16.51 209.3,17.32 209.3,31.55 206.45,34.39 206.45,35.61 214.99,44.15 217.02,44.15 D19.J2
N$373
  Top 0.203: D20.V2 205.23,12.04 210.11,12.04 210.11,11.63 210.51,11.23 219.46,11.23 219.46,39.27 220.68,40.49 D19.K2
N$374  (via drill 0.61)
  Top 0.203: v226.37,81.13 228.8,83.57 228.8,93.32 230.02,94.54 C18.R2
  Bottom 0.203: v226.37,81.13 206.04,81.13 205.23,81.94 C20.V2
N$375
  Route2 0.203: C20.U2 208.48,86 212.55,86 213.77,87.22 217.83,87.22 228.8,98.2 229.62,98.2 234.09,93.73 232.87,92.51 C18.S2
N$376  (via drill 0.61)
  Top 0.203: v209.7,97.79 206.45,94.54 206.45,91.29 204.83,89.66 C20.T2
  Bottom 0.203: v209.7,97.79 211.73,99.82 228.4,99.82 229.62,101.04 C18.N2
N$377  (via drill 0.61)
  Top 0.203: v232.87,93.73 232.87,97.79 C18.P2
  Bottom 0.203: v232.87,93.73 209.7,93.73 208.48,92.51 C20.S2
N$378  (via drill 0.61)
  Top 0.203: v203.61,102.67 203.61,96.57 204.42,95.76 C20.R2
  Bottom 0.203: v203.61,102.67 207.67,106.73 228.8,106.73 229.62,107.54 C18.L2
N$379
  Bottom 0.203: C20.P2 208.48,99.01 209.7,100.23 226.77,100.23 230.84,104.29 232.87,104.29 C18.M2
N$380  (via drill 0.61)
  Top 0.203: v227.18,103.07 228.8,104.7 228.8,112.42 230.02,113.64 C18.J2
  Bottom 0.203: v227.18,103.07 206.04,103.07 205.23,102.26 C20.N2
N$381  (via drill 0.61)
  Top 0.203: v232.87,106.32 233.27,106.73 233.27,110.39 C18.K2
  Bottom 0.203: v232.87,106.32 209.7,106.32 208.48,105.1 C20.M2
N$382
  Top 0.203: C19.K2 220.27,111.61 218.64,113.23 218.64,117.3 208.08,127.86 208.08,129.49 C20.C2
N$383
  Top 0.203: C19.J2 217.02,114.86 215.8,116.08 215.8,118.11 207.26,126.64 205.23,126.64 C20.D2
N$384
  Top 0.203: C19.M2 220.27,105.51 218.64,107.14 218.64,111.2 208.48,121.36 208.48,123.39 C20.E2
N$385
  Top 0.203: C20.F2 205.23,120.14 208.08,120.14 208.08,119.33 217.42,109.98 217.42,108.76 C19.L2
N$386
  Top 0.203: C19.P2 220.27,99.01 218.64,100.63 218.64,104.7 208.48,114.86 208.48,116.89 C20.H2
N$387
  Top 0.203: C20.J2 205.23,113.64 208.89,113.64 208.89,112.42 217.02,104.29 217.02,102.26 C19.N2
N$388
  Top 0.203: C19.S2 220.27,92.51 218.64,94.13 218.64,98.2 208.08,108.76 208.08,110.39 C20.K2
N$389
  Top 0.203: C20.L2 205.23,107.54 208.48,107.54 208.48,106.32 217.02,97.79 217.02,95.76 C19.R2
N$390
  Top 0.203: D23.R2 167.03,25.86 168.25,27.08 168.25,44.15 174.75,50.65 174.75,55.52 179.22,60 182.07,60 D22.C2
N$391
  Top 0.203: D23.S2 169.88,23.01 170.69,23.83 170.69,27.48 178,34.8 178,55.12 179.22,56.34 D22.D2
N$392
  Route15 0.203: D23.N2 167.03,32.36 167.03,36.42 183.29,52.68 182.47,53.49 D22.E2
N$393
  Top 0.203: D23.P2 170.28,29.11 171.91,30.73 171.91,46.99 177.6,52.68 177.6,57.56 178.41,58.37 180.85,58.37 180.85,52.68 179.63,51.46 D22.F2
N$394
  Route2 0.203: D23.L2 167.44,38.46 171.5,38.46 178.82,45.77 180.85,45.77 182.07,46.99 D22.H2
N$395
  Bottom 0.203: D23.M2 170.28,35.61 171.5,36.83 180.03,36.83 183.69,40.49 183.69,43.74 179.63,43.74 D22.J2
N$396
  Bottom 0.203: D23.J2 167.44,44.15 169.06,42.52 181.25,42.52 182.07,41.71 D22.K2
N$397
  Bottom 0.203: D23.K2 170.28,40.89 171.91,39.27 178,39.27 178.82,38.46 D22.L2
N$398  (via drill 0.61)
  Top 0.203: v171.5,24.23 181.25,24.23 181.25,33.58 182.07,34.39 D22.M2
  Bottom 0.203: v171.5,24.23 155.25,24.23 154.43,25.04 D24.R2
N$399
  Bottom 0.203: D24.S2 156.46,22.61 155.25,23.83 153.62,23.83 152.81,24.64 152.81,33.17 162.15,33.17 165,30.33 177.6,30.33 178.82,31.55 D22.N2
N$400
  Bottom 0.203: D24.N2 154.43,31.14 155.65,29.92 181.25,29.92 182.07,29.11 D22.P2
N$401
  Bottom 0.203: D24.P2 157.68,28.3 159.31,26.67 178,26.67 178.82,25.86 D22.R2
N$402  (via drill 0.61)
  Top 0.203: v169.88,36.83 168.66,35.61 168.66,21.79 169.47,20.98 182.07,20.98 182.07,21.79 D22.S2
  Bottom 0.203: v169.88,36.83 155.25,36.83 154.43,37.64 D24.L2
N$403
  Route2 0.203: D24.M2 157.68,34.39 159.72,34.39 176.78,17.32 178.82,19.36 D22.T2
N$404
  Top 0.203: D22.U2 182.07,15.29 180.85,14.07 180.85,12.04 179.63,10.82 155.25,10.82 155.25,42.93 154.43,43.74 D24.J2
N$405
  Top 0.203: D22.V2 178.82,12.45 174.35,12.45 174.35,12.04 173.53,11.23 161.75,11.23 161.75,34.8 157.28,39.27 157.28,40.49 D24.K2
NEG_CLAMP  (via drill 0.61)
  Top 0.203: v136.14,86.82 136.14,96.16 133.71,98.6 133.71,184.35 130.45,187.6 130.45,225.4 129.64,226.21 129.64,230.28 128.83,231.09 A26.R2 | D23.V2 166.22,13.26 165.41,14.07 165.41,81.13 166.22,81.94 C23.V2
  Bottom 0.203: D18.V2 229.62,13.26 228.8,14.07 219.46,14.07 218.24,12.85 D19.V2 217.02,13.26 216.21,14.07 165.41,14.07 | 151.99,14.07 142.65,14.07 141.83,13.26 D25.V2 | 151.99,14.07 153.21,12.85 D24.V2 | 165.41,14.07 166.22,13.26 D23.V2 | 165.41,14.07 151.99,14.07 | C18.V2 229.62,82.75 228.4,83.97 219.46,83.97 218.24,82.75 C19.V2 217.02,83.16 216.21,83.97 189.38,83.97 185.72,80.31 172.31,80.31 170.28,82.35 167.44,82.35 C23.V2 166.22,83.16 165.41,83.97 155.25,83.97 154.43,83.16 C24.V2 153.21,82.35 151.99,81.13 142.65,81.13 141.83,81.94 C25.V2 141.02,83.16 136.14,83.16 v136.14,86.82
NO_SHIFT  (via drill 0.61)
  Top 0.203: v349.1,194.51 349.5,194.92 349.5,202.23 351.94,204.67 351.94,218.08 352.35,218.49 352.35,220.52 351.54,221.34 351.54,224.18 352.35,224.99 352.35,238.81 349.91,241.25 349.91,243.28 349.5,243.69 349.5,244.91 355.19,250.6 355.19,258.32 353.97,259.54 A09.E1
  Route2 0.203: v349.1,194.51 346.25,191.67 346.25,190.86 345.85,190.45 345.44,190.45 338.53,183.54 338.53,181.51 B10.J1
  Bottom 0.203: 390.55,261.57 380.8,261.57 379.98,260.76 AB07.AE1 378.76,260.76 377.95,261.57 357.23,261.57 356.01,260.35 354.79,260.35 A09.E1 | 390.55,261.57 391.36,260.76 AB06.AE1 | 390.55,261.57 403.56,261.57 404.37,260.76 AB05.AE1 405.59,260.35 406.81,261.57 412.09,261.57 412.9,260.76 416.97,260.76 AB04.AE1 418.19,260.76 419,261.57 428.75,261.57 | 428.75,261.57 429.56,260.76 AB03.AE1 | 428.75,261.57 441.35,261.57 442.16,260.76 AB02.AE1
OP1  (via drill 0.61)
  Top 0.203: v343,97.38 343,40.08 344.22,38.86 D09.L2 | v365.35,96.98 365.35,114.05 369.42,118.11 369.42,120.14 C07.F2 | 324.31,255.47 324.31,255.88 325.12,256.69 A11.F1 | 324.31,255.47 324.31,245.31 324.71,244.91 A11.L1 | 321.06,255.47 321.06,257.91 322.27,259.13 322.27,259.54 A11.E2 322.27,261.16 322.27,262.38 323.49,263.6 | 321.06,255.47 321.06,248.97 321.87,248.16 A11.K2 | 323.49,263.6 324.71,264.82 324.71,268.88 325.12,269.29 A11.B1 | v324.31,262.38 323.49,263.2 323.49,263.6 | 324.31,255.47 321.06,255.47 | A12.H1 315.37,253.44 315.37,251.82 314.55,251 314.55,224.18 315.77,222.96 A12.U1 316.18,221.74 316.99,220.93 316.99,205.49 v316.59,205.08 | v304.8,205.08 304.39,204.67 304.39,185.57 303.58,184.76 B13.H1 | v297.89,174.19 298.3,174.6 298.3,182.32 297.08,183.54 B13.H2
  Route2 0.203: A09.D1 351.54,263.6 351.54,264.01 353.57,266.04 A09.C1
  Route15 0.203: v297.89,174.19 302.36,169.72 306.83,169.72 326.75,149.81 326.75,149.4 332.84,143.31 337.72,143.31 355.19,125.83 357.23,125.83 358.04,125.02 361.29,125.02 365.35,120.95 369.42,120.95 C07.F2
  Bottom 0.203: v343,97.38 343.41,96.98 v365.35,96.98 | v324.31,262.38 349.5,262.38 350.32,263.2 A09.D1 | B13.H2 297.49,183.95 302.77,183.95 B13.H1 | v316.59,205.08 v304.8,205.08 | A11.F1 324.71,257.1 323.09,255.47 320.24,255.47 319.02,254.25 316.59,254.25 A12.H1
OP1\  (via drill 0.61)
  Top 0.203: v371.45,140.06 371.86,139.65 371.86,125.83 373.07,124.61 C07.E2 | v336.91,118.52 336.5,118.92 336.5,139.65 v336.91,140.06
  Route2 0.203: v336.91,118.52 336.5,118.92 334.47,118.92 332.03,116.48 332.03,114.86 C10.J2
  Bottom 0.203: v371.45,140.06 368.2,140.06 366.98,138.84 349.5,138.84 348.29,140.06 v336.91,140.06 334.47,140.06 334.06,139.65 315.77,139.65 315.37,140.06 312.52,140.06 311.71,139.24 293.01,139.24 290.98,137.21 C14.A1
OP2  (via drill 0.61)
  Top 0.203: v348.69,50.65 353.97,55.93 353.97,59.59 D09.C1 | v301.14,128.27 301.55,128.68 301.55,200.61 301.14,201.02 301.14,213.21 298.7,215.65 298.7,232.72 297.08,234.34 A13.P2 | v340.16,50.65 339.75,51.05 339.75,80.31 340.16,80.72 340.16,83.97 336.91,87.22 v336.91,115.27
  Route15 0.203: v308.86,121.77 308.05,122.58 308.05,124.21 306.43,125.83 306.43,126.24 C12.D2
  Bottom 0.203: v348.69,50.65 345.03,50.65 D09.F2 343.81,50.65 v340.16,50.65 | 336.91,115.67 364.95,115.67 365.76,114.86 369.42,114.86 C07.J2 | 336.91,115.67 293.01,115.67 289.76,112.42 283.26,112.42 281.63,114.05 C14.J2 281.63,114.45 282.85,115.67 284.48,115.67 287.73,118.92 290.98,118.92 291.39,118.52 295.05,118.52 295.45,118.92 301.14,118.92 304.39,122.17 308.46,122.17 v308.86,121.77 | v301.14,128.27 302.36,127.05 305.61,127.05 C12.D2 | 336.91,115.67 v336.91,115.27
OP2\  (via drill 0.61)
  Top 0.203: v334.47,103.07 334.47,99.01 C10.P2
  Route2 0.203: v343.81,110.39 343.41,110.39 338.53,105.51 337.72,105.51 335.28,103.07 334.87,103.07 v334.47,103.07
  Route15 0.203: v303.58,132.74 304.8,132.74 v334.47,103.07 | v351.54,110.79 356.41,105.92 361.29,105.92 371.04,96.16 371.04,95.76 373.48,93.32 374.29,94.13 374.29,111.61 373.48,112.42 373.48,116.89 C07.H2
  Bottom 0.203: v303.58,132.74 302.77,132.74 301.95,131.93 293.01,131.93 292.61,132.33 288.95,132.33 288.14,133.15 C14.B1 | v351.54,110.79 350.72,109.98 344.22,109.98 v343.81,110.39
OP_STROBE\  (via drill 0.61)
  Top 0.203: v359.26,188.42 358.85,188.01 358.85,154.28 360.07,153.06 B08.U2
  Route2 0.203: v305.61,137.21 305.61,136.8 289.76,120.95 288.14,120.95 C14.F1 | v346.25,137.62 346.66,137.62 350.72,141.68 351.54,141.68 358.44,148.59 358.44,150.22 360.07,151.84 B08.U2
  Route15 0.203: v359.26,188.42 322.27,225.4 319.84,225.4 A11.T2
  Bottom 0.203: v305.61,137.21 306.43,138.02 319.43,138.02 319.84,138.43 324.31,138.43 325.12,137.62 327.56,137.62 327.96,138.02 329.59,138.02 330,137.62 334.06,137.62 334.47,138.02 338.94,138.02 339.34,137.62 340.56,137.62 340.97,138.02 345.85,138.02 v346.25,137.62
OUT_STOP2\
  Bottom 0.203: D31.N2 65.84,31.55 70.71,31.55 D31.N1
PANEL_LOCK  (via drill 0.61)
  Top 0.203: v107.7,221.34 107.7,224.99 103.63,224.99 A28.T2 | v266.6,222.15 267.41,221.34 v267.41,168.91
  Route2 0.203: v347.07,125.83 362.51,141.28 362.51,144.53 389.74,171.75 390.55,171.75 391.77,172.97 394.61,172.97 398.68,168.91 399.9,170.13 v402.34,170.13
  Route15 0.203: v300.33,165.66 300.74,165.66 302.77,163.63 306.83,163.63 321.46,149 321.46,148.59 333.65,136.4 333.65,135.99 336.91,132.74 336.91,132.33 343.41,125.83 v347.07,125.83
  Bottom 0.203: v107.7,221.34 108.51,220.52 136.96,220.52 141.43,216.05 167.03,216.05 167.44,216.46 208.08,216.46 208.48,216.05 260.5,216.05 v266.6,222.15 | v267.41,168.91 267.41,166.88 297.08,166.88 298.3,165.66 v300.33,165.66 | v402.34,170.13 402.74,169.72 444.19,169.72 445.41,168.5 B01.N2
PAUSE  (via drill 0.61)
  Top 0.203: v221.89,68.53 216.21,74.22 216.21,94.54 199.95,110.79 v199.95,125.83 | v112.57,128.27 112.98,128.27 114.2,129.49 114.2,131.93 112.98,133.15 112.98,135.99 C28.A1
  Route2 0.203: v372.26,114.86 372.26,114.45 357.23,99.42 357.23,98.2 348.69,89.66 348.69,88.85 343,83.16 343,81.94 338.94,77.88 334.47,77.88 328.78,72.19 327.96,72.19 v324.31,68.53
  Route15 0.203: v408.43,116.48 414.12,110.79 414.12,108.76 C04.L1
  Bottom 0.203: v408.43,116.48 405.99,118.92 376.73,118.92 372.67,114.86 v372.26,114.86 | v324.31,68.53 269.04,68.53 268.63,68.94 223.93,68.94 223.52,68.53 v221.89,68.53 | v199.95,125.83 115.01,125.83 v112.57,128.27
PAUSE\  (via drill 0.61)
  Top 0.203: v419.81,104.7 419.4,104.29 419.4,94.54 422.25,91.69 422.25,55.93 419.81,55.93 416.15,59.59 416.15,61.21 414.53,62.84 D04.B1
  Bottom 0.203: v419.81,104.7 418.19,104.7 C04.M1
PC_ENABLE  (via drill 0.61)
  Top 0.203: v357.23,214.43 357.23,218.49 A08.V2 | v360.88,207.52 361.29,207.11 361.29,204.27 361.7,203.86 361.7,188.01 362.1,187.6 v362.1,159.97
  Bottom 0.203: 374.29,159.97 373.48,159.16 AB07.BS2 | 374.29,159.97 384.45,159.97 385.27,159.16 AB06.BS2 386.49,158.34 387.3,157.53 397.05,157.53 | v357.23,214.43 355.19,212.39 355.19,207.52 v360.88,207.52 | v362.1,159.97 374.29,159.97 | 397.05,157.53 397.87,158.34 AB05.BS2 | 409.65,157.53 410.46,158.34 AB04.BS2 | 397.05,157.53 409.65,157.53 | 421.84,157.53 423.06,158.75 AB03.BS2 | 409.65,157.53 421.84,157.53 | 421.84,157.53 435.25,157.53 436.07,158.34 AB02.BS2
PC_ENABLE\  (via drill 0.61)
  Top 0.203: v291.39,112.42 289.36,114.45 289.36,137.62 288.95,138.02 v288.95,177.44 | v283.26,185.57 283.26,187.2 279.2,191.26 279.2,217.27 280.42,218.49 A14.V2
  Route2 0.203: v335.28,224.18 334.87,224.18 328.37,217.68 v328.37,217.27
  Bottom 0.203: v291.39,112.42 301.95,112.42 302.77,111.61 C13.K1 | v288.95,177.44 286.11,180.29 286.11,185.57 | 286.11,185.57 286.11,185.98 298.7,185.98 299.52,186.79 B13.F1 | v283.26,185.57 286.11,185.57 | v335.28,224.18 355.19,224.18 356.41,225.4 A08.T2 | v328.37,217.27 302.36,217.27 301.95,217.68 282.85,217.68 281.63,218.9 A14.V2
PC_LOAD  (via drill 0.61)
  Top 0.203: 358.44,182.32 357.63,181.51 B08.J2 | 358.44,182.32 358.44,197.76 358.85,198.17 358.85,212.39 360.07,213.61 360.07,220.12 362.1,222.15 v362.1,236.78 | v358.04,158.34 358.44,158.75 358.44,182.32
  Route2 0.203: v312.93,142.09 312.52,141.68 311.3,141.68 290.98,121.36 290.98,118.11 C14.H1 | v358.04,158.34 v343.81,144.12
  Bottom 0.203: 405.99,236.78 396.65,236.78 395.83,237.59 AB05.AN2 394.61,238 393.8,237.19 390.14,237.19 389.74,236.78 387.71,236.78 386.49,238 383.24,238 AB06.AN2 382.02,237.59 381.2,236.78 368.61,236.78 | 405.99,236.78 407.21,238 AB04.AN2 | 419.4,236.78 420.22,237.59 AB03.AN2 | 405.99,236.78 419.4,236.78 | 419.4,236.78 432,236.78 432.82,237.59 AB02.AN2 | C14.J1 287.73,114.86 289.76,116.89 290.17,116.89 C14.H1 | v362.1,236.78 368.61,236.78 | 368.61,236.78 369.42,237.59 AB07.AN2 | v312.93,142.09 335.28,142.09 337.31,144.12 v343.81,144.12
POWER_CLEAR\  (via drill 0.61)
  Top 0.203: v403.56,94.13 403.56,103.48 404.37,104.29 C05.M1 405.18,105.51 v405.18,106.73 | v263.35,48.21 263.75,48.62 263.75,65.28 264.57,66.09 D16.A1 | v119.89,181.1 117.86,183.13 117.86,227.03 118.67,227.84 A27.S2 | v390.96,59.18 390.96,92.91 389.33,94.54 C06.R1
  Route2 0.203: v263.35,48.21 259.28,44.15 259.28,41.71 D16.K2 | v337.72,59.18 336.5,59.18 v318.62,41.3
  Route15 0.203: v119.89,181.1 153.21,147.78 154.43,147.78 256.85,45.36 256.85,42.93 258.06,41.71 D16.K2
  Bottom 0.203: v403.56,94.13 403.15,93.73 390.96,93.73 389.74,94.94 C06.R1 | v405.18,106.73 405.59,106.32 419,106.32 420.22,107.54 CD03.AL2 | v390.96,59.18 v337.72,59.18 | v318.62,41.3 317.4,40.08 312.12,40.08 311.71,40.49 310.9,40.49 310.49,40.08 260.1,40.08 259.28,40.89 D16.K2
POWER_OK\  (via drill 0.61)
  Route15 0.203: v267,96.16 258.88,104.29 258.88,105.1 253.59,110.39 253.59,112.42 218.24,147.78 216.61,147.78 121.92,242.47 120.7,242.47 116.23,246.94 116.23,250.19 A27.J2 | v319.02,92.1 322.68,88.44 322.68,87.22 337.72,72.19 339.34,72.19 371.45,40.08 371.45,36.83 371.86,36.42 371.86,35.61 370.23,33.98 367.79,36.42 352.75,36.42 351.54,37.64 D09.L1
  Bottom 0.203: v267,96.16 267,93.32 305.61,93.32 307.64,91.29 308.46,91.29 308.86,90.88 317.81,90.88 v319.02,92.1
PROTECT\  (via drill 0.61)
  Top 0.203: v354.38,10.41 354.38,11.23 346.25,19.36 346.25,29.92 345.03,31.14 D09.N2 | v371.04,87.63 371.04,70.16 371.45,69.75 371.45,36.42 v371.04,36.02 | C11.T2 319.43,89.66 320.24,90.47 320.24,94.54 323.49,97.79 323.49,105.51 322.68,106.32 322.68,109.58 323.49,110.39 323.49,111.61 322.68,112.42 321.46,112.42 319.43,110.39 319.43,108.76 C11.L2 | v313.33,91.69 313.33,94.13 312.93,94.54 C12.R1
  Route2 0.203: v345.44,236.78 345.44,236.37 323.9,214.83 323.49,214.83 320.24,211.58 320.24,210.77 294.64,185.17 294.23,185.17 293.83,184.76 293.83,183.54 281.23,170.94 v280.82,170.94
  Route15 0.203: v280.82,170.94 274.32,164.44 282.45,156.31 282.45,149.4 286.92,144.93 286.92,144.12 290.98,140.06 290.98,139.65 301.95,128.68 301.95,127.05 317.4,111.61 317.4,110.39 319.02,108.76 C11.L2 | v313.33,91.69 313.33,90.47 v315.37,88.44 | v371.04,36.02 371.04,36.42 371.04,39.68 366.98,43.74 366.17,43.74 341.78,68.12 338.94,68.12 334.87,72.19 333.65,72.19 321.06,84.78 321.06,86.82 319.43,88.44 C11.T2
  Bottom 0.203: v354.38,10.41 354.79,10.82 412.09,10.82 413.71,12.45 D04.V1 | v371.04,87.63 376.73,87.63 377.95,88.85 382.02,88.85 C06.T2 | v371.04,36.02 368.2,33.17 345.85,33.17 345.03,32.36 D09.N2 | v280.82,170.94 282.85,172.97 290.98,172.97 292.2,171.75 296.27,171.75 B13.M2 | v315.37,88.44 318.62,88.44 C11.T2 | v345.44,236.78 355.19,236.78 356.41,238 A08.N2
PWR_LOW\
  Route15 0.203: C26.S2 131.27,92.51 127.2,92.51 126.39,93.32 119.89,93.32 110.13,103.07 103.63,103.07 94.28,112.42 89.81,112.42 65.02,137.21 65.02,139.24 22.76,181.51 22.76,183.13 22.35,183.54 22.35,187.6 18.29,191.67 18.29,193.29 14.22,197.36 14.22,198.17 4.06,208.33 4.06,209.14 3.66,209.55 3.66,221.74 3.25,222.15 3.25,224.99 2.85,225.4 2.85,230.28 2.03,231.09 A36.R2
  Bottom 0.203: A36.R2 2.03,232.31 2.03,236.78 37.8,236.78 39.01,238 A33.N2
PWR_SKP\  (via drill 0.61)
  Top 0.203: v47.95,240.03 47.95,246.13 48.77,246.94 A33.K1
  Bottom 0.203: v47.95,240.03 1.22,240.03 1.22,243.69 A36.L2
READ  (via drill 0.61)
  Top 0.203: 253.59,68.12 253.59,82.35 243.03,92.91 243.03,94.54 C17.R2 | 253.59,68.12 253.59,49.43 257.25,45.77 257.25,34.39 258.06,33.58 259.28,33.58 260.5,34.8 260.5,36.83 261.31,37.64 D16.L1 | D25.L1 147.93,38.86 149.15,40.08 149.15,55.12 147.93,56.34 D25.D1 147.52,57.96 146.71,58.78 146.71,62.43 146.3,62.84 146.3,68.53 | C25.D2 141.43,126.24 143.05,124.61 143.05,106.73 144.27,105.51 C25.M2 145.09,104.29 145.9,103.48 145.9,82.35 148.74,79.5 148.74,72.59 146.3,70.16 146.3,68.53 | v251.56,68.12 253.59,68.12 | 146.3,68.53 v145.09,68.53
  Bottom 0.203: v251.56,68.12 222.71,68.12 222.3,67.72 221.49,67.72 220.27,68.94 145.49,68.94 v145.09,68.53
READER_RUN
  Top 0.203: D33.M2 43.48,35.2 47.95,35.2 47.95,68.12 53.65,73.81 53.65,83.57 55.27,85.19 C32.U2
RESTART\  (via drill 0.61)
  Top 0.203: v408.03,36.42 409.25,37.64 409.25,84.38 v408.84,84.78 | v425.09,131.52 425.09,120.95 422.66,118.52 422.66,95.76 v423.06,95.35 | v132.89,79.1 132.08,79.91 132.08,85.19 C26.U2
  Route2 0.203: v414.93,87.22 419,91.29 419,92.91 420.62,94.54 CD03.AR2 | v300.74,110.39 300.33,110.39 295.45,105.51 295.45,94.94 281.63,81.13 274.73,81.13 v272.29,78.69
  Route15 0.203: v345.85,110.79 349.91,106.73 351.13,106.73 352.75,105.1 352.75,103.89 356.41,100.23 360.88,100.23 367.39,93.73 368.61,93.73 371.86,90.47 375.11,90.47 375.51,90.07 377.14,90.07 v379.17,88.04 | C26.U2 132.08,86.41 132.08,90.47 133.71,92.1 129.24,96.57 123.14,96.57 81.69,138.02 79.25,138.02 34.95,182.32 34.95,183.54 28.85,189.64 28.85,195.33 28.45,195.73 28.45,203.05 13.01,218.49 13.01,220.12 11.38,221.74 A36.U1
  Bottom 0.203: 396.65,87.63 397.05,87.22 408.84,87.22 | 396.65,87.63 395.83,88.44 C05.T2 | v414.93,87.22 408.84,87.22 | v408.03,36.42 408.84,37.24 413.31,37.24 413.71,37.64 D04.L1 | 408.84,87.22 v408.84,84.78 | v345.85,110.79 344.22,112.42 321.46,112.42 321.06,112.01 316.99,112.01 316.59,111.61 C12.K1 315.37,110.79 314.55,109.98 301.14,109.98 v300.74,110.39 | v379.17,88.04 379.58,87.63 396.65,87.63 | v425.09,131.52 438.1,131.52 439.32,132.74 C02.B1 | v423.06,95.35 421.44,95.35 CD03.AR2 | v272.29,78.69 271.88,79.1 v132.89,79.1
RIGHT_SHIFT  (via drill 0.61)
  Top 0.203: v348.69,181.1 349.1,180.7 349.1,179.88 349.5,179.48 v349.5,158.75 | v371.86,224.59 371.86,245.31 372.26,245.72 372.26,246.53 371.86,246.94 v371.86,263.2
  Route2 0.203: v371.86,224.59 364.54,217.27 364.13,217.27 362.1,215.24 361.29,215.24 360.07,214.02 360.07,213.61 340.97,194.51 340.16,194.51 339.34,193.7 338.94,193.7 B10.D1
  Route15 0.203: v348.69,181.1 338.12,191.67 338.12,192.89 B10.D1
  Bottom 0.203: v349.5,158.75 353.57,158.75 B09.S1 | AB02.AD2 432.82,264.01 428.35,264.01 427.53,264.82 422.66,264.82 421.44,263.6 AB03.AD2 420.22,264.01 419.81,264.41 415.34,264.41 414.93,264.82 409.25,264.82 408.43,264.01 AB04.AD2 407.21,263.6 404.77,263.6 403.56,264.82 396.65,264.82 395.83,264.01 AB05.AD2 394.61,264.01 391.77,264.01 390.96,264.82 384.05,264.82 383.24,264.01 AB06.AD2 382.02,264.01 378.76,264.01 377.95,264.82 371.86,264.82 371.04,264.01 | 371.04,264.01 370.64,263.6 AB07.AD2 | v371.86,263.2 371.04,264.01
RUN  (via drill 0.61)
  Top 0.203: v392.58,70.16 392.58,85.19 C06.U1 | v410.87,70.16 416.97,64.06 416.97,60.81 D04.C1
  Bottom 0.203: v392.58,70.16 392.99,69.75 407.62,69.75 408.03,70.16 v410.87,70.16
RUN\  (via drill 0.61)
  Top 0.203: 393.39,93.32 393.8,93.73 v393.8,99.82 | 393.39,93.32 392.58,92.51 C06.S1 | v358.04,4.72 370.64,17.32 393.8,17.32 393.8,61.62 392.58,62.84 392.58,65.28 393.39,66.09 393.39,93.32
  Route15 0.203: v241.81,6.35 236.93,11.23 236.12,11.23 120.7,126.64 116.64,126.64 C27.D2
  Bottom 0.203: v393.8,99.82 394.21,99.42 397.46,99.42 398.27,100.23 421.44,100.23 423.06,98.6 CD03.AP2 | v241.81,6.35 243.03,5.13 298.3,5.13 298.7,4.72 332.03,4.72 332.84,5.54 334.47,5.54 334.87,5.13 357.63,5.13 v358.04,4.72
RXD
  Route15 0.203: D32.M2 55.27,35.61 55.27,39.68 44.7,50.24 44.7,52.27 43.48,53.49 D33.E2
SET_IO_ON\  (via drill 0.61)
  Top 0.203: v367.79,182.73 368.2,182.32 368.2,155.91 v367.79,155.5 | v391.36,133.15 393.39,131.12 393.39,112.42 | 393.39,112.42 392.58,111.61 C06.K1 | v392.99,101.45 393.39,101.85 393.39,112.42
  Route2 0.203: v392.99,101.45 394.61,101.45 C05.N2
  Route15 0.203: v367.79,155.5 375.51,147.78 376.73,147.78 v391.36,133.15
  Bottom 0.203: v367.79,182.73 361.7,182.73 360.88,183.54 B08.H2
SHUT_DOWN\  (via drill 0.61)
  Top 0.203: v103.23,234.34 110.95,242.06 110.95,250.19 115.42,254.66 115.42,256.69 A27.F2
  Bottom 0.203: v103.23,234.34 100.79,231.9 61.37,231.9 60.15,233.12 19.1,233.12 13.41,227.43 4.88,227.43 4.88,222.96 A36.U2
SKIP  (via drill 0.61)
  Top 0.203: v275.13,243.28 274.73,242.88 274.73,207.11 274.32,206.7 274.32,198.98 274.73,198.58 274.73,191.67 273.1,190.04 v273.1,158.75 | v328.37,157.12 328.37,153.06 B11.U1
  Bottom 0.203: v275.13,243.28 300.74,243.28 301.14,243.69 304.39,243.69 304.8,243.28 311.3,243.28 312.12,244.09 A12.L1 | v273.1,158.75 273.91,157.94 282.85,157.94 283.26,157.53 306.43,157.53 308.86,159.97 311.71,159.97 314.15,157.53 319.43,157.53 321.87,159.97 325.53,159.97 v328.37,157.12
SKIP\  (via drill 0.61)
  Top 0.203: v301.95,82.75 v301.95,103.48 | v332.03,135.18 332.03,146.96 330.4,148.59 330.4,156.72 v330.81,157.12
  Route2 0.203: v301.95,103.48 301.95,105.51 319.84,123.39 320.24,123.39 321.06,124.21 321.06,124.61 328.37,131.93 328.78,131.93 330.4,133.55 330.4,133.96 331.62,135.18 v332.03,135.18
  Bottom 0.203: v301.95,82.75 305.61,82.75 C12.V2 | v330.81,157.12 329.59,158.34 329.18,158.34 B11.S1
SLICE  (via drill 0.61)
  Top 0.203: v117.45,231.5 117.45,231.09 108.51,222.15 108.51,219.71 103.63,219.71 A28.V2 | v205.64,230.28 207.26,228.65 A20.S2 | B18.S2 233.68,159.56 234.49,160.38 234.49,227.03 233.68,227.84 A18.S2
  Bottom 0.203: 218.64,159.97 209.3,159.97 208.48,159.16 B20.S2 | 218.64,159.97 219.86,158.75 B19.S2 | 218.64,159.97 232.05,159.97 232.87,159.16 B18.S2 | v117.45,231.5 119.08,233.12 201.57,233.12 204.42,230.28 v205.64,230.28 | 219.05,227.43 219.86,228.24 A19.S2 | 219.05,227.43 209.3,227.43 208.48,228.24 A20.S2 | 232.05,227.43 232.87,228.24 A18.S2 | 219.05,227.43 232.05,227.43 | 232.05,227.43 244.65,227.43 245.47,228.24 A17.S2
SPECIAL_CYCLE\  (via drill 0.61)
  Top 0.203: v304.39,59.18 304.39,83.97 304.8,84.38 304.8,105.92 304.39,106.32 v304.39,118.52 | v328.37,132.74 328.37,135.99 C11.A1 | v319.84,124.21 319.43,123.8 319.43,121.36 C11.F2
  Route2 0.203: v319.84,124.21 v328.37,132.74
  Bottom 0.203: v304.39,59.18 295.86,59.18 294.23,57.56 D13.D2 | v304.39,118.52 305.21,119.33 317.81,119.33 318.62,120.14 C11.F2
SPIKE_DETECT
  Top 0.203: C32.R1 58.12,95.76 56.9,96.98 56.9,103.48 56.08,104.29 C32.M2
SR00  (via drill 0.61)
  Route2 0.203: v408.84,196.54 408.84,196.95 426.31,214.43 426.31,216.46 450.7,240.84 450.7,252.22 449.48,253.44 A01.H2
  Bottom 0.203: v408.84,196.54 404.77,192.48 385.67,192.48 384.05,190.86 379.98,190.86 AB07.BE1
SR01  (via drill 0.61)
  Top 0.203: v368.61,211.99 368.61,199.39 369.01,198.98 369.01,194.51 369.42,194.11 AB07.BD2 | v445.82,216.05 450.7,220.93 450.7,250.6 446.63,254.66 446.63,256.69 A01.F2
  Bottom 0.203: v368.61,211.99 391.36,211.99 395.83,216.46 442.98,216.46 443.38,216.05 v445.82,216.05
SR02
  Route2 0.203: AB06.BE1 392.18,191.26 392.18,194.92 399.9,202.64 399.9,205.49 403.15,208.74 403.15,210.77 441.35,248.97 441.35,250.6 447.45,256.69 447.45,257.91 449.07,259.54 A01.E2
SR03
  Route2 0.203: AB06.BD2 383.24,194.11 383.24,196.14 385.27,198.17 386.49,198.17 387.71,199.39 387.71,207.92 408.43,228.65 409.25,228.65 442.16,261.57 443.79,261.57 445.41,263.2 A01.D2
SR04  (via drill 0.61)
  Top 0.203: v408.43,217.27 406.81,215.65 406.81,202.23 405.99,201.42 405.99,192.07 405.18,191.26 AB05.BE1
  Route2 0.203: v408.43,217.27 440.94,249.78 440.94,254.25 448.26,261.57 450.29,261.57 451.92,263.2 A01.D1
SR05  (via drill 0.61)
  Top 0.203: v397.05,139.24 397.05,191.26 395.43,192.89 AB05.BD2
  Bottom 0.203: v397.05,139.24 450.7,139.24 450.7,116.89 446.63,112.83 446.23,112.83 446.23,108.76 C01.L2
SR06
  Route15 0.203: C01.K2 448.67,111.61 448.67,116.08 447.85,116.89 447.85,128.68 447.45,129.08 447.45,144.93 428.35,164.03 428.35,177.44 419.4,186.38 419.4,188.82 418.19,190.04 AB04.BE1
SR07  (via drill 0.61)
  Top 0.203: v415.34,125.02 412.5,125.02 412.5,161.59 409.25,164.85 409.25,191.67 408.03,192.89 AB04.BD2
  Bottom 0.203: v415.34,125.02 427.13,125.02 432.82,119.33 434.44,119.33 434.85,118.92 445.82,118.92 445.82,114.86 C01.J2
SR08
  Route15 0.203: C01.H2 449.48,118.11 449.48,120.14 456.39,127.05 454.36,129.08 454.36,145.34 451.1,148.59 451.1,160.38 443.38,168.1 442.98,168.1 442.57,168.5 442.57,169.72 441.76,170.54 441.76,177.04 432,186.79 432,188.82 430.78,190.04 AB03.BE1
SR09
  Route15 0.203: C01.E2 449.07,124.61 449.07,128.27 447.85,129.49 447.85,145.34 428.75,164.44 428.75,183.54 422.66,189.64 422.66,191.26 421.03,192.89 AB03.BD2
SR10  (via drill 0.61)
  Top 0.203: v447.04,189.64 447.45,189.23 447.45,122.58 446.23,121.36 C01.F2
  Bottom 0.203: v447.04,189.64 446.63,190.04 443.38,190.04 AB02.BE1
SR11  (via drill 0.61)
  Top 0.203: v429.97,188.82 431.6,187.2 431.6,149 428.75,146.15 428.75,122.99 429.97,121.77 v429.97,119.74 | v445.41,109.58 447.45,109.58 447.45,79.1 445.01,76.66 445.01,72.59 449.48,68.12 450.7,68.12 450.7,36.83 449.48,35.61 D01.M2
  Bottom 0.203: v429.97,188.82 433.63,188.82 433.63,192.89 AB02.BD2 | v429.97,119.74 437.29,112.42 443.38,112.42 445.41,110.39 v445.41,109.58
SR_ENABLE  (via drill 0.61)
  Top 0.203: v369.42,210.77 369.42,212.39 368.2,213.61 368.2,230.68 365.35,233.53 365.35,258.32 366.57,259.54 A08.E1
  Route15 0.203: v369.42,210.77 373.48,206.7 373.48,204.67 377.55,200.61 377.55,198.58 378.76,197.36 AB07.BC1
  Bottom 0.203: 390.14,198.17 380.8,198.17 379.98,197.36 AB07.BC1 | 390.14,198.17 391.36,196.95 AB06.BC1 | 403.56,198.17 404.37,197.36 AB05.BC1 | 390.14,198.17 403.56,198.17 | 416.15,198.17 416.97,197.36 AB04.BC1 | 403.56,198.17 416.15,198.17 | 428.75,198.17 429.56,197.36 AB03.BC1 | 416.15,198.17 428.75,198.17 | 428.75,198.17 440.94,198.17 442.16,196.95 AB02.BC1
STOP_OK  (via drill 0.61)
  Top 0.203: v89.81,232.72 102.01,244.91 102.01,245.31 115.01,258.32 118.67,258.32 118.67,254.66 A27.H2
  Route15 0.203: v326.75,40.49 312.12,55.12 310.49,55.12 294.64,70.97 294.23,70.97 282.45,82.75 282.45,83.16 256.03,109.58 256.03,111.2 235.31,131.93 235.31,132.74 232.05,135.99 232.05,136.8 164.19,204.67 160.53,204.67 156.06,209.14 156.06,213.21 122.33,246.94 122.33,248.56 121.11,249.78 121.11,251.82 119.48,253.44 A27.H2
  Bottom 0.203: v89.81,232.72 61.37,232.72 60.55,233.53 6.1,233.53 5.28,234.34 A36.P2 | v326.75,40.49 327.15,40.08 335.69,40.08 338.12,42.52 352.75,42.52 353.57,41.71 D09.K1
STROBE\  (via drill 0.61)
  Top 0.203: v406.81,136.4 406.81,103.07 407.62,102.26 C04.N2 | v332.84,81.13 331.22,79.5 331.22,69.75 329.59,68.12 327.15,68.12 327.15,65.28 330,62.43 330,59.59 329.18,58.78 v328.37,58.78 | v416.15,57.56 419,54.71 419,54.3 423.06,54.3 CD03.BE2
  Route15 0.203: v81.69,157.94 81.69,157.12 123.55,115.27 123.55,110.79 v138.58,95.76 | v438.51,54.71 438.1,55.12 438.1,57.56 437.69,57.96 437.69,67.72 436.88,68.53 436.88,69.75 408.43,98.2 408.43,101.04 C04.N2
  Bottom 0.203: v406.81,136.4 408.43,138.02 415.75,138.02 416.97,136.8 C04.A1 | 438.1,54.3 441.76,50.65 441.76,49.02 443.38,49.02 444.19,48.21 444.19,40.49 442.16,38.46 440.54,38.46 D02.L1 | 438.1,54.3 437.29,55.12 424.69,55.12 424.28,54.71 CD03.BE2 | 244.25,87.63 243.43,88.44 C17.T2 | 244.25,87.63 261.72,87.63 265.38,83.97 270.26,83.97 273.51,80.72 332.44,80.72 v332.84,81.13 | D11.D1 325.93,57.56 327.15,57.56 v328.37,58.78 328.37,58.37 332.44,58.37 334.87,55.93 338.53,55.93 341.38,58.78 389.74,58.78 390.14,58.37 415.34,58.37 v416.15,57.56 | v81.69,157.94 81.28,157.53 31.7,157.53 30.89,158.34 B34.S2 | v138.58,95.76 143.46,90.88 168.25,90.88 169.06,90.07 214.58,90.07 217.02,87.63 244.25,87.63 | v438.51,54.71 438.1,54.3
STROBE_FIELD0  (via drill 0.61)