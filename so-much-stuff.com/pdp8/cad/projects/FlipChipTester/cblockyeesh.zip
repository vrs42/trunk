# EAGLE board cblockyeesh (EAGLE 4.11), part 2 of 2
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
N$168 (continued)
  Top 0.203: SIDE10.16 46.35,119.38 56.52,119.38 57.15,120.02 63.5,120.02 64.14,119.38 A4.H1
N$169
  Top 0.203: SIDE10.20 46.35,114.3 60.33,114.3 60.96,114.94 A4.J1
N$170
  Top 0.203: SIDE10.18 46.35,116.84 62.23,116.84 64.14,114.94 64.14,113.03 A4.K1
N$171
  Top 0.203: SIDE10.24 46.35,109.22 52.7,109.22 53.98,110.49 60.33,110.49 60.96,109.86 A4.L1
N$172
  Top 0.203: SIDE10.28 46.35,104.14 62.87,104.14 64.14,105.41 A4.M1
N$173
  Bottom 0.203: SIDE10.22 46.35,111.76 50.16,111.76 58.42,103.5 60.96,103.5 A4.N1
N$174  (via drill 0.61)
  Top 0.203: v66.04,103.5 64.77,102.23 64.77,100.33 A4.P1 | v59.69,101.6 46.35,101.6 SIDE10.30
  Bottom 0.203: v66.04,103.5 64.14,103.5 62.23,101.6 v59.69,101.6
N$175
  Bottom 0.203: SIDE10.26 46.35,106.68 53.34,106.68 60.96,99.06 60.96,97.16 A4.R1
N$176  (via drill 0.61)
  Top 0.203: v64.14,97.79 47.62,97.79 46.35,99.06 SIDE10.32
  Bottom 0.203: v64.14,97.79 65.41,96.52 64.77,95.89 64.77,93.98 A4.S1
N$177
  Top 0.203: SIDE10.34 46.35,96.52 52.07,96.52 57.78,90.81 60.96,90.81 A4.T1
N$178  (via drill 0.61)
  Top 0.203: v57.78,83.19 60.96,86.36 64.14,86.36 A4.U1 | v34.92,85.09 24.77,95.25 24.77,110.49 29.84,115.57 33.66,115.57 39.37,121.28 39.37,135.25 42.55,138.43 46.35,138.43 46.99,137.79 46.99,136.53 45.72,135.25 SIDE10.4
  Bottom 0.203: v57.78,83.19 56.52,83.19 55.88,82.55 37.47,82.55 v34.92,85.09
N$179  (via drill 0.61)
  Top 0.203: v49.53,85.72 41.91,93.34 40.01,93.34 38.73,94.61 38.73,99.06 40.64,100.97 40.64,112.39 38.73,114.3 38.73,120.02 41.91,123.19 41.91,135.25 42.55,135.89 43.81,135.89 45.09,137.16 SIDE10.2
  Bottom 0.203: v49.53,85.72 59.69,85.72 60.96,84.45 A4.V1
N$180  (via drill 0.61)
  Top 0.203: SIDE10.33 43.18,97.16 43.18,98.42 SIDE10.31 43.18,99.69 43.18,100.97 SIDE10.29 43.18,102.23 43.18,103.5 SIDE10.27 43.18,104.78 43.18,106.05 SIDE10.25 43.18,107.31 43.18,108.58 SIDE10.23 43.18,109.86 43.18,111.12 SIDE10.21 43.18,112.39 43.18,113.67 SIDE10.19 42.55,114.3 39.37,117.47 39.37,120.02 43.18,123.83 | SIDE10.17 43.18,117.47 43.18,118.75 SIDE10.15 | 43.18,123.83 43.18,122.56 SIDE10.13 | 43.18,123.83 SIDE10.11 | SIDE10.11 43.18,125.09 43.18,126.36 SIDE10.9 43.18,127.64 43.18,128.91 SIDE10.7 43.18,130.18 43.18,131.44 SIDE10.5 43.18,132.72 43.18,133.99 SIDE10.3 | v62.87,125.73 64.14,127 64.14,130.81 A4.C1 | v40.64,134.62 40.64,135.25 42.55,137.16 SIDE10.1 | 43.18,123.83 SIDE10.11
  Bottom 0.203: 43.18,120.65 43.18,120.02 SIDE10.15 | 43.18,120.65 43.18,121.28 SIDE10.13 | v62.87,125.73 62.87,123.19 66.04,120.02 66.04,118.11 64.77,116.84 54.61,116.84 50.8,120.65 43.18,120.65 | v40.64,134.62 42.55,134.62 SIDE10.3
N$181
  Top 0.203: SIDE11.33 137.16,23.5 137.16,24.77 SIDE11.31 137.16,26.04 137.16,27.3 SIDE11.29 137.16,28.57 137.16,29.84 SIDE11.27 137.16,31.11 137.16,32.38 SIDE11.25 137.16,33.66 137.16,34.92 SIDE11.23 137.16,36.2 137.16,37.47 SIDE11.21 137.16,38.73 137.16,40.01 SIDE11.19 137.16,41.27 137.16,42.55 SIDE11.17 137.16,43.81 137.16,45.09 SIDE11.15 137.16,46.35 137.16,47.62 SIDE11.13 137.16,48.9 137.16,50.16 SIDE11.11 137.16,51.44 137.16,52.7 SIDE11.9 137.16,53.98 137.16,55.24 SIDE11.7 137.16,56.52 137.16,57.78 SIDE11.5 137.16,59.05 137.16,60.33 SIDE11.3 137.16,61.59 137.16,62.87 SIDE11.1 136.53,63.5 101.6,63.5 100.97,62.87 88.9,62.87 88.27,62.23 83.82,62.23 A6.C2
N$182  (via drill 0.61)
  Top 0.203: v123.83,70.48 102.23,70.48 100.97,69.22 88.9,69.22 88.27,68.58 83.82,68.58 A6.A2
  Bottom 0.203: v123.83,70.48 129.54,64.77 137.79,64.77 139.06,63.5 SIDE11.2
N$183  (via drill 0.61)
  Top 0.203: v127,68.58 122.56,73.03 107.95,73.03 99.69,81.28 94.61,81.28 80.64,67.31 80.64,65.41 A6.B2
  Bottom 0.203: v127,68.58 130.18,65.41 139.7,65.41 140.97,64.14 140.97,62.87 139.7,61.59 SIDE11.4
N$184  (via drill 0.61)
  Top 0.203: v88.27,69.85 100.97,69.85 102.87,71.75 v120.02,71.75 | v127,64.77 137.79,64.77 138.43,64.14 138.43,60.33 139.7,59.05 SIDE11.6
  Bottom 0.203: v88.27,69.85 88.27,69.22 80.64,61.59 80.64,59.05 A6.D2 | v120.02,71.75 v127,64.77
N$185
  Bottom 0.203: A6.E2 83.82,55.88 83.82,59.69 94.61,70.48 118.11,70.48 126.36,62.23 131.44,62.23 136.53,57.15 137.79,57.15 139.06,55.88 SIDE11.8
N$186  (via drill 0.61)
  Top 0.203: v87,74.93 93.98,81.92 99.69,81.92 107.95,73.66 131.44,73.66 v133.35,71.75 | v134.62,70.48 140.97,64.14 140.97,55.24 139.7,53.98 SIDE11.10
  Bottom 0.203: v87,74.93 87,68.58 78.74,60.33 78.74,57.78 80.01,56.52 80.01,52.7 A6.F2 | v133.35,71.75 v134.62,70.48
N$187  (via drill 0.61)
  Top 0.203: v98.42,59.69 104.14,59.69 104.78,59.05 118.11,59.05 v119.38,60.33
  Bottom 0.203: v98.42,59.69 92.08,59.69 85.09,52.7 85.09,52.07 83.82,50.8 83.82,49.53 A6.H2 | v119.38,60.33 127,60.33 135.25,52.07 137.79,52.07 139.06,50.8 SIDE11.12
N$188  (via drill 0.61)
  Top 0.203: v135.89,17.14 140.97,22.23 140.97,46.35 139.7,47.62 SIDE11.14
  Bottom 0.203: v135.89,17.14 128.27,9.53 111.76,9.53 110.49,10.79 93.34,10.79 90.81,13.34 90.81,13.97 89.53,15.24 88.9,15.24 85.09,19.05 85.09,20.95 85.72,21.59 85.72,24.13 85.09,24.77 85.09,27.3 88.27,30.48 88.27,33.66 80.64,41.27 80.64,45.09 A6.J2
N$189  (via drill 0.61)
  Top 0.203: v99.69,49.53 101.6,47.62 103.5,47.62 109.22,53.34 109.22,54.61 110.49,55.88 114.3,55.88 117.47,52.7 117.47,41.91 v116.2,40.64 | v129.54,31.75 v129.54,40.01
  Bottom 0.203: v99.69,49.53 99.06,50.16 88.9,50.16 83.82,45.09 83.82,43.18 A6.K2 | v116.2,40.64 116.2,39.37 123.83,31.75 v129.54,31.75 | v129.54,40.01 136.53,46.99 137.79,46.99 139.06,45.72 SIDE11.16
N$190  (via drill 0.61)
  Top 0.203: v83.19,51.44 85.09,51.44 88.9,47.62 v92.08,47.62 | v121.28,33.02 121.28,28.57 v123.19,26.67 | v135.25,34.29 v135.25,43.18
  Bottom 0.203: v83.19,51.44 78.74,46.99 78.74,45.09 80.01,43.81 80.01,40.01 A6.L2 | v92.08,47.62 100.97,47.62 109.22,39.37 114.94,39.37 v121.28,33.02 | v123.19,26.67 127.64,26.67 v135.25,34.29 | v135.25,43.18 136.53,44.45 137.79,44.45 139.06,43.18 SIDE11.18
N$191  (via drill 0.61)
  Top 0.203: v132.72,35.56 132.72,16.51 122.56,6.35 111.76,6.35 109.86,8.26 101.6,8.26 88.27,21.59 88.27,27.3 83.82,31.75 83.82,35.56 A6.M2
  Bottom 0.203: v132.72,35.56 136.53,39.37 137.79,39.37 139.06,40.64 SIDE11.20
N$192  (via drill 0.61)
  Top 0.203: v128.91,8.89 142.24,22.23 v142.24,40.01
  Bottom 0.203: v128.91,8.89 111.76,8.89 110.49,10.16 92.08,10.16 88.27,13.97 88.27,14.61 81.92,20.95 81.92,27.3 80.64,28.57 80.64,32.38 A6.N2 | v142.24,40.01 140.34,38.1 SIDE11.22
N$193  (via drill 0.61)
  Top 0.203: v135.25,33.02 133.35,31.11 133.35,16.51 122.56,5.71 111.76,5.71 109.86,7.62 101.6,7.62 83.82,25.4 83.82,29.21 A6.P2
  Bottom 0.203: v135.25,33.02 136.53,34.29 137.79,34.29 139.06,35.56 SIDE11.24
N$194
  Bottom 0.203: A6.R2 80.01,26.04 80.01,22.23 78.74,20.95 78.74,19.68 88.9,9.53 110.49,9.53 111.76,8.26 128.27,8.26 128.91,7.62 130.18,7.62 141.6,19.05 141.6,30.48 139.7,32.38 SIDE11.26
N$195  (via drill 0.61)
  Top 0.203: v83.82,39.37 81.92,37.47 81.92,29.21 83.19,27.94 83.19,24.13 A6.S2 | v91.44,19.68 93.98,17.14 93.98,16.51 98.42,12.06 v101.6,12.06 | v135.89,26.67 v135.89,31.75
  Bottom 0.203: v83.82,39.37 91.44,31.75 91.44,24.77 92.08,24.13 92.08,21.59 91.44,20.95 v91.44,19.68 | v101.6,12.06 109.86,12.06 111.76,10.16 123.83,10.16 135.89,22.23 v135.89,26.67 | v135.89,31.75 137.79,31.75 139.06,30.48 SIDE11.28
N$196  (via drill 0.61)
  Top 0.203: v80.64,16.51 80.64,19.68 A6.T2 | v138.43,14.61 v138.43,17.14
  Bottom 0.203: v80.64,16.51 88.27,8.89 110.49,8.89 111.76,7.62 128.27,7.62 128.91,6.99 130.18,6.99 137.79,14.61 v138.43,14.61 | v138.43,17.14 138.43,26.04 139.7,27.3 SIDE11.30
N$197  (via drill 0.61)
  Top 0.203: v94.61,5.08 90.81,5.08 83.82,12.06 83.82,16.51 A6.U2 | v121.92,4.45 139.7,22.23 SIDE11.34
  Bottom 0.203: v94.61,5.08 109.22,5.08 109.86,4.45 v121.92,4.45
N$198  (via drill 0.61)
  Top 0.203: v137.16,12.7 v137.16,15.88 | v137.16,20.95 138.43,22.23 138.43,23.5 139.7,24.77 SIDE11.32
  Bottom 0.203: v137.16,12.7 130.81,6.35 128.91,6.35 128.27,6.99 111.76,6.99 110.49,8.26 88.27,8.26 83.19,13.34 80.64,13.34 A6.V2 | v137.16,15.88 v137.16,20.95
N$199  (via drill 0.61)
  Top 0.203: v91.44,64.77 90.17,66.04 90.17,67.31 A6.A1 | v90.17,59.05 95.89,53.34 v100.33,53.34 | v109.86,43.18 111.12,41.91 v116.2,41.91
  Bottom 0.203: v91.44,64.77 89.53,62.87 88.9,62.87 88.27,62.23 88.27,60.96 v90.17,59.05 | v100.33,53.34 109.86,43.81 v109.86,43.18 | v116.2,41.91 123.83,34.29 128.91,34.29 136.53,41.91 140.34,41.91 148.59,50.16 148.59,56.52 149.22,57.15 150.5,57.15 151.76,58.42 SIDE12.10
N$200
  Bottom 0.203: A6.B1 87,65.41 87,67.31 90.81,71.12 117.47,71.12 119.38,73.03 123.83,73.03 130.18,66.67 147.32,66.67 149.22,64.77 150.5,64.77 151.76,63.5 SIDE12.6
N$201  (via drill 0.61)
  Top 0.203: v120.65,69.22 101.6,69.22 100.97,68.58 99.69,68.58 94.61,63.5 83.19,63.5 81.92,62.23 81.92,60.96 83.82,59.05 86.36,59.05 A6.D1
  Bottom 0.203: v120.65,69.22 127,62.87 133.35,62.87 136.53,59.69 150.5,59.69 151.76,60.96 SIDE12.8
N$202  (via drill 0.61)
  Top 0.203: v80.01,50.16 v82.55,47.62 | v85.72,69.85 87,69.85 88.27,71.12 95.25,71.12 95.89,70.48 100.97,70.48 v104.14,73.66
  Bottom 0.203: v82.55,47.62 84.45,47.62 89.53,52.7 89.53,54.61 A6.E1 | v80.01,50.16 78.74,51.44 78.74,57.15 78.11,57.78 78.11,60.33 85.72,67.94 v85.72,69.85 | v104.14,73.66 149.22,73.66 153.67,69.22 153.67,57.78 152.4,56.52 SIDE12.12
N$203  (via drill 0.61)
  Top 0.203: v121.28,39.37 101.6,39.37 89.53,51.44 87,51.44 A6.F1 | v125.73,36.83 125.73,29.84 126.36,29.21 v128.27,29.21
  Bottom 0.203: v121.28,39.37 123.83,36.83 v125.73,36.83 | v128.27,29.21 135.89,36.83 140.34,36.83 143.51,40.01 143.51,43.81 149.22,49.53 150.5,49.53 151.13,50.16 151.13,51.44 152.4,52.7 SIDE12.14
N$204  (via drill 0.61)
  Top 0.203: v109.86,33.02 109.86,27.94 111.12,26.67 115.57,26.67 v123.19,19.05 | v134.62,26.04 v134.62,28.57 | v131.44,29.21 131.44,50.8 v135.25,54.61 | v144.15,58.42 144.15,64.77 149.22,69.85 150.5,69.85 151.13,69.22 151.13,52.7 152.4,51.44 SIDE12.16
  Bottom 0.203: v109.86,33.02 102.23,33.02 90.17,45.09 90.17,48.26 A6.H1 | v123.19,19.05 127.64,19.05 v134.62,26.04 | v134.62,28.57 132.08,28.57 v131.44,29.21 | v135.25,54.61 140.34,54.61 v144.15,58.42
N$205  (via drill 0.61)
  Top 0.203: v107.95,17.14 107.95,33.02 103.5,37.47 97.79,37.47 90.17,45.09 87,45.09 A6.J1 | v140.34,19.05 142.88,19.05 151.13,27.3 151.13,43.81 152.4,45.09 SIDE12.20
  Bottom 0.203: v107.95,17.14 111.12,13.97 116.2,13.97 123.83,21.59 128.91,21.59 136.53,29.21 140.34,29.21 140.97,28.57 140.97,19.68 v140.34,19.05
N$206  (via drill 0.61)
  Top 0.203: v59.69,27.3 67.94,35.56 69.22,35.56 69.85,34.92 72.39,34.92 74.93,37.47 80.64,37.47 85.09,41.91 89.53,41.91 A6.K1 | v29.21,12.06 34.92,12.06 45.72,1.27 131.44,1.27 156.21,26.04 156.21,43.81 152.4,47.62 SIDE12.18
  Bottom 0.203: v59.69,27.3 52.07,19.68 52.07,19.05 49.53,16.51 39.37,16.51 34.29,21.59 29.84,21.59 29.21,20.95 v29.21,12.06
N$207  (via drill 0.61)
  Top 0.203: v85.09,33.66 86.36,34.92 86.36,38.73 A6.L1 | v89.53,13.97 100.97,2.54 129.54,2.54 v136.53,9.53
  Bottom 0.203: v85.09,33.66 85.09,27.94 84.45,27.3 84.45,24.77 85.09,24.13 85.09,21.59 84.45,20.95 84.45,19.05 v89.53,13.97 | v136.53,9.53 146.69,19.68 146.69,36.83 149.22,39.37 150.5,39.37 151.76,40.64 SIDE12.24
N$208  (via drill 0.61)
  Top 0.203: v99.06,54.61 100.97,54.61 101.6,53.98 103.5,53.98 107.95,58.42 114.94,58.42 v117.47,55.88 | v143.51,46.35 143.51,34.92 v147.96,30.48
  Bottom 0.203: v99.06,54.61 98.42,53.98 92.08,53.98 81.92,43.81 81.92,41.91 82.55,41.27 87,41.27 89.53,38.73 89.53,36.83 A6.M1 | v117.47,55.88 123.83,49.53 140.34,49.53 v143.51,46.35 | v147.96,30.48 149.22,29.21 153.03,29.21 153.67,29.84 153.67,33.66 152.4,34.92 SIDE12.28
N$209  (via drill 0.61)
  Top 0.203: v89.53,27.94 87,30.48 87,32.38 A6.N1 | v88.27,18.41 84.45,14.61 84.45,12.7 v90.17,6.99 | v154.94,26.04 154.94,26.67 155.57,27.3 155.57,40.64 153.03,43.18 SIDE12.22
  Bottom 0.203: v89.53,27.94 89.53,26.04 91.44,24.13 91.44,21.59 v88.27,18.41 | v90.17,6.99 95.25,1.91 130.81,1.91 v154.94,26.04
N$210  (via drill 0.61)
  Top 0.203: v89.53,21.59 93.98,21.59 94.61,20.95 94.61,16.51 97.16,13.97 v97.79,13.97 | v95.89,12.06 100.97,6.99 109.86,6.99 113.67,3.17 125.09,3.17 133.35,11.43 137.79,11.43 153.67,27.3 153.67,31.11 152.4,32.38 SIDE12.30
  Bottom 0.203: v89.53,21.59 88.27,22.86 88.27,27.94 89.53,29.21 A6.P1 | v95.89,12.06 v97.79,13.97
N$211  (via drill 0.61)
  Top 0.203: v90.81,15.88 90.81,13.97 99.06,5.71 v109.86,5.71 | v128.27,5.08 130.81,5.08 136.53,10.79 137.79,10.79 154.31,27.3 154.31,35.56 152.4,37.47 SIDE12.26
  Bottom 0.203: v90.81,15.88 88.9,15.88 87,17.78 87,18.41 88.27,19.68 88.27,20.95 87,22.23 87,26.04 A6.R1 | v109.86,5.71 127.64,5.71 v128.27,5.08
N$212  (via drill 0.61)
  Top 0.203: v154.94,49.53 156.21,50.8 156.21,120.02 131.44,144.78 95.89,144.78 92.08,140.97 78.11,140.97 75.56,138.43 75.56,135.89 76.2,135.25 76.2,133.99 75.56,133.35 75.56,123.83 78.74,120.65 78.74,105.41 78.11,104.78 78.11,102.23 78.74,101.6 78.74,97.79 72.39,91.44 72.39,69.85 78.74,63.5 78.74,60.96 78.11,60.33 78.11,57.78 81.92,53.98 81.92,51.44 83.19,50.16 84.45,50.16 85.09,49.53 85.09,45.09 85.72,44.45 90.17,44.45 91.44,43.18 91.44,28.57 90.17,27.3 90.17,24.13 A6.S1
  Bottom 0.203: v154.94,49.53 154.94,41.27 155.57,40.64 155.57,39.37 153.03,36.83 151.76,36.83 151.13,36.2 151.13,32.38 152.4,31.11 SIDE12.32
N$213  (via drill 0.61)
  Top 0.203: v94.61,3.81 90.81,3.81 81.92,12.7 81.92,17.78 83.82,19.68 86.36,19.68 A6.T1
  Bottom 0.203: v94.61,3.81 95.89,2.54 130.81,2.54 152.4,24.13 152.4,27.3 SIDE12.34
N$214  (via drill 0.61)
  Top 0.203: v154.31,40.64 154.94,40.01 154.94,27.3 153.67,26.04 153.67,25.4 130.18,1.91 99.06,1.91 93.98,6.99 91.44,6.99 85.09,13.34 85.09,14.61 87,16.51 89.53,16.51 A6.U1 | v153.67,49.53 153.67,64.14 152.4,65.41 SIDE12.4
  Bottom 0.203: v154.31,40.64 154.31,48.9 v153.67,49.53
N$215  (via drill 0.61)
  Top 0.203: v95.25,6.99 88.9,13.34 87,13.34 A6.V1 | v144.78,42.55 144.78,56.52 142.88,58.42 142.88,66.67 147.32,71.12 150.5,71.12 152.4,69.22 SIDE12.2
  Bottom 0.203: v95.25,6.99 111.12,6.99 111.76,6.35 128.27,6.35 129.54,5.08 130.18,5.08 136.53,11.43 137.16,11.43 144.78,19.05 v144.78,42.55
N$216  (via drill 0.61)
  Top 0.203: SIDE12.33 149.86,28.57 149.86,29.84 SIDE12.31 149.86,31.11 149.86,32.38 SIDE12.29 149.86,33.66 149.86,34.92 SIDE12.27 149.86,36.2 149.86,37.47 SIDE12.25 149.86,38.73 149.86,40.01 SIDE12.23 149.86,41.27 149.86,42.55 SIDE12.21 149.86,43.81 149.86,45.09 SIDE12.19 149.86,46.35 149.86,47.62 SIDE12.17 149.86,48.9 149.86,50.16 SIDE12.15 149.86,51.44 149.86,52.7 SIDE12.13 149.86,53.98 149.86,55.24 SIDE12.11 149.86,56.52 149.86,57.78 SIDE12.9 149.86,59.05 149.86,60.33 SIDE12.7 149.86,61.59 149.86,62.87 SIDE12.5 149.86,64.14 149.86,65.41 SIDE12.3 149.86,66.67 149.86,67.94 SIDE12.1 | v97.79,65.41 98.42,66.04 125.73,66.04 v128.91,69.22
  Bottom 0.203: v97.79,65.41 94.61,62.23 90.17,62.23 A6.C1 | v128.91,69.22 149.86,69.22 SIDE12.1
N$217  (via drill 0.61)
  Top 0.203: SIDE13.33 5.08,28.57 5.08,29.84 SIDE13.31 5.08,31.11 5.08,32.38 SIDE13.29 5.08,33.66 5.08,34.92 SIDE13.27 5.08,36.2 5.08,36.83 | 5.08,36.83 5.08,37.47 SIDE13.25 5.08,38.73 5.08,40.01 SIDE13.23 5.08,41.27 5.08,42.55 SIDE13.21 5.08,43.81 5.08,45.09 SIDE13.19 5.08,46.35 5.08,47.62 SIDE13.17 5.08,48.9 5.08,50.16 SIDE13.15 5.08,51.44 5.08,52.7 SIDE13.13 5.08,53.98 5.08,55.24 SIDE13.11 5.08,56.52 5.08,57.78 SIDE13.9 5.08,59.05 5.08,60.33 SIDE13.7 5.08,61.59 5.08,62.87 SIDE13.5 5.08,64.14 5.08,65.41 SIDE13.3 5.08,66.67 5.08,67.94 SIDE13.1 | v58.42,46.99 62.23,50.8 68.58,50.8 72.39,54.61 72.39,59.05 73.03,59.69 73.03,60.33 71.75,61.59 71.12,61.59 A7.C2 | v37.47,46.99 v40.01,46.99 | v23.5,40.64 23.5,35.56 v24.77,34.29 | v16.51,34.29 10.79,34.29 8.26,36.83 5.08,36.83
  Bottom 0.203: v40.01,46.99 v58.42,46.99 | v37.47,46.99 29.84,46.99 v23.5,40.64 | v16.51,34.29 v24.77,34.29
N$218  (via drill 0.61)
  Top 0.203: v67.31,71.75 70.48,68.58 A7.A2 | v14.61,74.93 v53.34,74.93
  Bottom 0.203: v67.31,71.75 60.96,71.75 60.33,71.12 57.15,71.12 v53.34,74.93 | v14.61,74.93 8.26,68.58 SIDE13.2
N$219  (via drill 0.61)
  Top 0.203: v66.04,67.31 66.04,66.67 67.31,65.41 A7.B2 | v47.62,69.22 11.43,69.22 8.26,66.04 SIDE13.4
  Bottom 0.203: v66.04,67.31 66.04,68.58 65.41,69.22 v47.62,69.22
N$220  (via drill 0.61)
  Top 0.203: v71.75,60.33 69.22,60.33 67.94,59.05 A7.D2
  Bottom 0.203: v71.75,60.33 75.56,64.14 75.56,65.41 71.12,69.85 55.88,69.85 45.09,80.64 30.48,80.64 13.34,63.5 8.26,63.5 SIDE13.6
N$221  (via drill 0.61)
  Top 0.203: v45.72,59.05 49.53,55.24 50.16,55.24 v51.44,53.98 | v64.14,53.34 69.22,53.34 70.48,54.61 A7.E2
  Bottom 0.203: v45.72,59.05 40.01,64.77 17.14,64.77 13.34,60.96 8.26,60.96 SIDE13.8 | v51.44,53.98 53.98,53.98 56.52,56.52 60.96,56.52 v64.14,53.34
N$222  (via drill 0.61)
  Top 0.203: v64.14,6.35 62.87,5.08 v46.35,5.08 | v27.3,3.81 v31.11,3.81
  Bottom 0.203: v64.14,6.35 64.14,6.99 78.74,21.59 78.74,37.47 67.94,48.26 67.94,51.44 A7.F2 | v46.35,5.08 45.09,3.81 v31.11,3.81 | v27.3,3.81 3.81,27.3 3.81,56.52 4.45,57.15 5.71,57.15 6.99,58.42 SIDE13.10
N$223  (via drill 0.61)
  Top 0.203: v21.59,44.45 v26.67,39.37 | v38.73,39.37 41.27,36.83 47.62,36.83 55.24,44.45 57.15,44.45 62.87,50.16 69.85,50.16 70.48,49.53 A7.H2
  Bottom 0.203: v21.59,44.45 17.14,44.45 16.51,45.09 16.51,46.35 7.62,55.24 SIDE13.12 | v26.67,39.37 v38.73,39.37
N$224  (via drill 0.61)
  Top 0.203: v34.29,34.29 v40.01,28.57 | v43.18,26.67 43.18,28.57 43.81,29.21 46.35,29.21 55.24,38.1 62.87,38.1 67.31,42.55 67.31,45.09 A7.J2
  Bottom 0.203: v34.29,34.29 29.84,34.29 24.77,39.37 17.14,39.37 15.88,40.64 15.88,44.45 7.62,52.7 SIDE13.14 | v40.01,28.57 40.01,27.94 41.27,26.67 v43.18,26.67
N$225  (via drill 0.61)
  Top 0.203: v57.15,53.34 53.98,53.34 45.09,44.45 38.73,44.45 33.66,49.53 32.38,49.53 31.75,50.16 v31.75,52.07 | v10.79,50.8 8.26,50.8 SIDE13.16
  Bottom 0.203: v57.15,53.34 67.31,43.18 70.48,43.18 A7.K2 | v31.75,52.07 29.84,52.07 22.86,45.09 22.86,43.81 20.95,41.91 17.14,41.91 16.51,42.55 16.51,44.45 10.79,50.16 v10.79,50.8
N$226  (via drill 0.61)
  Top 0.203: v53.98,12.7 62.87,12.7 69.22,19.05 v69.22,34.29
  Bottom 0.203: v53.98,12.7 52.07,10.79 27.94,10.79 15.24,23.5 15.24,40.01 7.62,47.62 SIDE13.18 | v69.22,34.29 69.22,37.47 67.94,38.73 A7.L2
N$227  (via drill 0.61)
  Top 0.203: v16.51,36.83 15.88,36.83 7.62,45.09 SIDE13.20 | v26.04,36.83 v29.21,36.83 | v36.2,36.83 41.27,31.75 45.09,31.75 53.98,40.64 64.77,40.64 66.04,41.91 66.04,46.35 66.67,46.99 68.58,46.99 75.56,40.01 75.56,38.73 73.66,36.83 71.12,36.83 A7.M2
  Bottom 0.203: v16.51,36.83 v26.04,36.83 | v29.21,36.83 v36.2,36.83
N$228  (via drill 0.61)
  Top 0.203: v62.87,19.68 66.04,22.86 66.04,31.11 67.31,32.38 A7.N2
  Bottom 0.203: v62.87,19.68 53.34,10.16 27.94,10.16 14.61,23.5 14.61,35.56 7.62,42.55 SIDE13.22
N$229  (via drill 0.61)
  Top 0.203: v16.51,49.53 6.99,49.53 6.35,48.9 6.35,42.55 7.62,41.27 SIDE13.24 | v26.04,57.15 26.67,57.15 31.11,61.59 33.02,61.59 33.66,62.23 55.24,62.23 57.15,64.14 57.78,64.14 58.42,63.5 v59.69,64.77 | v68.58,63.5 68.58,61.59 66.04,59.05 v66.04,54.61
  Bottom 0.203: v16.51,49.53 20.95,49.53 26.04,54.61 v26.04,57.15 | v59.69,64.77 59.69,65.41 60.33,66.04 63.5,66.04 66.04,63.5 v68.58,63.5 | v66.04,54.61 66.04,49.53 72.39,43.18 72.39,31.75 71.12,30.48 A7.P2
N$230  (via drill 0.61)
  Top 0.203: v62.87,18.41 67.31,22.86 67.31,26.04 A7.R2
  Bottom 0.203: v62.87,18.41 53.98,9.53 27.94,9.53 13.97,23.5 13.97,31.11 7.62,37.47 SIDE13.26
N$231  (via drill 0.61)
  Top 0.203: v72.39,17.78 72.39,16.51 65.41,9.53 50.16,9.53 48.9,8.26 40.64,8.26 34.92,13.97 30.48,13.97 26.04,18.41 20.32,18.41 16.51,22.23 16.51,26.04 7.62,34.92 SIDE13.28 | v72.39,20.95 70.48,22.86 A7.S2
  Bottom 0.203: v72.39,17.78 v72.39,20.95
N$232  (via drill 0.61)
  Top 0.203: v63.5,15.88 65.41,15.88 67.31,17.78 67.31,19.68 A7.T2
  Bottom 0.203: v63.5,15.88 60.96,15.88 53.98,8.89 27.94,8.89 13.34,23.5 13.34,26.67 7.62,32.38 SIDE13.30
N$233
  Bottom 0.203: SIDE13.34 7.62,27.3 7.62,26.04 32.38,1.27 56.52,1.27 67.94,12.7 68.58,12.7 70.48,14.61 70.48,16.51 A7.U2
N$234
  Bottom 0.203: SIDE13.32 7.62,29.84 12.7,24.77 12.7,23.5 27.94,8.26 62.23,8.26 67.31,13.34 A7.V2
N$235  (via drill 0.61)
  Top 0.203: v27.94,63.5 29.84,65.41 50.16,65.41 v55.88,71.12 | v74.3,70.48 76.83,67.94 A7.A1
  Bottom 0.203: v27.94,63.5 24.13,59.69 24.13,57.78 20.32,53.98 SIDE14.10 | v55.88,71.12 56.52,71.12 57.15,70.48 v74.3,70.48
N$236  (via drill 0.61)
  Top 0.203: v64.77,66.04 53.98,66.04 50.8,62.87 33.66,62.87 33.02,62.23 31.11,62.23 27.3,58.42 20.95,58.42 SIDE14.6
  Bottom 0.203: v64.77,66.04 73.03,66.04 73.66,65.41 A7.B1
N$237  (via drill 0.61)
  Top 0.203: v57.15,62.87 55.88,61.59 33.66,61.59 33.02,60.96 31.11,60.96 26.04,55.88 20.95,55.88 SIDE14.8
  Bottom 0.203: v57.15,62.87 67.31,62.87 71.12,59.05 73.66,59.05 A7.D1
N$238  (via drill 0.61)
  Top 0.203: v29.21,63.5 30.48,63.5 31.11,64.14 31.75,64.14 32.38,64.77 50.8,64.77 55.88,69.85 62.87,69.85 63.5,70.48 66.04,70.48 v76.83,59.69
  Bottom 0.203: v29.21,63.5 24.77,59.05 24.77,55.88 20.32,51.44 SIDE14.12 | v76.83,59.69 76.83,55.88 A7.E1
N$239  (via drill 0.61)
  Top 0.203: v28.57,57.15 20.32,48.9 SIDE14.14 | v46.99,59.05 v53.34,59.05
  Bottom 0.203: v28.57,57.15 28.57,58.42 29.84,59.69 43.81,59.69 45.72,57.78 v46.99,59.05 | v53.34,59.05 55.24,60.96 56.52,60.96 57.78,59.69 63.5,59.69 70.48,52.7 73.66,52.7 A7.F1
N$240  (via drill 0.61)
  Top 0.203: v29.21,62.23 29.84,62.23 31.11,63.5 31.75,63.5 32.38,64.14 50.8,64.14 55.88,69.22 62.87,69.22 63.5,69.85 65.41,69.85 78.74,56.52 78.74,50.8 77.47,49.53 A7.H1
  Bottom 0.203: v29.21,62.23 27.3,60.33 27.3,53.34 20.32,46.35 SIDE14.16
N$241  (via drill 0.61)
  Top 0.203: v37.47,52.07 45.72,60.33 55.88,60.33 v56.52,59.69
  Bottom 0.203: v37.47,52.07 34.92,49.53 29.84,49.53 20.95,40.64 SIDE14.20 | v56.52,59.69 59.05,57.15 64.77,57.15 73.66,48.26 73.66,46.35 A7.J1
N$242
  Top 0.203: SIDE14.18 20.32,43.81 19.05,45.09 19.05,59.05 19.68,59.69 27.94,59.69 31.11,62.87 31.75,62.87 32.38,63.5 50.8,63.5 53.98,66.67 60.96,66.67 63.5,69.22 65.41,69.22 75.56,59.05 75.56,44.45 76.83,43.18 A7.K1
N$243  (via drill 0.61)
  Top 0.203: v50.16,31.75 57.15,31.75 63.5,38.1 73.03,38.1 73.66,38.73 A7.L1
  Bottom 0.203: v50.16,31.75 29.84,31.75 26.04,35.56 20.95,35.56 SIDE14.24
N$244  (via drill 0.61)
  Top 0.203: v26.67,15.88 29.84,12.7 34.92,12.7 40.64,6.99 59.69,6.99 60.96,8.26 65.41,8.26 78.74,21.59 78.74,30.48 77.47,31.75 77.47,35.56 A7.M1
  Bottom 0.203: v26.67,15.88 23.5,19.05 23.5,26.67 20.32,29.84 SIDE14.28
N$245  (via drill 0.61)
  Top 0.203: v24.77,33.02 20.32,37.47 SIDE14.22 | v24.77,20.32 25.4,20.32 30.48,15.24 34.92,15.24 40.64,9.53 48.9,9.53 50.16,10.79 62.23,10.79 70.48,19.05 74.93,19.05 75.56,19.68 75.56,31.11 74.3,32.38 A7.N1
  Bottom 0.203: v24.77,20.32 v24.77,33.02
N$246  (via drill 0.61)
  Top 0.203: v27.94,19.68 20.32,27.3 SIDE14.30 | v27.94,12.06 27.94,9.53 33.66,3.81 v32.38,2.54 | v60.33,6.35 v62.87,6.35
  Bottom 0.203: v27.94,12.06 v27.94,19.68 | v32.38,2.54 56.52,2.54 v60.33,6.35 | v62.87,6.35 75.56,19.05 75.56,24.13 76.83,25.4 76.83,29.21 A7.P1
N$247  (via drill 0.61)
  Top 0.203: v66.04,13.34 62.87,10.16 50.16,10.16 48.9,8.89 40.64,8.89 34.92,14.61 30.48,14.61 26.04,19.05 22.23,19.05 19.05,22.23 19.05,31.11 20.32,32.38 SIDE14.26
  Bottom 0.203: v66.04,13.34 66.04,15.88 73.66,23.5 73.66,26.04 A7.R1
N$248  (via drill 0.61)
  Top 0.203: v24.13,17.14 26.67,17.14 30.48,13.34 34.92,13.34 40.64,7.62 48.9,7.62 50.16,8.89 65.41,8.89 76.83,20.32 76.83,22.86 A7.S1
  Bottom 0.203: v24.13,17.14 19.05,22.23 19.05,23.5 20.32,24.77 SIDE14.32
N$249
  Top 0.203: SIDE14.34 20.95,22.86 23.5,22.86 30.48,15.88 34.92,15.88 40.64,10.16 48.9,10.16 50.16,11.43 62.23,11.43 70.48,19.68 73.66,19.68 A7.T1
N$250  (via drill 0.61)
  Top 0.203: v43.18,5.08 46.35,1.91 64.14,1.91 76.83,14.61 76.83,16.51 A7.U1 | v30.48,5.08 26.04,5.08 3.81,27.3 v3.81,59.69
  Bottom 0.203: v30.48,5.08 v43.18,5.08 | v3.81,59.69 18.41,59.69 19.68,60.96 SIDE14.4
N$251  (via drill 0.61)
  Top 0.203: v6.35,26.67 v8.89,26.67 | v45.09,5.08 47.62,2.54 62.87,2.54 73.66,13.34 A7.V1
  Bottom 0.203: v6.35,26.67 6.35,56.52 6.99,57.15 20.95,57.15 21.59,57.78 21.59,61.59 20.32,62.87 SIDE14.2 | v8.89,26.67 27.94,7.62 42.55,7.62 v45.09,5.08
N$252  (via drill 0.61)
  Top 0.203: SIDE14.33 17.78,23.5 17.78,24.77 SIDE14.31 17.78,26.04 17.78,27.3 SIDE14.29 17.78,28.57 17.78,29.84 SIDE14.27 17.78,31.11 17.78,32.38 SIDE14.25 17.78,33.66 17.78,34.92 SIDE14.23 17.78,36.2 17.78,37.47 SIDE14.21 17.78,38.73 17.78,40.01 SIDE14.19 17.78,41.27 17.78,42.55 SIDE14.17 17.78,43.81 17.78,45.09 SIDE14.15 17.78,46.35 17.78,47.62 SIDE14.13 17.78,48.9 17.78,50.16 SIDE14.11 17.78,51.44 17.78,52.7 SIDE14.9 17.78,53.98 17.78,55.24 SIDE14.7 17.78,56.52 17.78,57.78 SIDE14.5 17.78,59.05 17.78,60.33 SIDE14.3 17.78,61.59 17.78,62.23 | 17.78,62.23 17.78,62.87 SIDE14.1 | v62.87,80.01 61.59,81.28 46.99,81.28 43.18,77.47 13.34,77.47 8.26,82.55 6.99,82.55 6.35,81.92 6.35,62.87 6.99,62.23 17.78,62.23
  Bottom 0.203: v62.87,80.01 74.93,80.01 78.74,76.2 78.74,67.31 77.47,66.04 77.47,62.23 A7.C1
N$253
  Top 0.203: SIDE15.33 30.48,18.41 30.48,19.68 SIDE15.31 30.48,20.95 30.48,22.23 SIDE15.29 30.48,23.5 30.48,24.77 SIDE15.27 30.48,26.04 30.48,27.3 SIDE15.25 30.48,28.57 30.48,29.84 SIDE15.23 30.48,31.11 30.48,32.38 SIDE15.21 30.48,33.66 30.48,34.92 SIDE15.19 30.48,36.2 30.48,37.47 SIDE15.17 30.48,38.73 30.48,40.01 SIDE15.15 30.48,41.27 30.48,42.55 SIDE15.13 30.48,43.81 30.48,45.09 SIDE15.11 30.48,46.35 30.48,47.62 SIDE15.9 30.48,48.9 30.48,50.16 SIDE15.7 30.48,51.44 30.48,52.7 SIDE15.5 30.48,53.98 30.48,55.24 SIDE15.3 30.48,56.52 30.48,57.78 SIDE15.1 31.11,58.42 33.66,60.96 57.78,60.96 A8.C2
N$254  (via drill 0.61)
  Top 0.203: v52.7,63.5 55.88,63.5 57.15,64.77 v58.42,64.77
  Bottom 0.203: v52.7,63.5 46.35,57.15 45.72,57.15 44.45,58.42 33.66,58.42 SIDE15.2 | v58.42,64.77 58.42,67.31 A8.A2
N$255
  Bottom 0.203: SIDE15.4 33.66,55.88 46.35,55.88 54.61,64.14 A8.B2
N$256
  Bottom 0.203: SIDE15.6 33.66,53.34 39.37,53.34 41.27,55.24 52.07,55.24 54.61,57.78 A8.D2
N$257  (via drill 0.61)
  Top 0.203: v50.16,53.98 49.53,54.61 41.27,54.61 37.47,50.8 33.66,50.8 SIDE15.8
  Bottom 0.203: v50.16,53.98 51.44,52.7 53.34,52.7 55.24,54.61 57.78,54.61 A8.E2
N$258
  Bottom 0.203: SIDE15.10 33.66,48.26 34.92,48.26 41.27,54.61 48.26,54.61 50.8,52.07 54.61,52.07 A8.F2
N$259
  Bottom 0.203: SIDE15.12 33.66,45.72 37.47,45.72 41.27,49.53 57.78,49.53 A8.H2
N$260
  Bottom 0.203: SIDE15.14 33.66,43.18 40.01,43.18 41.27,44.45 53.98,44.45 54.61,45.09 A8.J2
N$261
  Bottom 0.203: SIDE15.16 33.66,40.64 40.01,40.64 41.27,41.91 57.78,41.91 A8.K2
N$262
  Bottom 0.203: SIDE15.18 33.66,38.1 40.01,38.1 41.27,39.37 54.61,39.37 A8.L2
N$263  (via drill 0.61)
  Top 0.203: v31.75,26.67 31.75,33.66 33.02,34.92 SIDE15.20
  Bottom 0.203: v31.75,26.67 36.2,26.67 41.27,21.59 52.07,21.59 59.69,29.21 59.69,34.29 58.42,35.56 A8.M2
N$264  (via drill 0.61)
  Top 0.203: v52.7,34.29 54.61,32.38 A8.N2
  Bottom 0.203: v52.7,34.29 41.27,34.29 40.01,33.02 33.66,33.02 SIDE15.22
N$265  (via drill 0.61)
  Top 0.203: v47.62,29.21 v53.98,29.21
  Bottom 0.203: v47.62,29.21 41.27,29.21 40.01,30.48 33.66,30.48 SIDE15.24 | v53.98,29.21 57.78,29.21 A8.P2
N$266
  Bottom 0.203: SIDE15.26 33.66,27.94 37.47,27.94 41.27,24.13 52.7,24.13 54.61,26.04 A8.R2
N$267  (via drill 0.61)
  Top 0.203: v50.8,19.05 54.61,22.86 57.78,22.86 A8.S2
  Bottom 0.203: v50.8,19.05 41.27,19.05 34.92,25.4 33.66,25.4 SIDE15.28
N$268  (via drill 0.61)
  Top 0.203: v51.44,16.51 43.81,16.51 43.18,15.88 43.18,12.06 42.55,11.43 41.27,11.43 34.29,18.41 34.29,20.95 33.02,22.23 SIDE15.30
  Bottom 0.203: v51.44,16.51 54.61,19.68 A8.T2
N$269
  Top 0.203: SIDE15.34 33.66,17.78 40.64,10.79 48.9,10.79 50.16,12.06 50.8,12.06 55.24,16.51 57.78,16.51 A8.U2
N$270
  Bottom 0.203: SIDE15.32 33.66,20.32 34.92,20.32 41.27,13.97 54.61,13.97 A8.V2
N$271
  Top 0.203: SIDE16.10 45.09,43.18 48.26,43.18 66.04,60.96 66.04,66.04 64.77,67.31 A8.A1
N$272
  Top 0.203: SIDE16.6 45.09,48.26 46.99,48.26 60.96,62.23 60.96,64.14 A8.B1
N$273
  Top 0.203: SIDE16.8 45.09,45.72 45.72,45.72 57.78,57.78 60.96,57.78 A8.D1
N$274
  Top 0.203: SIDE16.12 45.09,40.64 46.99,40.64 60.96,54.61 64.14,54.61 A8.E1
N$275
  Top 0.203: SIDE16.14 45.09,38.1 58.42,51.44 60.96,51.44 A8.F1
N$276
  Top 0.203: SIDE16.16 45.09,35.56 46.99,35.56 55.24,43.81 57.15,43.81 61.59,48.26 64.14,48.26 A8.H1
N$277  (via drill 0.61)
  Top 0.203: v51.44,36.83 45.09,30.48 SIDE16.20
  Bottom 0.203: v51.44,36.83 54.61,36.83 60.96,43.18 60.96,45.09 A8.J1
N$278
  Top 0.203: SIDE16.18 45.09,33.02 53.34,41.27 63.5,41.27 64.14,41.91 A8.K1
N$279
  Bottom 0.203: SIDE16.24 45.09,25.4 58.42,38.73 60.96,38.73 A8.L1
N$280
  Top 0.203: SIDE16.28 44.45,20.95 43.18,22.23 43.18,23.5 43.81,24.13 54.61,24.13 64.14,33.66 64.14,35.56 A8.M1
N$281
  Top 0.203: SIDE16.22 45.09,27.94 53.98,27.94 58.42,32.38 60.96,32.38 A8.N1
N$282
  Top 0.203: SIDE16.30 45.09,17.78 54.61,17.78 64.14,27.3 64.14,29.21 A8.P1
N$283
  Top 0.203: SIDE16.26 45.09,22.86 53.98,22.86 57.15,26.04 60.96,26.04 A8.R1
N$284
  Top 0.203: SIDE16.32 45.09,15.24 52.7,15.24 60.33,22.86 64.14,22.86 A8.S1
N$285
  Top 0.203: SIDE16.34 45.09,12.7 50.8,12.7 57.78,19.68 60.96,19.68 A8.T1
N$286
  Bottom 0.203: A8.U1 64.14,17.78 64.14,21.59 62.87,22.86 62.87,46.35 59.05,50.16 44.45,50.16 SIDE16.4
N$287
  Bottom 0.203: A8.V1 61.59,14.61 64.14,14.61 66.04,16.51 66.04,43.81 59.05,50.8 47.62,50.8 45.09,53.34 SIDE16.2
N$288
  Top 0.203: SIDE16.17 41.91,33.66 41.91,34.92 SIDE16.15 | SIDE16.11 41.91,40.01 41.91,38.73 SIDE16.13 | SIDE16.9 41.91,42.55 41.91,41.27 SIDE16.11 | SIDE16.33 41.91,13.34 41.91,14.61 SIDE16.31 41.91,15.88 41.91,17.14 SIDE16.29 41.91,18.41 41.91,19.68 SIDE16.27 41.91,20.95 41.91,22.23 SIDE16.25 41.91,23.5 41.91,24.77 SIDE16.23 41.91,26.04 41.91,27.3 SIDE16.21 41.91,28.57 41.91,29.84 SIDE16.19 41.27,30.48 34.92,36.83 34.92,37.47 38.1,40.64 41.27,40.64 SIDE16.11 | 41.91,46.99 41.91,47.62 SIDE16.5 41.91,48.9 41.91,50.16 SIDE16.3 41.91,51.44 41.91,52.7 SIDE16.1 | 41.91,46.99 41.91,46.35 SIDE16.7 | 41.91,46.99 46.35,46.99 59.05,59.69 62.87,59.69 64.14,60.96 A8.C1
  Bottom 0.203: SIDE16.13 41.91,37.47 41.91,36.2 SIDE16.15 | SIDE16.9 41.27,43.18 40.01,41.91 32.38,41.91 31.75,42.55 31.75,43.81 32.38,44.45 40.01,44.45 41.27,45.72 SIDE16.7