# EAGLE board tester (EAGLE 4.11), part 2 of 2
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
PIA-B7  (via drill 0.61) (continued)
  Bottom 0.254: v125.73,100.95 123.19,103.49 106.68,103.49 104.14,100.95 67.95,100.95 67.95,99.05 69.22,97.78 81.28,97.78 81.28,87.62 82.55,86.35 86.36,86.35 88.27,84.44 CORE-IO.20 | v146.05,52.69 140.97,47.61 v135.89,47.61
R1  (via drill 0.61)
  Top 0.254: 102.87,56.5 102.87,65.39 101.6,66.66 L1-V1.5 | 102.87,56.5 100.33,53.96 100.33,51.42 99.69,50.78 99.69,31.73 JP3.14 | v83.82,21.57 83.82,8.88 IN1-2.12 | v130.81,48.24 134.62,44.44 SIDE1.26 | 102.87,56.5 v102.87,50.78
  Bottom 0.254: v83.82,21.57 86.36,24.11 99.06,24.11 99.06,30.46 99.69,30.46 JP3.14 | v130.81,48.24 129.54,49.52 107.95,49.52 106.68,50.78 v102.87,50.78
R2  (via drill 0.61)
  Top 0.254: 100.33,36.18 100.33,34.27 101.6,33.01 101.6,28.56 100.33,27.29 JP4.14 | 100.33,36.18 100.33,50.15 101.6,51.42 L2-V2.5 | v133.35,14.59 133.35,12.05 121.28,12.05 114.94,5.7 IN3-4.15 | v104.78,36.18 100.33,36.18 | v128.27,36.81 128.27,33.64 133.35,28.56 133.35,20.3 134.62,19.04 SIDE2.26
  Bottom 0.254: v133.35,14.59 133.35,18.4 133.99,18.4 SIDE2.26 | v104.78,36.18 105.41,36.81 v128.27,36.81
S1  (via drill 0.61)
  Top 0.254: v104.14,64.12 104.14,66.66 L1-V1.6 | v64.77,23.48 v64.77,34.27 | v133.35,30.46 v133.35,42.53 | v104.14,27.92 102.87,29.2 102.87,29.83 JP3.15
  Bottom 0.254: v104.14,64.12 102.23,62.21 93.34,62.21 92.71,61.58 92.71,58.41 85.72,58.41 83.82,56.5 70.48,56.5 69.85,57.13 66.04,57.13 62.23,53.32 62.23,34.91 64.77,34.91 | 64.77,34.91 80.65,34.91 81.92,33.64 101.6,33.64 102.87,32.37 JP3.15 | v64.77,23.48 72.39,15.86 78.11,15.86 85.72,8.24 IN1-2.14 | v64.77,34.27 64.77,34.91 | v133.35,42.53 140.34,42.53 141.61,43.8 SIDE1.32 | v133.35,30.46 132.72,29.83 130.81,29.83 129.54,31.1 122.56,31.1 121.28,29.83 112.4,29.83 111.12,28.56 104.78,28.56 v104.14,27.92
S2  (via drill 0.61)
  Top 0.254: v100.33,11.41 100.33,22.21 102.87,24.75 JP4.15 | v139.7,53.32 143.51,49.52 143.51,38.09 140.97,35.55 140.97,22.84 137.16,19.04 SIDE2.28 136.53,18.4 136.53,17.13 128.91,17.13 128.27,16.49 128.27,15.22 v127,13.95
  Bottom 0.254: v100.33,11.41 102.23,9.51 104.78,9.51 106.05,8.24 IN3-4.10 107.31,8.24 113.03,13.95 v127,13.95 | v139.7,53.32 125.09,53.32 123.83,54.59 106.05,54.59 104.78,53.32 L2-V2.6
T1  (via drill 0.61)
  Top 0.254: v107.31,72.38 107.31,69.84 106.68,69.2 L1-V1.7 | v132.72,70.47 133.99,69.2 133.99,60.95 134.62,60.31 141.61,60.31 141.61,52.69 144.78,49.52 144.78,44.44 SIDE1.34
  Bottom 0.254: v107.31,72.38 108.59,73.65 118.75,73.65 121.92,70.47 v132.72,70.47 | JP3.16 105.41,32.37 106.05,33.01 137.8,33.01 138.43,33.64 138.43,39.99 145.42,39.99 146.05,40.62 146.05,43.16 144.78,43.16 SIDE1.34
T2  (via drill 0.61)
  Top 0.254: v114.94,50.78 118.11,47.61 118.11,46.34 119.38,45.07 120.65,45.07 120.65,32.37 118.75,30.46 v118.75,28.56 | v106.68,10.14 108.59,8.24 IN3-4.12 | v101.6,12.68 101.6,20.94 105.41,24.75 JP4.16 | v141.61,22.21 141.61,20.94 139.7,19.04 SIDE2.30
  Bottom 0.254: v114.94,50.78 108.59,50.78 107.31,52.05 L2-V2.7 | 118.11,27.92 v118.75,28.56 | 118.11,27.92 106.05,27.92 105.41,27.29 JP4.16 | v106.68,10.14 104.14,12.68 v101.6,12.68 | v141.61,22.21 141.61,24.75 121.28,24.75 118.11,27.92
U1  (via drill 0.61)
  Top 0.254: L1-V1.8 109.86,68.57 111.12,69.84 113.03,69.84 113.03,59.04 107.95,53.96 v107.95,47.61 107.95,45.7 106.68,44.44 SIDE1.4 | v88.9,46.34 88.9,8.88 IN1-2.16 | v107.95,39.99 107.95,32.37 JP3.17
  Bottom 0.254: v88.9,46.34 90.17,47.61 v107.95,47.61 | v107.95,39.99 107.95,43.16 106.68,43.16 SIDE1.4
U2  (via drill 0.61)
  Top 0.254: v110.49,42.53 110.49,50.15 109.22,51.42 L2-V2.8 | v110.49,39.99 109.22,38.72 109.22,28.56 107.95,27.29 JP4.17 | v142.88,20.94 144.78,19.04 SIDE2.34
  Bottom 0.254: v110.49,39.99 v110.49,42.53 | IN3-4.14 112.4,8.24 116.2,12.05 140.97,12.05 143.51,14.59 143.51,18.4 144.14,18.4 SIDE2.34 | v142.88,20.94 121.92,20.94 121.28,20.94 118.75,23.48 118.75,24.11 108.59,24.11 107.95,24.75 JP4.17
V1  (via drill 0.61)
  Top 0.254: L1-V1.9 111.76,66.66 110.49,65.39 110.49,59.04 105.41,53.96 105.41,45.7 104.14,44.44 SIDE1.2 | v94.62,11.41 94.62,6.97 93.98,6.33 93.98,3.16 95.25,3.16 96.52,4.43 96.52,5.07 IN3-4.1 | v99.06,13.32 99.06,27.92 99.69,28.56 v100.33,28.56 | v111.76,39.35 110.49,38.09 110.49,32.37 JP3.18
  Bottom 0.254: v94.62,11.41 96.52,13.32 v99.06,13.32 | v100.33,28.56 100.97,29.2 109.86,29.2 110.49,29.83 JP3.18 | v111.76,39.35 111.12,38.72 105.41,38.72 105.41,41.89 104.14,43.16 SIDE1.2
V2  (via drill 0.61)
  Top 0.254: v113.03,42.53 113.03,50.15 111.76,51.42 L2-V2.9 | v113.03,39.35 111.76,38.09 111.76,28.56 110.49,27.29 JP4.18 110.49,24.75 113.03,22.21 113.03,19.67 115.57,19.67 115.57,12.68 | 115.57,12.68 115.57,10.14 114.3,8.88 IN3-4.16 | v130.18,13.32 127.64,13.32 127,12.68 115.57,12.68
  Bottom 0.254: v113.03,39.35 v113.03,42.53 | v130.18,13.32 140.97,13.32 140.97,16.49 142.24,17.77 SIDE2.32
VCC  (via drill 0.61)
  Top 0.508: v74.93,57.77 74.93,80 76.2,81.27 CORE-IO.9 76.84,81.9 78.74,83.81 CORE-IO.12 | IC4.14 114.94,115.56 114.3,116.19 114.3,116.83 BYP4.1 114.3,118.1 114.94,118.73 v114.94,120 | IC3.14 102.23,115.56 101.6,116.19 101.6,116.83 BYP3.1 | IC2.14 89.53,115.56 88.9,116.19 88.9,116.83 BYP2.1 | IC1.14 76.84,115.56 76.2,116.19 76.2,116.83 BYP1.1 | v67.31,85.71 67.31,88.25 JP2.1 | IC5.14 127.64,115.56 127,116.19 127,116.83 BYP5.1 | IC6.14 140.34,115.56 139.7,116.19 139.7,116.83 BYP6.1 | BYP7.1 129.54,76.19 130.18,75.55 130.18,74.92 IC7.14 | BYP8.1 142.24,76.19 142.88,75.55 142.88,74.92 IC8.14 143.51,74.92 143.51,89.52 142.24,90.79 POWER.2 | v144.78,29.2 147.32,31.73 v147.32,88.25
  Bottom 0.508: v74.93,57.77 68.58,57.77 66.67,59.68 A2-K2.18 | 74.93,113.65 64.14,113.65 64.14,93.97 67.31,90.79 JP2.1 | 74.93,113.65 76.2,114.92 IC1.14 | 87.63,113.65 88.9,114.92 IC2.14 | 74.93,113.65 87.63,113.65 | 100.33,113.65 101.6,114.92 IC3.14 | 87.63,113.65 100.33,113.65 | 100.33,113.65 113.03,113.65 114.3,114.92 IC4.14 | v67.31,85.71 76.84,85.71 78.11,84.44 CORE-IO.12 | 137.8,116.19 130.81,116.19 129.54,114.92 IC5.14 | 137.8,116.19 139.06,117.46 BYP6.1 | IC9.14 137.8,27.92 138.43,28.56 139.06,28.56 BYP9.1 140.34,28.56 140.97,29.2 v144.78,29.2 | BYP10.1 120.02,92.06 121.92,90.16 139.06,90.16 139.7,89.52 140.97,89.52 142.24,90.79 POWER.2 | IC7.14 132.08,74.28 133.35,75.55 140.34,75.55 141.61,76.82 BYP8.1 | v147.32,88.25 144.14,91.43 142.88,91.43 POWER.2 | IC6.14 141.61,114.29 142.88,113.02 142.88,93.33 142.24,93.33 POWER.2 | v114.94,120 133.99,120 137.8,116.19

## Text on the board
Top: Component Side | PA8PDP/VRS
Bottom: Solder Side
tValues: - | + | + | - | FlipChip Tester - Rev.1